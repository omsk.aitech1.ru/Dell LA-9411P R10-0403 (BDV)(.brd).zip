# Allegro board LA-9411P R10-0403.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
CLK_MSE: length 171.9
  TOP w0.102: R851.2 280.28,114.85 280.9,114.85 v2(281.33,114.42) 281.57,114.66 U51.A39
  IN2 w0.127: v2(278.87,173.88) 278.87,174.96 275.32,178.51 254.1,178.51 253.6,178.02 246.05,178.02 244.81,179.25 238.2,179.25 235.35,176.4 225.06,176.4 224.09,177.38 212.7,177.38 212.42,177.1 205.77,177.1 204.71,176.03 203.82,176.03 203.31,175.53 200.77,175.53 200.67,175.63 199.33,175.63 198.06,174.36 197,174.36 196.36,173.72 193.68,173.72 193.32,174.09 193.32,174.7 v2(193.71,175.09)
  IN4 w0.102: v2(281.33,114.42) 281.71,114.8 281.71,115.89 281.44,116.17 279.95,116.17 279.69,116.43 279.69,120.98 277.96,122.71 277.96,124.27 277.83,124.4 277.83,125.95 277.4,126.38 277.4,130.72 277.41,130.73 277.41,131.93 277.4,131.94 277.4,134.08 277.95,134.63 277.95,139.75 278.11,139.91 278.11,146.27 277.39,146.99 277.39,164.81 278.62,166.04 278.62,170.28 278.39,170.51 278.39,173.41 278.7,173.71 278.71,173.71 v2(278.87,173.88)
  BOTTOM w0.102: JDOCK1.71 185.75,179.84 185.44,179.53 185.44,178.32 186.01,177.75 ; v2(193.71,175.09) 193.12,175.69 192.04,175.69 191.49,176.24 186.94,176.24 186.47,176.71 186.47,177.29 186.01,177.75 ; 186.01,177.75 v1(186.01,177.76)
CLK_PCH_14M: length 7.3
  BOTTOM w0.089: UH1.F45 220.1,74.15 220.46,73.8 221.96,73.8
  BOTTOM w0.102: 221.96,73.8 222.52,73.8 RH146.1 223.41,75.41 224.16,76.16 224.86,76.16 v1(225.04,75.98)
CLK_PCI_5048: length 87.2
  TOP w0.089: 221.93,73.98 221.19,73.98 RH158.2
  TOP w0.102: 221.93,73.98 222.08,73.98 CH15.1 223.32,72.74 224.49,72.74 227.13,70.09 227.58,70.09 230.36,67.31 230.36,54.56 231.36,53.56 239,53.56 241.84,56.4 242.55,56.4 244.05,57.9 v1(244.05,58.81) 244.05,59.21 249.16,64.31 250.98,64.31 250.98,64.31 251.48,64.31 251.67,64.5 252.73,65.56 259.4,65.56 259.66,65.81 262.39,65.81 263.47,66.89 266.81,66.89 267.54,66.17 271.17,66.17 v2(271.56,65.77) ; U46.A28 266.45,58.1 266.45,58.53 266.33,58.65 266.33,59.58 265.52,60.38 R795.1 264.99,61.32 264.99,62.9 v2(265.63,63.54)
  IN2 w0.127: v2(265.63,63.54) 265.63,64.63 267.06,66.07 271.27,66.07 v2(271.56,65.77)
CLK_PCI_DOCK: length 273.6
  TOP w0.089: 222.89,72.3 222.61,72.58 222.61,72.86 222.04,73.43 RH162.2
  TOP w0.102: 222.89,72.3 223.07,72.12 224.24,72.12 v2(225.98,70.38) 225.98,70.36 226.86,69.48 227.33,69.48 229.75,67.06 v1(229.75,57.56) 229.75,54.27 231.07,52.95 239.25,52.95 242.09,55.79 242.6,55.79 242.8,55.79 244.66,57.65 244.66,58.33 246.26,59.93 246.26,59.94 250,63.68 251.71,63.68 251.92,63.89 252.81,64.78 256.55,64.78 256.8,64.53 259.9,64.53 260.19,64.82 262.26,64.82 263.72,66.28 266.56,66.28 267.28,65.56 268.82,65.56 v2(268.91,65.47)
  IN1 w0.102: v2(200.25,173.14) 199.88,173.51 199.88,177.18 198.86,178.19 v2(198.86,179.37)
  IN2 w0.127: v2(200.25,173.14) 200.8,173.68 204.02,173.68 204.52,174.18 205.57,174.18 206.39,175.01 213.75,175.01 213.89,175.15 223.88,175.15 224.34,174.69 224.43,174.69 224.52,174.6 237.81,174.6 238.67,175.46 246.94,175.46 247.62,174.79 255.4,174.79 255.63,175.02 260.26,175.02 260.71,174.57 261.1,174.57 261.91,173.76 266.17,173.76 268.17,171.77 274.93,171.77 v2(275.36,171.34)
  IN4 w0.102: v2(275.36,171.34) 274.79,170.76 274.79,170.01 274.75,169.97 274.75,168.81 275.43,168.12 275.43,165.18 273.43,163.17 273.43,151.96 273.85,151.55 273.85,148.7 275.74,146.81 275.74,146.31 276.46,145.58 276.46,140.6 276.3,140.43 276.3,135.31 275.27,134.29 275.27,121.67 276,120.93 276,119.6 275.47,119.07 275.47,111.71 274.59,110.83 274.59,108.65 275.24,108 275.24,107.58 274.46,106.79 274.46,97.08 271.62,94.24 271.62,93.3 269.63,91.32 269.63,75.89 269.81,75.72 269.81,73.53 269.81,73.53 269.81,72.53 269.97,72.36 269.97,70.54 269.81,70.37 269.81,67.89 268.84,66.93 268.84,65.53 v2(268.91,65.47)
  BOTTOM w0.102: R756.1 199.5,178.33 198.86,178.97 v2(198.86,179.37) 198.86,179.59 199.25,179.98 JDOCK1.121 ; v2(225.98,70.38) 225.98,72.21 CH76.1
CLK_PCI_LOOPBACK: length 167.8
  IN2 w0.127: v2(216.35,61.05) 216.69,61.05 216.81,61.18 216.81,61.3 213.97,64.14 213.97,64.32 214.28,64.63 214.46,64.63 215.57,63.53 215.74,63.53 216.3,62.97 216.57,62.97 217.15,63.55 217.15,63.97 215.58,65.54 214.3,65.54 212.22,63.47 212.22,62.76 212.54,62.43 212.72,62.43 213.07,62.78 213.25,62.78 213.52,62.51 213.52,62.33 213.17,61.98 213.17,61.8 213.44,61.53 213.62,61.53 214.3,62.21 214.48,62.21 214.75,61.94 214.75,61.76 214.07,61.08 214.07,60.9 214.34,60.63 214.52,60.63 215.28,61.4 215.46,61.4 215.73,61.13 215.73,60.95 214.97,60.19 214.97,60.01 215.24,59.74 215.42,59.74 215.77,60.08 215.95,60.08 216.22,59.81 216.22,59.64 215.81,59.23 215.81,59.05 216.08,58.78 216.26,58.78 217.07,59.59 217.25,59.59 217.52,59.32 217.52,59.14 216.77,58.39 216.77,58.21 217.23,57.75 217.23,56.9 217.1,56.77 216.67,56.77 216.54,56.64 216.54,54.53 216.67,54.41 217.43,54.41 217.56,54.53 217.56,56.46 217.69,56.59 219.4,56.59 219.53,56.72 219.53,57.09 219.4,57.21 218.75,57.21 218.63,57.34 218.63,57.71 218.75,57.84 219.4,57.84 219.53,57.96 219.53,59.05 219.65,59.18 220.37,59.18 220.49,59.05 220.49,57.52 220.62,57.39 221.45,57.39 221.57,57.52 221.57,61.35 221.45,61.48 218.17,61.48 218.04,61.61 218.04,62.1 218.17,62.23 222.49,62.23 222.61,62.1 222.61,60.01 222.74,59.88 223.68,59.88 224.26,60.46 230.87,60.46 231,60.34 231,59.83 230.87,59.7 224.77,59.7 224.65,59.58 224.65,59.07 224.77,58.94 230.87,58.94 231,58.81 231,58.01 230.87,57.89 222.42,57.89 222.19,57.65 222.19,56.76 222.49,56.46 222.51,56.46 222.59,56.39 223.11,56.39 v2(223.38,56.65)
  BOTTOM w0.089: UH1.D17 212.12,64.78 212.12,64.38 212.31,64.19 212.58,64.19 213.07,63.7 213.07,63.02 213.34,62.74
  BOTTOM w0.102: 213.34,62.74 213.43,62.65 214.09,62.65 215.61,61.14 216.27,61.14 v2(216.35,61.05) ; RH164.2 224.83,67.77 225.22,67.77 CH77.1 225.97,67.77 226.3,67.45 v1(227.25,67.45) 228.46,67.45 228.58,67.32 228.58,66.69 228.46,66.56 225.41,66.56 225.28,66.43 225.28,66.05 225.41,65.93 228.46,65.93 228.58,65.8 228.58,65.42 228.46,65.29 226.42,65.29 226.3,65.16 226.3,64.66 226.42,64.53 227.57,64.53 227.69,64.4 227.69,64.02 227.57,63.89 225.92,63.89 225.79,63.77 225.79,63.39 225.92,63.26 228.33,63.26 228.46,63.13 228.46,62.75 228.33,62.62 226.55,62.62 226.42,62.5 226.42,62.12 226.55,61.99 228.33,61.99 228.46,61.86 228.46,61.35 228.33,61.23 225.41,61.23 225.28,61.1 225.28,60.72 225.41,60.59 228.33,60.59 228.46,60.46 228.46,60.08 228.33,59.96 223.88,59.96 223.76,59.83 223.76,59.45 223.88,59.32 228.33,59.32 228.46,59.2 228.46,58.81 228.33,58.69 224.52,58.69 224.39,58.56 224.39,58.18 224.52,58.05 228.33,58.05 228.46,57.92 228.46,57.54 228.33,57.42 223.5,57.42 223.38,57.29 v2(223.38,56.65)
CLK_PCI_MEC: length 150.6
  TOP w0.089: RH160.2 220.96,75.2
  TOP w0.102: v2(281.29,99.89) 281.29,99.4 281.87,98.82 v1(281.87,98.29) 281.87,97.71 279.5,95.34 279.5,68.66 277.62,66.78 267.79,66.78 267.04,67.53 263.24,67.53 262.14,66.42 259.2,66.42 258.94,66.17 252.47,66.17 252.28,65.98 251.23,64.92 248.9,64.92 243.44,59.46 243.44,58.24 242.21,57.01 241.59,57.01 238.74,54.17 231.63,54.17 231.05,54.75 231.05,67.17 231.06,67.18 231.06,67.47 227.83,70.7 227.39,70.7 224.63,73.45 224.63,73.47 222.6,75.5 CH16.1 221.6,75.2 220.96,75.2 ; R885.1 285.18,121.52 285.18,120.9 v2(285.19,120.9) 284.75,120.46 284.75,120.17 285.22,119.71 U51.A29
  IN4 w0.102: v2(281.29,99.89) 282.91,99.89 286.32,103.29 286.63,103.29 287.69,104.35 287.69,104.66 289.75,106.72 289.75,108.93 290.28,109.46 291.39,109.46 291.88,109.95 291.88,114.96 291.47,115.37 290.56,115.37 290.15,115.77 290.15,117.97 289.39,118.73 289.1,118.73 288.14,119.7 287.19,119.7 286.77,120.12 286.77,120.95 286.36,121.37 285.85,121.37 285.37,120.9 v2(285.19,120.9)
CLK_PCI_TPM: length 167.8
  TOP w0.102: RE5.1 v2(295,129.2) 296.2,130.4 U39.21
  IN2 w0.127: v2(266.42,129.03) 266.87,129.48 270.91,129.48 272.79,127.6 274.04,127.6 275.55,129.11 282.49,129.11 282.83,128.77 283.94,128.77 284.57,129.4 285.95,129.4 286.35,129.81 290.32,129.81 291.59,128.53 294.34,128.53 v2(295,129.2)
  IN4 w0.102: v2(266.42,129.03) 265.65,128.26 265.65,121.54 265.88,121.31 265.88,113.55 265.51,113.18 265.51,109.64 264.76,108.89 264.76,108.13 264.62,107.99 264.62,105.15 264.62,104.04 264,103.41 264,101.83 260.42,98.26 260.42,97.76 255.92,93.26 255.85,93.26 255.61,93.02 255.61,93.02 255.61,92.95 255.48,92.82 255.48,88.63 253.6,86.75 253.6,84.47 254.3,83.77 254.3,62.41 253.68,61.79 253.68,57.89 254.05,57.52 254.05,52.68 254.24,52.49 254.24,49.82 253.12,48.7 248.8,48.7 246.6,50.9 244.78,50.9 244.28,51.4 243.49,51.4 243.09,51.8 242.07,52.82 241.88,52.82 240.57,54.13 231.68,54.13 230.2,55.61 227.39,55.61 227.19,55.82 v2(227.19,68.97)
  BOTTOM w0.102: v2(227.19,68.97) 226.68,68.97 v1(226.25,69.4) CH78.1 RH155.1
CLK_PCIE_EMB: length 100.8
  TOP w0.102: v2(248.36,68.89) 248.36,69.63 248.16,69.82 246.45,69.82 245.51,68.88 231.88,68.88 231.35,69.41 231.35,69.82 228.9,72.28 228.06,72.28 226.55,73.79 226.55,75.4 226.93,75.78 226.93,79.92 221.38,85.47 219.29,85.47 218.03,84.21 215.51,84.21 215.34,84.38 215.14,84.38 v2(215.12,84.37)
  BOTTOM w0.089: 213.01,80.87 212.98,80.87 212.72,80.61 212.72,80.34 212.54,80.16 212.13,80.16 UH1.AJ42
  BOTTOM w0.102: v2(248.36,68.89) 248.36,67.97 248.78,67.55 248.78,60.71 246.58,58.51 246.58,55.2 245.88,54.5 244.12,54.5 243.86,54.24 243.86,52.81 242.12,51.07 242.12,49.26 241.66,48.8 241.66,47.1 240.7,46.14 240.7,41.19 239.33,39.82 239.33,33.59 238.88,33.14 238.88,31.63 238.64,31.38 237.49,31.38 236.57,30.45 236.19,30.45 235.55,29.82 235.55,29.26 235.77,29.04 235.77,28.75 JSATA2.15 ; 213.01,80.87 213.3,81.17 213.3,82.33 214.05,83.08 214.05,83.46 214.96,84.37 v2(215.12,84.37)
CLK_PCIE_EMB#: length 100.8
  TOP w0.102: v2(248.94,68.89) 248.61,69.22 248.61,69.74 248.27,70.08 246.35,70.08 245.41,69.14 231.98,69.14 231.61,69.52 231.61,69.93 229,72.53 228.17,72.53 226.8,73.89 226.8,75.29 227.19,75.68 227.19,80.02 221.48,85.72 219.18,85.72 217.93,84.47 215.62,84.47 215.31,84.77 214.84,84.77 v2(214.77,84.85)
  BOTTOM w0.089: 212.92,81.18 212.92,81.1 212.48,80.66 212.48,80.61 212.41,80.53 UH1.AJ44
  BOTTOM w0.102: v2(214.77,84.85) 214.71,84.8 214.71,84.48 213.8,83.56 213.8,83.18 213.05,82.44 213.05,81.31 212.92,81.18 ; JSATA2.16 235.97,29.2 235.8,29.37 235.8,29.71 236.29,30.2 236.67,30.2 237.6,31.13 238.74,31.13 239.14,31.52 239.14,33.03 239.59,33.48 239.59,39.72 240.96,41.08 240.96,46.03 241.92,46.99 241.92,48.7 242.38,49.15 242.38,50.96 244.12,52.7 244.12,54.14 244.22,54.24 245.98,54.24 246.83,55.09 246.83,55.3 246.83,55.3 246.83,58.41 249.03,60.6 249.03,67.65 248.61,68.07 248.61,68.56 v2(248.94,68.89)
CLK_PCIE_EXP: length 139.8
  TOP w0.102: v2(286.84,30.1) 287.01,29.93 288.76,29.93 288.88,30.06 JEXP1.11
  IN4 w0.114: v2(250.01,59.58) 250.16,59.72 250.16,60.21 249.68,60.68 247.46,60.68 246.71,61.44 246.71,70.55 243.15,74.11 243.15,75.76 240.25,78.66 236.14,78.66 234.95,79.86 226.17,79.86 220.91,85.12 219.98,85.12 219.07,86.02 219.07,88.26 218.84,88.49 218.66,88.49 218.44,88.27 v2(218.44,87.93)
  BOTTOM w0.089: 215.07,80.88 214.68,80.5 214.14,80.5 213.6,79.96 UH1.AF45
  BOTTOM w0.102: 215.07,80.88 215.29,81.1 215.29,81.59 215.91,82.21 215.91,83.55 216,83.64 216,84 217.37,85.37 217.37,87.33 217.97,87.93 v2(218.44,87.93) ; v2(250.01,59.58) 250.16,59.42 250.16,58 249.82,57.66 249.82,54.38 250.8,53.39 251.13,53.39 251.61,52.91 252.38,52.91 252.99,52.29 252.99,51.16 254.87,49.28 254.87,47.72 254.5,47.35 254.5,40.81 255.67,39.65 255.67,38.87 255.05,38.24 255.05,37.62 254.4,36.97 254.4,35.84 253.97,35.41 253.97,29.45 259.58,23.84 280.66,23.84 280.87,23.84 285.62,28.59 286.9,28.59 287.11,28.59 287.64,29.12 287.64,29.45 287.64,29.66 287.36,29.93 287.15,29.93 287.01,29.93 v2(286.84,30.1)
CLK_PCIE_EXP#: length 140
  TOP w0.102: JEXP1.9 288.88,29.56 288.76,29.68 287.01,29.68 v2(286.84,29.51)
  IN4 w0.114: v2(218.03,88.34) 218.1,88.34 218.54,88.79 218.96,88.79 219.36,88.38 219.36,86.14 220.1,85.41 221.03,85.41 226.29,80.15 235.07,80.15 236.26,78.96 240.37,78.96 243.45,75.88 243.45,74.23 247,70.68 247,61.56 247.58,60.97 249.8,60.97 250.45,60.33 250.45,59.72 v2(250.59,59.58)
  BOTTOM w0.089: UH1.AF43 212.97,79.43 213.29,79.75 213.29,80.03 214.02,80.76 214.59,80.76 214.96,81.14
  BOTTOM w0.102: v2(286.84,29.51) 287.01,29.68 287.26,29.68 287.38,29.55 287.38,29.22 287,28.84 285.51,28.84 280.76,24.09 280.66,24.09 259.69,24.09 254.22,29.56 254.22,35.3 254.66,35.74 254.66,36.87 255.3,37.52 255.3,38.14 255.93,38.76 255.93,39.75 254.76,40.92 254.76,47.24 255.13,47.61 255.13,49.39 253.25,51.27 253.25,52.4 252.48,53.16 251.71,53.16 251.23,53.64 250.91,53.64 250.07,54.48 250.07,57.56 250.41,57.9 250.41,59.4 v2(250.59,59.58) ; v2(218.03,88.34) 217.11,87.43 217.11,85.48 215.74,84.11 215.74,83.74 215.65,83.66 215.65,82.32 215.03,81.7 215.03,81.2 214.96,81.14
CLK_PCIE_LAN: length 221.7
  IN4 w0.114: v2(319.67,198.11) 320.18,198.11 320.44,197.84 320.44,197.12 320.99,196.57 320.99,195.52 322.08,194.42 322.08,193.12 322.73,192.47 323.78,191.43 323.78,189.84 321.84,187.9 321.84,185.39 318.93,182.49 316.42,182.49 316.1,182.16 297.85,182.16 297.09,182.92 297.09,183.11 293.08,187.12 279.52,187.12 279.04,186.64 275.95,186.64 273.33,184.01 269.93,184.01 269.36,183.44 266.39,183.44 265.46,182.51 263,182.51 261.86,181.37 261.86,180.37 260.47,178.98 260.47,173.79 260.18,173.5 260.18,169.08 260.66,168.6 260.66,166.4 261.06,166 261.06,154.59 261.38,154.27 261.38,149.49 261.9,148.97 261.9,145.18 260.6,143.88 260.6,135.72 260.23,135.36 260.23,133.49 260.66,133.06 260.66,124.83 260.27,124.43 260.27,112.32 259.16,111.21 259.16,106.64 258.67,106.15 258.67,103.79 257.85,102.98 257.52,102.98 249.75,95.21 249.75,94.17 243.09,87.5 241.91,87.5 241.38,88.02 238.53,88.02 237.98,87.46 230.36,87.46 230.06,87.77 229.59,87.77 229.34,87.53 229.33,87.53 v2(229.18,87.38)
  BOTTOM w0.089: UH1.AA42 214.42,77.85 214.82,77.85 215.01,78.04 215.01,78.3 215.24,78.53 217.04,78.53 217.05,78.52 217.26,78.52 217.31,78.58 217.32,78.58 217.33,78.59
  BOTTOM w0.102: v2(229.18,87.38) 229.19,87.38 228.69,86.88 228.31,86.88 227.72,86.28 227.72,85.43 226.87,84.58 222.4,84.58 221.47,83.65 221.29,83.65 219.73,82.1 219.73,81.08 218.8,80.15 218.8,79.87 217.93,78.99 217.74,78.99 217.33,78.59 ; U31.44 319.34,198.42 319.65,198.11 v2(319.67,198.11)
CLK_PCIE_LAN#: length 221.6
  IN4 w0.114: v2(319.63,197.52) 319.67,197.52 319.96,197.81 320.05,197.81 320.15,197.72 320.15,197 320.7,196.45 320.7,195.4 321.79,194.3 321.79,193 322.44,192.35 322.44,192.35 323.48,191.31 323.48,189.96 321.55,188.02 321.55,185.52 318.81,182.78 316.3,182.78 315.98,182.45 297.97,182.45 297.38,183.04 297.38,183.24 293.2,187.41 279.4,187.41 278.92,186.93 275.83,186.93 273.2,184.3 269.81,184.3 269.24,183.73 266.26,183.73 265.34,182.8 262.88,182.8 261.56,181.49 261.56,180.49 260.17,179.1 260.17,173.91 259.89,173.62 259.89,168.96 260.37,168.48 260.37,166.27 260.77,165.88 260.77,154.47 261.08,154.15 261.08,149.37 261.6,148.85 261.6,145.3 260.31,144.01 260.31,135.85 259.94,135.48 259.94,133.37 260.37,132.94 260.37,124.95 259.98,124.56 259.98,112.44 258.87,111.33 258.87,106.76 258.38,106.27 258.38,103.91 257.73,103.27 257.4,103.27 249.46,95.33 249.46,94.29 242.97,87.79 242.03,87.79 241.51,88.32 238.41,88.32 237.85,87.76 230.48,87.76 230.18,88.06 229.32,88.06 229.01,87.76 228.82,87.76 228.67,87.91 v2(228.67,88.04)
  BOTTOM w0.089: UH1.AA44 214.64,78.24 214.64,78.37 214.73,78.46 214.89,78.46 215.04,78.61 215.2,78.77 217.15,78.77
  BOTTOM w0.102: v2(319.63,197.52) 319.13,198.02 U31.45 ; 217.15,78.77 217.63,79.25 217.82,79.25 218.55,79.98 218.55,80.25 219.48,81.18 219.48,82.2 221.18,83.91 221.37,83.91 222.29,84.83 226.76,84.83 227.47,85.54 227.47,86.39 228.21,87.13 228.59,87.13 228.77,87.32 228.77,87.55 229.04,87.82 229.04,88.04 228.94,88.14 228.77,88.14 v2(228.67,88.04)
CLK_PCIE_MINI1: length 263.3
  IN1 w0.114: v2(335.28,209.6) 334.98,209.31 334.67,209.31 334.37,209.01 334.37,208.29 335.81,206.86 335.81,205.64 335.64,205.47 335.64,194.81 334.42,193.59 334.42,191.07 332.67,189.32 332.67,182.51 328.57,178.41 327.25,178.41 326.59,179.07 324.15,179.07 323.59,178.51 322.59,178.51 320.16,176.07 311.89,176.07 310.46,177.51 310.46,179.15 311.02,179.7 311.02,181.11 310.37,181.76 307.8,181.76 307.2,182.36 303.79,182.36 300.29,178.85 280.97,178.85 280.27,178.16 278.3,178.16 277.9,177.75 276.89,177.75 276.45,178.19 272.13,178.19 269.41,175.48 269.41,174.58 268.94,174.11 268.94,170.02 268.02,169.09 268.02,166.53 269.01,165.54 269.01,155.12 269.13,154.99 269.13,150.13 268.36,149.36 268.36,145.56 270.99,142.93 270.99,141.45 272.09,140.34 272.09,137.85 271.29,137.05 271.29,133.37 271.04,133.12 271.04,130.14 271.96,129.22 271.96,120.56 271.46,120.05 271.46,102.75 272.32,101.89 272.32,97.5 271.47,96.66 271,96.66 269.82,95.48 269.82,95.19 269.49,94.86 268.66,94.86 v2(268.55,94.97)
  IN2 w0.127: v2(268.55,94.97) 268.54,94.97 268.26,94.69 267.44,94.69 265.65,96.48 262.85,96.48 260.74,94.37 257.53,94.37 256.43,95.47 251.38,95.47 250,94.08 244.32,94.08 240.76,90.52 240.76,89.85 238.93,88.02 231.63,88.02 230.67,87.06 230.27,87.06 v2(230.27,87.05)
  BOTTOM w0.089: 215.33,78.19 215.34,78.18 215.44,78.18 215.54,78.28 215.67,78.28 215.77,78.18 215.95,78.18 216.05,78.28 216.21,78.28 216.31,78.18 216.48,78.18 216.58,78.28 216.81,78.28 216.91,78.18 217.34,78.18 217.8,78.64 218.46,78.64 219.13,79.31
  BOTTOM w0.102: v2(230.27,87.05) 230.27,86.59 227.58,83.9 223.19,83.9 222.3,83.01 222.3,81.72 220.92,80.34 220.16,80.34 219.13,79.31 ; v2(335.28,209.6) 335.06,209.38 330.64,209.38 330.4,209.62 330.4,209.84 330.51,209.94 330.81,209.94 330.95,210.09 JMINI1.13
CLK_PCIE_MINI1#: length 263.3
  IN1 w0.114: v2(268.55,94.39) 268.73,94.56 269.61,94.56 270.11,95.07 270.11,95.36 271.12,96.37 271.59,96.37 272.61,97.38 272.61,102.01 271.75,102.87 271.75,119.93 272.25,120.43 272.25,129.34 271.33,130.26 271.33,132.99 271.59,133.25 271.59,136.93 272.39,137.73 272.39,140.46 271.28,141.57 271.28,143.05 268.65,145.68 268.65,149.24 269.43,150.01 269.43,155.11 269.3,155.24 269.3,165.66 268.31,166.65 268.31,168.97 269.24,169.9 269.24,173.99 269.71,174.46 269.71,175.35 272.25,177.9 276.33,177.9 276.77,177.46 278.02,177.46 278.42,177.86 280.39,177.86 281.09,178.56 300.41,178.56 303.91,182.07 307.08,182.07 307.68,181.47 310.25,181.47 310.73,180.99 310.73,179.83 310.17,179.27 310.17,177.39 311.77,175.78 320.28,175.78 322.72,178.22 323.71,178.22 324.27,178.78 326.47,178.78 327.13,178.12 328.69,178.12 332.96,182.39 332.96,189.2 334.72,190.95 334.72,193.47 335.94,194.69 335.94,205.35 336.1,205.52 336.1,206.98 334.67,208.41 334.67,208.89 334.79,209.02 v2(335.28,209.02)
  IN2 w0.127: v2(230.68,86.64) 231.76,87.72 239.06,87.72 241.07,89.73 241.07,90.4 244.45,93.78 250.12,93.78 251.51,95.16 256.31,95.16 257.4,94.07 260.87,94.07 262.97,96.18 265.53,96.18 267.32,94.39 v2(268.55,94.39)
  BOTTOM w0.089: 219.31,79.13 219.3,79.12 219.29,79.12 219.24,79.06 219.23,79.06 218.56,78.4 217.9,78.4 217.44,77.94 215.67,77.94 215.62,77.89 215.12,77.89 214.78,77.55 UH1.Y43
  BOTTOM w0.102: v2(335.28,209.02) 335.16,209.13 330.54,209.13 330.15,209.52 JMINI1.11 ; v2(230.68,86.64) 227.68,83.64 223.29,83.64 222.55,82.9 222.55,81.61 221.03,80.09 220.27,80.09 219.31,79.13
CLK_PCIE_MINI2: length 145.9
  IN4 w0.114: v2(227,89.6) 227.64,90.25 229.87,90.25 231.06,89.05 237.19,89.05 237.94,89.8 242.11,89.8 252.93,100.62 252.93,100.7 255.79,103.57 255.79,103.57 256.24,104.02 256.24,110.65 258.68,113.09 258.68,132.03 257.22,133.49 257.22,134.87 258.96,136.61 258.96,145.02 259.8,145.86 259.8,153.29 259.34,153.75 259.34,165.32 259,165.65 259,167.88 258.6,168.28 258.6,174.26 258.89,174.55 258.89,180.79 255.69,184.01 v2(255.69,185.74)
  BOTTOM w0.089: UH1.AE42 213.27,79 213.66,79 213.86,79.2 213.86,79.45 214.08,79.67 214.24,79.67 214.56,79.99 215.2,79.99 215.56,80.35
  BOTTOM w0.102: v2(255.69,185.74) 255.69,186.21 255.85,186.37 JMINI2.13 ; 215.56,80.35 216.47,81.26 216.47,81.72 216.77,82.03 216.77,83.18 216.86,83.27 216.86,83.65 218.37,85.15 218.37,86.63 219.18,87.45 219.18,88.18 220.04,89.04 224.29,89.04 224.79,88.53 225.93,88.53 v2(227,89.6)
CLK_PCIE_MINI2#: length 145.8
  IN4 w0.114: v2(226.51,90.11) 226.6,90.02 227,90.02 227.52,90.54 229.99,90.54 231.18,89.34 237.07,89.34 237.82,90.09 241.99,90.09 252.64,100.74 252.64,100.82 255.5,103.69 255.5,103.69 255.95,104.14 255.95,110.78 258.39,113.21 258.39,131.91 256.93,133.37 256.93,134.99 258.67,136.73 258.67,145.14 259.51,145.98 259.51,153.17 259.04,153.63 259.04,165.19 258.71,165.53 258.71,167.76 258.31,168.16 258.31,174.38 258.6,174.68 258.6,180.67 255.4,183.89 255.4,185.45 255.1,185.74 v2(255.07,185.74)
  BOTTOM w0.089: 215.38,80.53 215.08,80.23 214.46,80.23 214.13,79.9 214.01,79.9 213.56,79.44 UH1.AE44
  BOTTOM w0.102: v2(226.51,90.11) 226.68,89.94 226.68,89.85 226.58,89.75 226.58,89.54 225.82,88.79 224.9,88.79 224.39,89.29 219.95,89.29 218.93,88.28 218.93,87.56 218.11,86.74 218.11,85.26 216.61,83.75 216.61,83.39 216.59,83.37 216.59,83.37 216.52,83.29 216.52,82.13 216.21,81.83 216.21,81.36 215.38,80.53 ; JMINI2.11 255.05,186.36 255.15,186.26 255.41,186.26 255.47,186.2 255.47,186.1 255.11,185.74 v2(255.07,185.74)
CLK_PCIE_MINI3: length 183.9
  IN4 w0.114: v2(298.95,182.87) 298.66,183.16 298.66,183.47 298.3,183.83 293.84,188.29 278.69,188.29 278.17,187.77 274.52,187.77 272.11,185.36 268.83,185.36 267.99,184.52 265.74,184.52 264.95,183.73 261.89,183.73 259.39,181.23 259.39,174.3 259.09,174.01 259.09,168.62 259.58,168.13 259.58,165.85 259.83,165.6 259.83,154.03 260.3,153.56 260.3,149.04 260.8,148.53 260.8,145.67 259.48,144.35 259.48,136.35 258.95,135.82 258.95,133.22 259.58,132.59 259.58,129.45 259.18,129.04 259.18,112.86 258.07,111.75 258.07,107.16 257.21,106.29 257.21,104.29 256.29,103.37 256.29,103.36 253.78,100.85 253.78,100.76 242.27,89.26 242.18,89.26 238.1,89.26 237.39,88.54 230.82,88.54 230.36,89 228.94,89 228.51,89.43 228.08,89.43 227.83,89.19 227.41,89.19 v2(227.41,89.18)
  BOTTOM w0.089: UH1.AD45 214.27,79.34 214.63,79.69 215.82,79.69 215.95,79.82
  BOTTOM w0.102: 215.95,79.82 216.82,80.69 216.82,81.21 217.69,82.07 217.69,82.86 218.98,84.16 218.98,86.37 219.95,87.34 219.95,87.87 220.35,88.28 224.14,88.28 224.65,87.77 226.23,87.77 227.41,88.95 v2(227.41,89.18) ; JMINI3.13 299.06,183.65 298.79,183.38 298.79,183.03 v2(298.95,182.87)
CLK_PCIE_MINI3#: length 184
  IN4 w0.114: v2(298.37,182.87) 298.37,183.35 298.1,183.62 293.72,188 278.81,188 278.29,187.48 274.65,187.48 272.23,185.06 268.95,185.06 268.11,184.23 265.86,184.23 265.07,183.44 262.01,183.44 259.68,181.11 259.68,174.18 259.39,173.89 259.39,168.74 259.88,168.25 259.88,165.98 260.13,165.73 260.13,154.15 260.59,153.69 260.59,149.16 261.09,148.65 261.09,145.55 259.77,144.23 259.77,136.23 259.24,135.7 259.24,133.34 259.88,132.71 259.88,129.33 259.47,128.92 259.47,112.74 258.36,111.63 258.36,107.04 257.5,106.17 257.5,104.16 256.58,103.24 256.58,103.24 254.07,100.73 254.07,100.64 242.39,88.96 242.06,88.96 242.06,88.96 238.22,88.96 237.51,88.25 230.7,88.25 230.24,88.71 228.82,88.71 228.39,89.14 228.2,89.14 227.83,88.77 v2(227.82,88.77)
  BOTTOM w0.089: UH1.AD43 213.69,78.7 214.02,79.03 214.31,79.03 214.73,79.45 215.92,79.45 216.04,79.57 216.05,79.57 216.1,79.62 216.11,79.62 216.12,79.64
  BOTTOM w0.102: v2(298.37,182.87) 298.53,183.03 298.53,183.38 298.26,183.65 JMINI3.11 ; 216.12,79.64 217.08,80.59 217.08,81.1 217.94,81.97 217.94,82.76 219.23,84.05 219.23,86.27 220.2,87.24 220.2,87.77 220.45,88.02 v4(223.06,88.02) 224.03,88.02 224.54,87.52 226.33,87.52 227.59,88.77 v2(227.82,88.77)
CLK_PCIE_MMI: length 75
  TOP w0.102: U38.3 252.72,48.36 252.76,48.41 252.81,48.41 252.86,48.46 252.86,48.67 253.13,48.94 253.13,49.24 253.08,49.29 v2(252.84,49.29)
  IN4 w0.114: v2(252.84,49.29) 252.94,49.39 252.94,49.85 253.09,50 253.09,52.92 253.2,53.02 253.2,56.92 252.53,57.59 252.53,59.99 250.76,61.77 248.49,61.77 247.51,62.75 247.51,71.17 243.94,74.74 243.94,76.34 242.01,78.28 241.85,78.28 240.67,79.46 236.47,79.46 235.28,80.66 226.51,80.66 222.17,85 222.17,85.55 220.92,86.8 220.63,86.8 220.39,86.57 220.39,86.19 220.53,86.05 220.67,86.05 v2(220.84,86.22)
  BOTTOM w0.089: UH1.AB45 214.75,78.86 214.91,79.02 216.33,79.02 216.5,79.19 216.55,79.24 216.56,79.24 216.58,79.25
  BOTTOM w0.102: 216.58,79.25 217.35,80.03 217.35,80.15 218.85,81.66 218.85,82.44 220.13,83.72 220.13,84.97 220.35,85.19 220.35,86.37 220.44,86.46 220.79,86.46 220.84,86.41 v2(220.84,86.22)
CLK_PCIE_MMI#: length 74.9
  TOP w0.102: v2(253.39,49.66) 253.39,48.83 253.12,48.56 U38.2
  IN4 w0.114: v2(253.39,49.66) 253.39,52.8 253.49,52.9 253.49,57.04 252.82,57.71 252.82,60.12 250.88,62.06 248.61,62.06 247.8,62.87 247.8,71.29 244.23,74.86 244.23,76.46 242.13,78.57 241.98,78.57 240.79,79.76 236.59,79.76 235.4,80.95 226.63,80.95 222.46,85.12 222.46,85.67 221.04,87.1 220.51,87.1 220.09,86.68 220.09,86.39 v2(219.95,86.25)
  BOTTOM w0.089: 216.4,79.43 216.38,79.42 216.38,79.41 216.33,79.36 216.23,79.26 214.81,79.26 214.43,78.88 214.43,78.57 214.11,78.25 UH1.AB43
  BOTTOM w0.102: 216.4,79.43 217.1,80.14 217.1,80.26 218.6,81.76 218.6,82.55 219.18,83.12 219.88,83.82 219.88,85.07 220.1,85.29 220.1,86.09 v2(219.95,86.25)
CLK_PCIE_VGA: length 65.2
  IN1 w0.089: v2(212.15,75.61) 212.15,75.42 212.23,75.35 212.43,75.35 213.91,76.83 213.91,77.09 214.64,77.82
  IN1 w0.109: 217.03,81.36 216.97,81.3 216.97,81.3 214.92,79.25 214.92,78.1 214.64,77.82
  IN1 w0.114: 217.03,81.36 217.03,81.39 219.7,84.06 221.13,84.06 221.48,84.4 226.23,84.4 227.5,85.68 227.5,87.87 228.28,88.64 228.28,89.84 230.04,91.6 v2(230.04,92.26)
  BOTTOM w0.089: UH1.AB36 211.95,76.1 211.95,75.78 212.12,75.61 v2(212.15,75.61)
  BOTTOM w0.102: UV1.AB35 224.18,119.72 224.35,119.72 224.44,119.63 224.44,119.18 224.6,119.02 224.6,118.59 224.46,118.45 224.46,118.36 224.6,118.22 224.6,116.22 224.62,116.2 224.62,115.23 220.07,110.69 220.07,106.14 229.17,97.04 229.17,92.24 229.85,91.55 230.17,91.55 230.23,91.62 230.23,91.85 230.38,91.99 230.44,92.05 230.44,92.19 230.37,92.26 v2(230.04,92.26)
CLK_PCIE_VGA#: length 65.2
  IN1 w0.089: 214.85,77.61 214.21,76.97 214.21,76.83 212.53,75.15 v2(211.69,75.15)
  IN1 w0.109: 214.85,77.61 215.21,77.98 215.21,79.13 217.26,81.18
  IN1 w0.114: v2(230.64,91.65) 230.51,91.65 228.57,89.72 228.57,88.52 227.8,87.74 227.8,85.56 226.35,84.11 221.6,84.11 221.26,83.77 219.82,83.77 217.32,81.27 217.32,81.24 217.26,81.18
  BOTTOM w0.089: v2(211.69,75.15) 211.63,75.21 UH1.AB35
  BOTTOM w0.102: v2(230.64,91.65) 230.29,91.3 229.75,91.3 228.91,92.13 228.91,96.94 228.15,97.71 220.17,105.68 219.82,106.03 219.82,110.79 224.37,115.34 224.37,116.1 224.35,116.11 224.35,116.19 224.38,116.22 224.38,118.13 224.24,118.27 224.24,118.54 224.38,118.68 224.38,118.91 224.16,119.14 223.31,119.14 UV1.AA36
CLK_SIO_14M: length 91.5
  TOP w0.102: U46.A32 264.44,58.41 264.36,58.48 263.55,58.48 262.11,59.92 R794.1 262.11,60.94 262.59,61.43 262.59,62.02 262.81,62.23 263.44,62.23 264.31,63.09 v2(264.45,63.09) ; v2(272,64.64) 271.88,64.64 270.84,63.6 268.68,63.6 268.39,63.89 266.7,63.89 265.96,64.63 264.3,64.63 262.86,63.19 262.41,63.19 262.17,62.95 257.55,62.95 257.45,62.85 254.32,62.85 252.32,60.86 249.4,60.86 247.84,59.29 247.84,59.28 246.99,58.43 246.99,57.1 246.49,56.6 246.49,55.09 246.27,54.88 245.39,54.88 243.18,52.67 241.28,52.67 239.94,51.32 v1(231.81,51.32) 230.13,51.32 229.5,51.96 229.48,51.96 228.91,52.52 228.91,52.54 227.73,53.72 227.73,53.72 227.73,56.8 228.11,57.18 228.11,63.87 227.19,64.8 227.19,65.95 CH79.1 226.75,66.38 226.75,66.99 224.27,69.47 221.83,69.47 221.7,69.34 RH157.1
  IN2 w0.127: v2(272,64.64) 271.75,64.64 271.03,65.37 269.62,65.37 267.46,63.21 266.59,63.21 265.84,62.46 265.49,62.46 264.86,63.09 v2(264.45,63.09)
CLK_TP_SIO: length 64.9
  TOP w0.102: v2(280.28,99.73) 280.2,99.73 279.8,100.13 276.69,100.13 274.53,97.97 271.24,97.97 271.06,98.15 269.69,98.15 R902.2 269.1,98.51 268.8,98.22 268.6,98.22 C751.1 268.08,98.5 267.84,98.26 267.33,98.26 267.1,98.49 R1164.1 ; v2(281.26,115.58) 281.34,115.66 U51.A37
  IN1 w0.102: v2(291.05,104.67) 291.06,104.68 294.9,104.68 295.46,105.24 297.26,105.24 298.06,106.04 298.06,110.98 295.28,113.75 295.28,114.1 294.57,114.82 293.37,114.82 292.46,113.91 290.51,113.91 289.71,113.11 285.3,113.11 284.73,113.67 284.73,114.23 284.39,114.57 283.1,114.57 282.09,115.58 v2(281.26,115.58)
  BOTTOM w0.102: v2(280.28,99.73) 279.92,99.36 279.92,98.82 280.23,98.5 280.93,98.5 282.08,99.66 283.15,99.66 285.84,102.35 288.72,102.35 290.69,104.32 290.72,104.32 291.05,104.65 v2(291.05,104.67)
CLK_XDP: length 3
  BOTTOM w0.102: RH1.1 121.88,113.88 120.95,113.88 120.87,113.96 120.73,113.96 120.66,113.9 JXDP1.40
CLK_XDP#: length 3
  BOTTOM w0.102: RH2.1 122.03,114.13 v4(121.33,114.13) 121.06,114.13 120.98,114.21 120.82,114.21 120.63,114.4 JXDP1.42
CLKA0: length 34.8
  TOP w0.102: UV5.J12 v2(193.05,117.1)
  IN4 w0.114: v2(212.19,125.22) 212.17,125.2 212.17,121.33 211.37,120.53 211.37,119.51 209.74,117.88 208.28,117.88 207.55,117.15 203.58,117.15 199.8,113.37 197.35,113.37 196.34,112.36 195.44,112.36 195.16,112.64 195.16,112.88 v2(194.97,113.07) 195.19,113.3 195.19,114.06 194.06,115.2 194.06,115.85 193.23,116.67 193.23,116.91 v2(193.05,117.1)
  BOTTOM w0.102: UV5.J12 v2(193.05,117.1) ; v2(212.19,125.22) 212.65,125.68 UV1.H27
  BOTTOM w0.127: RV187.1 194.57,112.25 194.57,112.25 194.75,112.25 195.04,112.54 195.04,112.99 v2(194.97,113.07)
CLKA0#: length 34.4
  TOP w0.109: v2(193.85,117.1) UV5.J11
  IN4 w0.114: v2(193.85,117.1) 193.71,117.23 193.61,117.23 193.44,117.06 193.44,116.76 194.26,115.93 194.26,115.28 195.4,114.15 195.4,113.25 v2(195.56,113.08) 195.36,112.88 195.36,112.72 195.52,112.56 196.25,112.56 197.27,113.58 199.72,113.58 203.5,117.35 207.46,117.35 208.19,118.08 209.66,118.08 211.17,119.6 211.17,120.61 211.97,121.41 211.97,124.85 v2(211.57,125.26)
  BOTTOM w0.102: UV1.G27 211.57,125.51 v2(211.57,125.26) ; v2(193.85,117.1) UV5.J11
  BOTTOM w0.127: v2(195.56,113.08) 195.31,112.83 195.31,112.43 194.83,111.95 194.83,111.7 RV188.1
CLKA1: length 41.1
  TOP w0.102: UV3.J12 193.51,142.9 v2(193.91,143.3)
  IN4 w0.114: v2(199.21,149.83) 199,149.63 199,147.53 198.4,146.93 195.68,146.93 194.1,145.35 194.1,144.16 193.66,143.71 193.66,143.55 v2(193.91,143.3) 194.24,142.97 194.24,142.36 194.52,142.08 194.52,141.4 194.27,141.15 194.27,140.56 194.64,140.2 195.16,140.2 196.52,138.84 201.65,138.84 201.86,138.62 201.86,138.07 201.95,137.99 202.39,137.99 202.47,138.07 202.47,139.09 202.73,139.34 203.16,139.34 203.45,139.05 203.45,138.1 203.56,137.99 205.62,137.99 205.88,138.25 206.7,138.25 207.01,137.94 207.01,137.5 207.32,137.19 208.31,137.19 208.77,136.73 212.2,136.73 212.34,136.87 213.04,136.87 213.25,136.65 v2(213.25,135.98)
  BOTTOM w0.102: UV1.J14 213.45,136.16 213.26,135.97 213.26,135.98 v2(213.25,135.98) ; v2(193.91,143.3) 193.51,142.9 UV3.J12
  BOTTOM w0.127: RV189.1 199.4,150.51 199.06,150.16 199.06,149.98 v2(199.21,149.83)
CLKA1#: length 41.1
  TOP w0.102: v2(193.85,142.5) UV3.J11
  IN4 w0.114: v2(212.66,135.98) 212.71,135.98 213.05,136.32 213.05,136.57 212.95,136.66 212.42,136.66 212.28,136.52 208.69,136.52 208.23,136.98 207.23,136.98 206.8,137.41 206.8,137.86 206.62,138.04 205.97,138.04 205.71,137.78 203.48,137.78 203.25,138.02 203.25,138.97 203.07,139.14 202.81,139.14 202.67,139 202.67,137.98 202.47,137.78 201.86,137.78 201.66,137.99 201.66,138.54 201.56,138.63 196.44,138.63 195.08,139.99 194.55,139.99 194.06,140.48 194.06,141.23 194.32,141.49 194.32,141.99 194.21,142.1 193.94,142.1 193.85,142.19 v2(193.85,142.5) 193.47,142.88 193.47,143.45 193.45,143.47 193.45,143.8 193.9,144.24 193.9,145.44 195.59,147.13 198.32,147.13 198.8,147.61 198.8,149.65 v2(198.62,149.83)
  BOTTOM w0.102: v2(212.66,135.98) 212.66,136.06 212.65,136.07 UV1.H14 ; v2(193.85,142.5) UV3.J11
  BOTTOM w0.127: RV190.1 198.79,150.15 198.79,149.99 v2(198.62,149.83)
CLKB0: length 60
  TOP w0.102: UV7.J12 v2(205.91,158.09)
  IN1 w0.114: v2(205.91,158.09) 205.6,158.4 205.51,158.49 205.51,159.1 205.19,159.41 205.19,160.95 204.46,161.68 199.06,161.68 198.56,162.18 198.56,167.24 199.77,168.45 207.62,168.45 207.81,168.64 207.81,169.19 v2(207.6,169.39)
  IN4 w0.114: v2(214.74,141.23) 214.74,141.41 214.41,141.74 213.98,141.74 213.61,142.11 213.61,143.66 213.77,143.82 213.77,145.94 213.22,146.49 211.65,146.49 209.6,148.53 207.3,148.53 206.93,148.9 206.93,149.29 207.42,149.78 207.42,149.96 207.14,150.24 206.96,150.24 206.39,149.68 206.06,149.68 205.7,150.04 205.7,150.37 206.14,150.81 206.14,150.97 205.97,151.14 205.44,151.14 205.2,151.39 205.2,151.87 205.44,152.12 206.95,152.12 207.08,152.25 207.08,152.56 206.95,152.69 205.08,152.69 204.83,152.94 204.83,153.42 205.08,153.67 206.17,153.67 206.35,153.84 206.35,156.82 206.19,156.98 206.19,158.03 206.12,158.09 v2(205.91,158.09)
  BOTTOM w0.102: UV1.L9 215.18,140.8 v2(214.74,141.23) ; UV7.J12 v2(205.91,158.09)
  BOTTOM w0.127: v2(207.6,169.39) 207.74,169.53 207.74,169.75 RV206.1
CLKB0#: length 59.2
  TOP w0.109: UV7.J11 206.31,158.49 v2(205.9,158.9)
  IN1 w0.114: v2(208.19,169.39) 208.01,169.22 208.01,168.56 207.7,168.25 199.86,168.25 198.76,167.16 198.76,162.27 199.15,161.89 204.54,161.89 205.39,161.04 205.39,159.5 205.71,159.18 205.71,159.09 v2(205.9,158.9)
  IN4 w0.114: v2(205.9,158.9) 205.9,158.7 206.4,158.2 206.4,157.06 206.55,156.91 206.55,153.76 206.25,153.46 205.16,153.46 205.04,153.34 205.04,153.02 205.16,152.89 207.03,152.89 207.28,152.65 207.28,152.16 207.03,151.92 205.53,151.92 205.4,151.79 205.4,151.47 205.53,151.34 206.06,151.34 206.35,151.05 206.35,150.72 205.91,150.28 205.91,150.12 206.15,149.88 206.31,149.88 206.88,150.45 207.23,150.45 207.63,150.05 207.63,149.7 207.13,149.2 207.13,148.98 207.38,148.74 209.69,148.74 211.73,146.69 213.31,146.69 213.98,146.02 213.98,143.74 213.81,143.57 213.81,142.2 214.06,141.95 v2(214.75,141.95)
  BOTTOM w0.102: v2(205.9,158.9) 206.31,158.49 UV7.J11 ; UV1.L8 215.1,141.6 v2(214.75,141.95)
  BOTTOM w0.127: v2(208.19,169.39) 208.01,169.57 208.01,169.74 RV208.1
CLKB1: length 51.2
  TOP w0.102: v2(226.91,158.09) UV9.J12
  TOP w0.127: v2(229.83,169.47) 229.83,169.48 230.06,169.71 230.06,169.85 229.79,170.12 RV209.1
  IN1 w0.114: v2(229.83,169.47) 230.09,169.2 230.09,168.86 231.47,167.49 233.35,167.49 234.53,166.31 234.53,162.98 233.63,162.09 227.74,162.09 226.55,160.9 226.55,159.13 227.2,158.48 227.2,158.39 v2(226.91,158.09)
  IN4 w0.114: v2(226.91,158.09) 227.32,157.68 227.87,157.68 228.13,157.42 228.13,155.98 228.3,155.81 228.3,155.11 227.95,154.76 227.95,152.97 228.22,152.7 228.95,152.7 229.08,152.57 229.08,152.12 228.95,151.99 228,151.99 227.76,151.75 227.76,151.16 228,150.91 228.6,150.91 228.72,150.79 228.72,150.33 228.6,150.2 228.02,150.2 227.77,149.96 227.77,149.42 228.02,149.17 228.48,149.17 228.61,149.05 228.61,148.72 228.48,148.59 227.99,148.59 227.74,148.34 227.74,147.81 227.99,147.56 229.09,147.56 229.22,147.43 229.22,147.03 229.09,146.9 228.1,146.9 226.98,145.78 226.98,145.25 225.57,143.84 225.57,143.29 225.8,143.06 225.8,141.43 226.01,141.22 v2(226.63,141.22)
  BOTTOM w0.102: v2(226.91,158.09) UV9.J12 ; v2(226.63,141.22) 226.59,141.22 226.59,141.26 226.26,141.6 UV1.AD8
CLKB1#: length 50.5
  TOP w0.109: UV9.J11 v2(227.71,158.09)
  TOP w0.127: RV210.1 230.63,170.12 230.34,169.82 230.34,169.55 v2(230.41,169.47)
  IN1 w0.114: v2(230.41,169.47) 230.3,169.35 230.3,168.95 231.55,167.69 233.43,167.69 234.73,166.4 234.73,162.9 233.72,161.89 227.83,161.89 226.76,160.81 226.76,159.22 227.41,158.57 227.41,158.4 v2(227.71,158.09)
  IN4 w0.114: v2(227.71,158.09) 227.92,157.89 227.96,157.89 228.34,157.51 228.34,156.06 228.5,155.89 228.5,155.03 228.15,154.67 228.15,153.06 228.31,152.9 229.04,152.9 229.28,152.66 229.28,152.04 229.04,151.79 228.09,151.79 227.96,151.66 227.96,151.24 228.09,151.12 228.68,151.12 228.93,150.87 228.93,150.25 228.68,150 228.1,150 227.97,149.87 227.97,149.5 228.1,149.38 228.57,149.38 228.81,149.13 228.81,148.63 228.57,148.39 228.07,148.39 227.95,148.26 227.95,147.89 228.07,147.76 229.18,147.76 229.42,147.52 229.42,146.94 229.18,146.7 228.18,146.7 227.19,145.7 227.19,145.16 225.78,143.75 225.78,143.37 226,143.14 226,141.51 226.1,141.42 226.28,141.42 226.57,141.71 v2(226.57,141.9)
  BOTTOM w0.102: v2(227.71,158.09) UV9.J11 ; UV1.AD7 226.08,142.4 v2(226.57,141.9)
CLKRUN#: length 267.2
  TOP w0.102: v2(292.87,132.74) 292.84,132.74 292.3,132.2 U39.15 ; v2(271.28,56.54) 271.19,56.63 U46.B20 ; U51.A32 283.72,119.64 283.55,119.81 283.36,119.81 283.14,119.6 v2(283.14,119.51) ; v2(191.01,61.74) 191.32,62.04 RH90.2
  IN1 w0.102: v2(292.87,132.74) 292.81,132.74 291.46,131.39 286.01,131.39 282.7,128.08 282.7,122.94 281.77,122.01 281.77,120.54 282.8,119.51 v2(283.14,119.51)
  IN2 w0.127: v2(271.28,56.54) 272.33,57.59 277.73,57.59 278.09,57.95 v2(279.32,57.95)
  IN3 w0.089: v2(199.83,71.06) 199.83,70.37 198.85,69.39 198.85,68.3 198.06,67.51 198.06,67.41 197.91,67.26
  IN3 w0.127: 197.91,67.26 196.46,65.81 196.46,65.58 195.21,64.33 193.89,64.33 193.78,64.21 193.74,64.21 192.78,63.26 192.68,63.26 191.39,61.96 191.24,61.96 v2(191.01,61.74)
  IN4 w0.102: v2(191.01,61.74) 191.01,60.94 190.66,60.59 190.66,50.76 198.04,43.38 198.04,42.49 199.38,41.15 200.83,41.15 202.04,39.94 202.04,39.03 203.72,37.35 203.72,35.1 215.77,23.04 231.71,23.04 233.43,21.32 245.09,21.32 245.6,21.83 252.69,21.83 263.81,32.96 263.81,42.14 264.38,42.71 264.38,43.93 265.35,44.89 265.35,45.48 264.8,46.02 264.8,46.81 265.87,47.88 266.23,47.88 266.62,48.27 266.62,49.91 266.21,50.32 266.21,55.34 265.97,55.58 265.97,56.32 265.98,56.34 265.98,57.14 264.14,58.98 v2(263.86,58.98) ; v2(279.32,57.95) 278.98,58.29 278.98,59.32 279.19,59.54 279.19,62.62 278.8,63.01 278.8,64.55 277.02,66.33 277.02,92.31 280.17,95.46 280.17,98.45 279.8,98.82 279.8,101.07 279.15,101.71 279.15,104.09 279.69,104.62 281.24,104.62 282.26,105.65 284.1,105.65 284.95,106.49 285.52,106.49 286,106.97 286,108.04 286.36,108.4 286.36,108.63 286.94,109.21 287.74,109.21 288.34,109.81 288.34,110.19 288.29,110.24 288.29,111.24 288.37,111.32 288.37,114.46 287.9,114.92 287.9,116.12 287.56,116.47 287.51,116.47 287.12,116.86 287.12,117.63 286.16,118.59 284.79,118.59 283.88,119.51 v2(283.14,119.51)
  BOTTOM w0.089: v2(199.83,71.06) 199.83,70.93 UH1.AN7
  BOTTOM w0.102: v2(263.86,58.98) 264.3,58.98 265.72,57.56 v1(267.06,57.56) 269.49,57.56 269.97,57.07 269.97,55.5 270.12,55.35 270.68,55.35 271.28,55.94 v2(271.28,56.54)
CLKTESTA: length 3.9
  TOP w0.102: CV82.1 230.81,138.35 230.81,139.34 v2(231.06,139.6) 231.06,139.76 230.84,139.98 230.84,140.77 v1(230.91,140.83)
  BOTTOM w0.102: UV1.AK10 230.66,140 v2(231.06,139.6)
CLKTESTB: length 2.4
  TOP w0.102: v1(231.91,140) 231.73,139.83 v2(231.73,139.47) 231.29,139.03 CV81.1
  BOTTOM w0.102: v2(231.73,139.47) 231.73,139.71 UV1.AL10
COMP: length 15.5
  TOP w0.254: PC523.2 114.61,158.91 PC519.2 113,158.91 v1(112.56,158.48) 112.24,158.16 v2(112.24,158.01) ; PC517.2 117.05,155.89 117.01,155.93 116.99,155.93 116.72,156.2 v4(116.61,156.2) 116.42,156.2 PR542.2
  IN1 w0.254: v2(112.24,158.01) 112.24,157.55 112.87,156.92 114.93,156.92 115.63,156.22 116.58,156.22 v4(116.61,156.2)
  BOTTOM w0.203: v4(116.61,156.2) 116.73,156.2 117,155.93 117.62,155.93 117.72,155.83 PU500.7
  BOTTOM w0.254: v4(116.61,156.2) 116.58,156.22 115.88,156.22 PC525.2 PR542.2
CONTACTLESS_DET#: length 99.2
  TOP w0.102: JUSH1.4 262.66,87.57 261.39,88.84 255.24,88.84 251.15,92.93 248.87,92.93 247,94.8 v2(247,95.69) ; RH201.2 215.8,59.51 v1(215.5,59.51) 215,59.51 v2(214.86,59.37)
  IN3 w0.127: v2(214.86,59.37) 215.58,59.37 217.17,57.77 217.17,57.41 218.05,56.53 218.64,56.53 220.38,54.79 230.08,54.79 231.16,53.71 235.32,53.71 241.92,60.3 241.92,73.13 243.15,74.37 243.15,83.63 245.51,85.99 245.51,94.21 v2(247,95.69)
  BOTTOM w0.089: 212.92,62.33 212.47,62.77 212.47,63.42 212.15,63.74 212.15,64.09 211.82,64.43 UH1.C16
  BOTTOM w0.102: v2(214.86,59.37) 214.86,59.99 214.59,60.26 214.59,60.59 214.39,60.79 214.39,61.13 213.79,61.73 213.52,61.73 212.92,62.33
CPPE#: length 262.5
  TOP w0.102: v2(223.19,186.41) v1(223.19,185.89) ; v2(267.78,190.51) 267.78,189.22 R737.1
  IN1 w0.102: v2(223.19,186.41) 224.14,186.41 227.3,189.57 257.48,189.57 257.81,189.9 267.17,189.9 v2(267.78,190.51)
  IN3 w0.127: v2(223.19,173.8) 223.62,173.37 231.96,173.37 232.53,173.94 238.19,173.94 239.04,174.79 246.35,174.79 247.4,173.74 252.74,173.74 253.68,172.8 254.15,172.8 256.47,170.47 256.47,166.99 255.84,166.36 255.84,165.41 256.47,164.78 256.47,163.11 257.29,162.29 257.29,158.87 258.47,157.7 258.47,144.4 259.95,142.92 259.95,137.87 257.16,135.08 257.16,132.79 258.59,131.35 258.59,113.78 255.98,111.16 255.98,103.87 248.73,96.62 246.75,96.62 245,94.87 245,86.2 242.65,83.84 242.65,74.58 240.25,72.18 240.25,70.14 238.11,68 232.24,68 231.12,66.88 231.12,57.8 229.05,55.73 225.34,55.73 224.52,56.55 224.52,56.69 v2(224.33,56.88)
  BOTTOM w0.089: UH1.B13 211.29,63.18 211.67,62.8 211.67,62.28 212.27,61.68
  BOTTOM w0.102: JMINI2.37 268.65,188.37 267.78,189.24 v2(267.78,190.51) ; v2(223.19,186.41) v2(223.19,173.8) ; 212.27,61.68 213.06,60.89 213.06,60.6 214.92,58.74 214.92,58.53 215.6,57.85 215.6,57.01 216.67,55.94 216.67,54.48 217.85,53.3 220.75,53.3 v2(224.33,56.88)
CPU1.5V_S3_GATE: length 210.1
  TOP w0.102: v2(141.78,69.38) 143.01,69.38 RC96.1 ; R889.2 280.07,116.84 280.67,116.84 v2(280.72,116.88) 281.44,116.16 U51.A36 ; v1(252.98,115.15) 253.62,114.51 v2(253.62,114.31)
  IN1 w0.102: v2(183.79,100.6) 183.79,100 183.88,99.91 183.88,90.44 187.03,87.29 187.03,79.88 186.85,79.7 186.85,79.06 v2(186.42,78.63)
  IN2 w0.127: v2(253.62,114.31) 253.47,114.46 253.47,114.69 253.64,114.86 253.64,114.87 253.89,115.12 253.9,115.12 253.98,115.2 273.93,115.2 274.11,115.38 279.19,115.38 279.46,115.65 279.46,116.55 279.79,116.88 280.72,116.88 v2(280.72,116.88) ; v2(141.78,69.38) 141.26,68.86 141.26,63.04 144.17,60.13 175.15,60.13 184.87,69.85 184.87,77.46 186.04,78.63 v2(186.42,78.63)
  IN3 w0.127: v2(253.62,114.31) 253.58,114.31 253.3,114.59 252.62,114.59 250.62,112.59 250.62,108.51 246.66,104.55 246.66,103.44 237.59,94.37 222.99,94.37 215.77,101.6 207.09,101.6 206.4,100.91 203.66,100.91 202.04,102.54 197.52,102.54 197.37,102.69 194.98,102.69 194.51,103.16 189.37,103.16 187.97,101.76 183.96,101.76 183.79,101.6 v2(183.79,100.6)
CPU_B+: length 21.6
  IN1 w0.254: v4(147.05,156.35) 144.13,156.35 143.49,156.98 141.44,156.98 141.21,156.76 137.2,156.76 136.97,156.98 133.02,156.98 132.83,156.79 129.95,156.79 129.85,156.9 v4(126.68,156.9)
  BOTTOM w0.254: PR526.2 126.51,156.73 v4(126.68,156.9)
  vias: v1(121.27,144.03) v4(120.82,140.73) v4(120.82,139.97) v4(120.82,139.14) v4(120.82,138.44) v4(121.59,140.73) v4(121.59,139.97) v4(121.59,139.2) v4(121.59,138.44) v4(122.35,140.73) v4(122.35,139.97) v4(122.35,139.2) v4(122.35,138.44) v4(147.05,155.59) v4(147.05,154.83) v4(147.05,154.06) v4(149.67,156.24) v4(149.67,155.47) v4(149.69,154.77) v4(149.69,154.01) v4(150.43,156.24) v4(150.43,155.47) v4(150.45,154.77) v4(150.45,154.01) v4(160.51,142.89) v4(160.51,142.13) v4(160.51,141.36) v4(160.51,140.6) v4(160.51,139.84) v4(160.51,139.08) v4(161.27,142.89) v4(161.27,142.13) v4(161.27,141.36) v4(161.27,140.6) v4(161.27,139.84) v4(161.27,139.08)
CPU_DETECT#: length 287.4
  TOP w0.102: v1(263.63,39.38) 264.05,38.96 v2(264.26,38.96) ; U46.A3 273.96,49.89 274.81,49.04 v2(275.01,49.04) 275.73,49.76 R763.2
  IN1 w0.102: v2(275.01,49.04) 274.62,49.04 273.92,48.35 273.92,47.04 274.35,46.61 274.35,42.09 v2(274.24,41.97)
  IN2 w0.127: v2(264.26,38.96) 264.23,38.99 264.23,40.31 264.46,40.54 268.49,40.54 269.11,41.16 272.31,41.16 272.44,41.29 273.15,41.29 273.83,41.97 v2(274.24,41.97) ; v2(117.66,113.16) 117.56,113.06 117.56,109.19 114.46,106.09 114.46,90.77 115.17,90.06 115.17,87.39 115.43,87.13 118.35,87.13 119.49,85.99 119.49,81.69 120.25,80.92 120.25,66.65 128.5,58.41 179.71,58.41 v2(180.97,59.66)
  IN3 w0.127: v2(264.26,38.96) 264.26,38.87 262.67,37.29 262.67,32 261.15,30.48 247.86,17.18 226.24,17.18 225.23,18.19 225.23,19.46 221.83,22.86 218.17,22.86 217.11,23.91 217.11,24.88 215.9,26.1 215.53,26.1 214.14,27.48 214.14,32.04 210.94,35.24 198.39,35.24 194.69,38.94 194.69,41.14 193.95,41.87 193.95,43.17 180.97,56.15 v2(180.97,59.66)
  IN4 w0.089: v2(138.73,110.92) 138.69,110.92 138.29,111.33 136.39,111.33 136,111.72
  IN4 w0.102: 136,111.72 135.82,111.9 135.82,112.85 132.91,115.76 125.97,115.76 125.13,114.92 122.31,114.92 121.51,114.12 119.4,114.12 118.44,113.16 v2(117.66,113.16)
  BOTTOM w0.089: v2(138.73,110.92) JCPU1.AP32
CPU_DMI: length 8.5
  TOP w0.089: v2(168.73,104.92) 168.87,104.92 168.97,104.82 168.97,104.65 169.48,104.15 170.06,104.15 170.26,104.15 170.4,104.29 170.48,104.29 170.48,104.29 170.89,104.29 170.89,104.29 171.48,104.29 171.48,104.29 171.89,104.29 171.89,104.29 172.58,104.29 172.58,104.29 172.89,104.29 172.89,104.29 173.33,104.29 173.4,104.22 173.4,104.21 173.41,104.2
  TOP w0.102: 173.41,104.2 v4(173.78,103.83) 174.45,103.16 175.01,103.16 RC48.1
  BOTTOM w0.089: v2(168.73,104.92) 168.26,104.45 JCPU1.E26
CPU_DMI#: length 8.5
  TOP w0.089: v2(169.73,104.92) 169.64,105.02 169.32,105.02 169.21,104.91 169.21,104.75 169.58,104.39 170.16,104.39 170.3,104.53 170.38,104.53 170.38,104.54 170.99,104.54 170.99,104.53 171.38,104.53 171.38,104.54 171.99,104.54 171.99,104.53 172.48,104.53 172.48,104.54 172.99,104.54 172.99,104.53 173.44,104.53 173.59,104.38
  TOP w0.102: 173.59,104.38 174.56,103.42 175.07,103.42 RC46.1
  BOTTOM w0.089: v2(169.73,104.92) 169.26,104.45 JCPU1.D26
CPU_EDP_HPD: length 29
  TOP w0.102: v2(171.7,140.83) 171.7,140.61 172.05,140.26 U27.1 ; QC3.2 163.04,128.92 163.2,129.08 RC75.1 163.2,130.45 162.97,130.68 162.02,130.68 v2(162,130.66) 161.37,130.66 v1(161.25,130.53)
  IN2 w0.127: v2(162,130.66) 162.95,129.7 170.84,129.7 v2(171.62,130.49)
  IN3 w0.127: v2(171.7,140.83) 170.92,140.06 170.92,131.19 v2(171.62,130.49)
CPU_PLTRST#: length 158.3
  IN1 w0.102: v2(111.7,103.83) 111.7,101.83 117.89,95.64 117.89,70.24 117.14,69.49 117.14,65.21 118.55,63.8 v2(118.55,63.6)
  IN4 w0.089: 192.66,72.55 193.7,71.51 195.08,71.51 196.5,70.09 v2(196.5,69.9)
  IN4 w0.102: 192.66,72.55 189.75,75.47 189.75,76.67 v2(189.94,76.86) ; v2(111.7,103.83) 113.09,105.22 121.76,105.22 122.75,104.23 126.93,104.23 127.16,104 130.11,104 v2(130.13,104.03)
  BOTTOM w0.089: UH1.AU4 197.89,70.52 197.49,70.52 197.3,70.32 197.3,70.07 197.11,69.88 196.54,69.88 196.5,69.91 v2(196.5,69.9)
  BOTTOM w0.102: v2(130.13,104.03) RC66.2 ; v2(118.55,63.6) 118.97,63.18 120.4,63.18 124.62,58.97 172.27,58.97 184.57,71.27 184.57,71.86 v1(187.52,74.81) 188.5,75.8 188.5,76.24 189.12,76.86 v2(189.94,76.86)
CPU_PLTRST#_R: length 29.3
  IN2 w0.127: v2(123.93,116.09) 123.9,116.09 123.11,115.3 123.11,112.19 126.91,108.39 126.92,108.39 130.87,104.44 132.43,104.44 132.8,104.08 v2(132.8,104)
  BOTTOM w0.089: JCPU1.AT26 136.2,104.45 136,104.25
  BOTTOM w0.102: v2(123.93,116.09) 123.55,116.47 RC23.1 ; v1(129.71,105.12) 129.71,104.75 129.09,104.13 RC64.2 129.55,103.47 131.33,103.47 RC66.1 132.77,104.03 v2(132.8,104) 132.82,104.03 135.77,104.03 136,104.25
CPU_PWR_DEBUG: length 98.3
  TOP w0.089: v2(164.73,105.92) 164.73,105.95 165.17,106.39 166.84,106.39 167.24,105.98 167.24,105.83 167.75,105.32 167.93,105.32 168.26,104.99 168.26,103.77 168.59,103.44 170.96,103.44 171.04,103.35 173.4,103.35 173.59,103.16
  TOP w0.102: v2(117.81,114.71) 117.06,113.96 v1(116.44,113.96) 114.64,113.96 RC22.1 ; 173.59,103.16 174.2,102.55 174.22,102.55 174.35,102.42 174.74,102.42 RC85.2 RC89.1
  IN2 w0.089: v2(164.73,105.92) 164.73,105.91 165.51,105.14 166.28,105.14 168.16,103.26 168.16,99.91 167.13,98.89 167.13,95.39 165.1,93.36 144,93.36 142.93,94.43 136.11,94.43
  IN2 w0.102: 136,94.43 136.11,94.43
  IN2 w0.127: 136,94.43 135.37,94.43 133.91,92.98 129.52,92.98 119.49,103.01 119.49,105.55 118.22,106.82 118.22,114.3 v2(117.81,114.71)
  BOTTOM w0.089: v2(164.73,105.92) JCPU1.H27
CPU_PWR_DEBUG_R: length 4.3
  TOP w0.102: v2(112.2,115.18) v1(112.2,114.57) 112.2,113.92 112.57,113.55 RC22.2
  BOTTOM w0.102: v2(112.2,115.18) 112.42,115.4 JXDP1.45
CPU_SSC_DPLL: length 11.7
  TOP w0.089: 173.59,105.55 173.24,105.55 173.21,105.52 168.48,105.52 168.29,105.71 168.29,105.88 168.42,106.02 168.63,106.02 v2(168.73,105.92)
  TOP w0.102: RC44.1 177.71,105.55 173.59,105.55
  BOTTOM w0.089: JCPU1.E27 168.26,105.45 v2(168.73,105.92)
CPU_SSC_DPLL#: length 11.7
  TOP w0.089: v2(167.73,105.92) 168.32,105.33 173.22,105.33 173.26,105.3 173.59,105.3
  TOP w0.102: RC42.1 177.71,105.3 v4(176.39,105.3) 173.59,105.3
  BOTTOM w0.089: JCPU1.F27 167.26,105.45 v2(167.73,105.92)
CPU_VTT_ON: length 4.7
  TOP w0.102: U46.B17 273.2,56.64 273.62,57.06 273.62,57.9 274.68,58.97 v1(274.68,58.98) 274.73,59.03 274.73,59.83 R789.2
CPUSB#: length 18.6
  TOP w0.102: JEXP1.2 282.44,27.5 v1(282.02,27.92) v2(281.41,28.52) 281.22,28.33 CE10.1 ; U41.9 272.9,33.66 273.41,33.15 v2(273.43,33.15)
  IN1 w0.102: v2(281.41,28.52) 280.67,27.77 274.47,27.77 273.54,28.7 273.54,33.03 v2(273.43,33.15)
CRT_IREF: length 4.3
  TOP w0.089: v2(214.54,75.23) 214.6,75.3 214.61,75.3 v1(214.97,75.65) 215.2,75.88 215.2,76.05 215.55,76.41 215.55,76.68 216.04,77.17 RH97.2
  BOTTOM w0.089: v2(214.54,75.23) 214.7,75.4 UH1.U40
CRT_SWITCH: length 226.9
  TOP w0.102: v2(178.7,172.58) 179.05,172.94 180.49,172.94 180.67,173.11 U6.30 ; v2(263.27,47.71) 264.12,47.71 264.19,47.78 U46.B52
  IN3 w0.127: v2(178.7,172.58) 178.24,172.12 178.24,171.01 179,170.26 180.52,170.26 181.18,170.92 184.92,170.92 185.3,171.3 193.38,171.3 193.5,171.18 203.97,171.18 205.04,172.26 214.22,172.26 214.56,172.59 218.66,172.59 221.7,175.63 222.01,175.95 224.56,175.95 224.74,175.77 225.13,175.77 232.37,175.77 237.26,175.77 238.21,176.72 246.75,176.72 247.04,177.01 252.79,177.01 255.02,174.78 258.66,174.78 260.15,173.29 260.15,167.32 261.02,166.45 261.02,149.94 261.95,149.01 261.95,144.92 264.14,142.72 264.14,141.21 265.35,140.01 265.35,138.36 265.88,137.83 265.88,133.97 265.5,133.59 265.5,130.3 264.79,129.59 264.79,121.36 265.5,120.65 265.5,110.12 266.06,109.56 266.06,105.83 265.53,105.3 265.53,94.05 265.51,94.03 265.51,93.9 264.33,92.71 264.33,76.68 263.24,75.59 263.24,66.11 260.38,63.25 260.38,58.61 259.99,58.22 259.99,52.75 260.64,52.1 260.64,49 261.93,47.71 v2(263.27,47.71)
  BOTTOM w0.102: v2(263.27,47.71) v1(263.27,46.82)
CS_1.35V: length 7
  TOP w0.203: PU200.13 210.42,16.14 210.37,16.19 v4(210.37,16.28)
  TOP w0.254: PR201.2 212.25,18.63 212.9,17.98 v4(212.9,16.65)
  IN2 w0.254: v4(212.9,16.65) 212.9,16.43 212.39,15.93 210.73,15.93 v4(210.37,16.28)
  BOTTOM w0.102: v4(210.37,16.28) 210.37,16.59 v1(210.1,16.85)
