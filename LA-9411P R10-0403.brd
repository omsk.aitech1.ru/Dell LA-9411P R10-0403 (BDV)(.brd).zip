# Allegro board LA-9411P R10-0403.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
DQA1_19: length 32
  TOP w0.102: v2(213.14,138.52) 212.94,138.32 212.94,138.31 212.75,138.12 212.73,138.12 212.56,137.96 211.42,137.96 210.73,137.27 210.73,136.94 209.93,136.14 209.93,135.89 209.61,135.57 208.61,135.57 207.98,134.95 207.17,134.95 207.12,135
  TOP w0.13: UV3.A2 187.39,134.56 187.39,133.95 187.36,133.93 187.36,133.38 188.97,131.77 194.67,131.77 195.07,132.17 200.4,132.17 203.23,135 v1(205.47,135) 207.12,135
  BOTTOM w0.102: UV1.H11 212.66,139 v2(213.14,138.52)
DQA1_20: length 30.6
  TOP w0.13: UV3.E2 190.69,134.46 190.69,133.85 190.8,133.74 190.8,133.49 191.18,133.11 193.92,133.11 194.45,133.63 200,133.63 200.75,134.39 200.75,137.73 200.9,137.87 201.27,137.87 201.39,138 201.39,138.55 201.52,138.68 201.79,138.68 201.91,138.55 201.91,138 202.04,137.87 202.3,137.87 202.43,138 202.43,138.55 202.56,138.68 202.82,138.68 202.95,138.55 202.95,138 203.08,137.87 v1(203.89,137.87) 206.4,137.87 207.13,138.6 207.13,138.63 207.97,139.47 209.6,139.47 210.12,139.99 211,139.99 v2(211.4,140.39)
  BOTTOM w0.102: UV1.G10 211.79,140 v2(211.4,140.39)
DQA1_21: length 29
  TOP w0.13: UV3.E4 190.25,136.8 190.65,137.19 190.65,139.76 191.13,140.25 198.48,140.25 198.82,140.58 203.16,140.58 203.28,140.45 203.28,140.19 203.41,140.06 203.73,140.06 203.86,140.19 203.86,140.47 203.98,140.6 204.13,140.6 204.28,140.75 204.61,140.75 204.68,140.83 204.68,141.11 204.81,141.23 205.12,141.23 205.24,141.11 205.24,140.88 205.37,140.75 205.63,140.75 205.76,140.88 205.76,141.14 205.89,141.27 206.15,141.27 206.28,141.14 206.28,140.88 206.41,140.75 206.67,140.75 206.8,140.88 206.8,141.21 206.93,141.33 207.74,141.33 207.86,141.45 207.86,141.66 207.98,141.79 208.59,141.79 208.83,142.02 v2(212.24,142.02)
  BOTTOM w0.102: v2(212.24,142.02) 211.85,141.64 UV1.G8
DQA1_22: length 30.1
  TOP w0.102: 209.84,141.59 v1(210.42,141.59) 213.8,141.59 214.66,140.73 v2(214.66,140.4)
  TOP w0.13: UV3.F4 191.05,136.55 191.44,136.94 191.44,139.51 191.71,139.78 199.29,139.78 199.63,140.12 201.19,140.12 201.32,139.99 201.32,139.73 201.44,139.6 201.78,139.6 201.9,139.73 201.9,139.99 202.03,140.12 202.61,140.12 202.74,139.99 202.74,139.76 202.9,139.6 204.22,139.6 204.34,139.73 204.34,140.16 204.47,140.29 207.11,140.29 207.12,140.29 207.21,140.29 208.02,141.11 209.36,141.11 209.84,141.59
  BOTTOM w0.102: v2(214.66,140.4) 214.27,140.8 UV1.K9
DQA1_23: length 30.8
  TOP w0.102: 210.08,140.8 211.73,140.8 211.75,140.78 213.49,140.78 v2(213.87,140.41)
  TOP w0.13: 210.08,140.8 209.3,140.03 v1(208.9,140.03) 207.88,140.03 206.99,139.14 206.64,139.14 206.51,139.01 206.51,138.63 206.38,138.5 206.09,138.5 205.96,138.63 205.96,139.23 205.84,139.35 205.57,139.35 205.44,139.23 205.44,138.93 205.32,138.8 205,138.8 204.66,139.14 204.22,139.14 204.09,139.01 204.09,138.58 203.96,138.46 203.67,138.46 203.54,138.58 203.54,139.01 203.41,139.14 192.79,139.14 192.31,138.66 192.31,137.28 191.99,136.96 191.83,136.96 191.51,136.63 191.51,136.48 191.19,136.16 191.03,136.16 190.71,135.83 190.71,135.23 UV3.F2
  BOTTOM w0.102: v2(213.87,140.41) 213.9,140.41 213.9,140.37 214.25,140.02 UV1.K10
DQA1_24: length 30.1
  BOTTOM w0.102: UV1.G9 211.85,140.9 211.39,141.36 211.39,141.91 211.21,142.09 210.41,142.09 209.88,142.62 209.79,142.62 209.66,142.49 209.24,142.49 209.07,142.66 208.56,142.66 208.29,142.92 208.29,143.24 207.42,144.11 207.42,144.26 207.23,144.45 207.12,144.45
  BOTTOM w0.13: 207.12,144.45 206.93,144.45 206.29,145.1 204.64,145.1 v1(203.57,146.17) 202.94,146.8 188.95,146.8 187.34,145.19 187.34,144.87 187.4,144.81 187.4,144.41 187.85,143.96 UV6.T13
DQA1_25: length 23.4
  BOTTOM w0.102: 207.12,142.16 207.86,141.42 208.63,141.42 UV1.A8
  BOTTOM w0.13: 207.12,142.16 206.55,142.16 206.44,142.27 v1(205.55,142.27) 205.16,142.66 202.93,142.66 200.07,145.52 191.16,145.52 190.7,145.06 190.7,143.67 190.39,143.36 190.23,143.36 189.91,143.04 189.91,142.43 UV6.N11
DQA1_26: length 21.2
  BOTTOM w0.102: 207.12,141.7 207.6,141.21 208.4,141.21 208.52,141.09 208.78,141.09 208.9,141.21 209.25,141.21 209.44,141.4 UV1.C8
  BOTTOM w0.13: 207.12,141.7 206.36,141.7 206.25,141.81 204.13,141.81 203.75,142.19 v1(203.45,142.19) 202.75,142.19 199.65,145.29 192.77,145.29 192.32,144.83 191.71,144.83 191.51,144.64 191.51,144.16 UV6.M13
DQA1_27: length 21.7
  BOTTOM w0.102: UV1.E8 209.98,141.4 209.62,141.03 209.43,141.03 209.4,141 209.26,141 209.25,141.01 208.98,141.01 208.86,140.89 208.44,140.89 208.32,141.01 207.36,141.01 207.13,141.24 207.12,141.24
  BOTTOM w0.13: 207.12,141.24 206.17,141.24 206.07,141.34 203.95,141.34 203.74,141.56 v1(201.85,141.56) 201.53,141.56 200.21,140.23 191.68,140.23 191.45,140.46 191.45,141.7 UV6.M11
DQA1_28: length 30.5
  BOTTOM w0.102: UV1.A6 208.65,143.17 207.63,144.19 207.63,144.41 207.12,144.92
  BOTTOM w0.13: 207.12,144.92 206.48,145.56 204.83,145.56 203.13,147.26 v1(195.03,147.26) 188.46,147.26 186.25,145.06 186.25,144.65 186.75,144.16 187.09,144.16 187.46,143.79 187.46,143.61 187.77,143.29 189.58,143.29 189.98,143.7 UV6.N13
DQA1_29: length 35.4
  BOTTOM w0.102: 207.44,146.55 207.44,146.21 207.71,145.93 207.71,145.62 208.05,145.28 208.05,144.85 208.24,144.66 208.24,144.63 208.56,144.31 208.67,144.31 209.09,143.89 209.09,143.65 209.45,143.29 UV1.C6
  BOTTOM w0.13: UV6.T11 187.51,141.76 186.29,141.76 185.4,142.64 185.4,146.27 185.73,146.6 185.73,146.61 187.76,148.64 194.99,148.64 195.55,149.2 v1(197.19,149.2) 199.03,149.2 199.59,148.64 203.7,148.64 204.98,147.36 206.62,147.36 207.44,146.55
DQA1_30: length 30.5
  BOTTOM w0.102: UV1.E6 210.17,143 210,142.82 209.71,142.82 209.58,142.69 209.32,142.69 209.15,142.86 209.15,142.87 209.15,143.12 209.15,143.13 209.15,143.23 208.8,143.59 208.56,143.59 208.55,143.59 208.52,143.59 207.84,144.28 207.84,144.49 207.5,144.83 207.5,145.19 207.12,145.57
  BOTTOM w0.13: UV6.U13 186.49,143.7 186.02,144.16 186.02,145.6 188.14,147.72 v1(198.79,147.72) 203.32,147.72 205.02,146.02 206.67,146.02 207.12,145.57
DQA1_31: length 31.3
  BOTTOM w0.102: 207.79,145.11 207.79,144.82 208.04,144.57 208.04,144.44 208.59,143.9 UV1.A5
  BOTTOM w0.13: 207.79,145.11 207.79,145.24 207.5,145.53 207.5,145.84 206.86,146.48 205.21,146.48 203.51,148.18 v1(201.19,148.18) 199.35,148.18 198.79,148.74 195.84,148.74 195.28,148.18 187.95,148.18 186.19,146.42 186.19,146.41 185.79,146 185.79,142.8 186.54,142.05 187,142.05 UV6.U11
DQB0_0: length 21.9
  TOP w0.102: UV7.T13 201.13,156.48 201.13,155.3 201.26,155.17 201.5,155.17 201.63,155.05 201.63,154.63 201.57,154.57
  TOP w0.13: 201.57,154.57 201.5,154.51 200.47,154.51 200.34,154.38 200.34,154.08 200.47,153.95 201.5,153.95 201.63,153.82 201.63,150.38 203.64,148.37 208.01,148.37 v2(209.09,147.29)
  BOTTOM w0.102: UV1.C5 209.45,144.22 209.86,144.63 209.86,146.12 209.18,146.8 209.18,147.21
  BOTTOM w0.13: 209.18,147.21 v2(209.09,147.29)
DQB0_1: length 22.9
  TOP w0.102: UV7.N13 202.79,157.22 199.77,157.22 199.19,156.63 199.19,155.79
  TOP w0.13: v2(208.07,146.93) 208.03,146.89 v1(206.74,146.89) 203.83,146.89 200.71,150 200.71,152.4 199.4,153.71 199.4,154.57 199.19,154.79 199.19,155.79
  BOTTOM w0.102: UV1.C3 209.45,144.86 208.62,145.7 208.62,146.39 v2(208.07,146.93)
DQB0_2: length 20.7
  TOP w0.102: 211.97,147.21 v2(211.17,146.41)
  TOP w0.13: UV7.M13 203.91,156.62 203.57,156.28 203.57,155.95 203.59,155.94 203.59,155.23 203.23,154.87 203.23,151.02 204.3,149.95 209.62,149.95 209.87,149.69 210.83,149.69 212.38,148.14 212.38,147.61 211.97,147.21
  BOTTOM w0.102: v2(211.17,146.41) 210.65,145.89 210.65,145.43 210.35,145.13 UV1.E3
DQB0_3: length 35.6
  TOP w0.13: v2(208.16,145.94) 207.73,145.51 203.26,145.51 201.24,147.52 200.34,147.52 197.95,149.91 197.95,158.5 200.16,160.71 202.87,160.71 203.51,160.06 203.51,159.17 203.11,158.77 UV7.N11
  BOTTOM w0.102: UV1.E1 210.35,145.92 209.66,146.61 209.66,147.21 ; 207.67,147.21 207.67,146.63 208.16,146.14 v2(208.16,145.94)
  BOTTOM w0.13: 207.67,147.21 207.67,147.47 208.09,147.89 209.36,147.89 209.66,147.59 209.66,147.21
DQB0_4: length 35.9
  TOP w0.13: UV7.M11 203.92,158.49 204.36,158.94 204.36,159.97 203.13,161.2 199.96,161.2 197.43,158.67 197.43,149.78 200.32,146.89 201.23,146.89 203.09,145.02 207.17,145.02 207.51,144.68 209.76,144.68 v2(210.1,144.34)
  BOTTOM w0.102: v2(210.1,144.34) 210.35,144.34 211.25,145.24 UV1.F1
DQB0_5: length 26.5
  TOP w0.102: 199.37,158.49 199.73,158.85 200.35,158.85 UV7.T11 ; 207.12,145.97 207.5,146.35 208.41,146.35 208.57,146.19 208.57,145.76 209.08,145.25 210.04,145.25 v2(210.93,144.36)
  TOP w0.13: 199.37,158.49 198.43,157.55 198.43,153.38 199.77,152.05 199.77,149.77 199.57,149.57 199.57,149.2 200.78,147.98 201.43,147.98 203.45,145.97 v1(203.74,145.97) 207.12,145.97
  BOTTOM w0.102: v2(210.93,144.36) 210.93,144.36 211.25,144.69 UV1.F3
DQB0_6: length 24.6
  TOP w0.102: v2(211.56,143.59) 211.56,144.29 209.3,146.55 207.24,146.55 207.12,146.43 ; 198.94,154.57 198.94,157.26 199.91,158.23 UV7.U11
  TOP w0.13: 198.94,154.57 198.94,153.52 200.25,152.21 200.25,149.81 v1(201.27,148.8) 203.64,146.43 207.12,146.43
  BOTTOM w0.102: UV1.F5 211.25,143.9 v2(211.56,143.59)
DQB0_7: length 22.3
  TOP w0.102: v2(212.38,143.8) 212.38,144.01 209.5,146.89 208.77,146.89 208.45,147.21
  TOP w0.13: UV7.U13 199.43,156.41 199.43,155.22 199.86,154.79 199.86,153.9 201.17,152.59 v1(201.17,151.54) 201.17,150.19 203.8,147.56 208.09,147.56 208.45,147.21
  BOTTOM w0.102: v2(212.38,143.8) 212.38,144.07 UV1.G4
DQB0_8: length 45.9
  BOTTOM w0.102: 203.58,167.78 203.58,166.36 203.87,166.08 203.99,166.08 204.23,165.83 204.23,165.56 203.99,165.32 203.87,165.32 203.49,164.93 203.49,164.81 203.11,164.43 UV8.E4 ; UV1.H5 212.85,144.1 212.83,144.1 212.04,144.89 211.92,144.89 211.75,145.07 211.75,145.32 211.77,145.35 211.77,146.9 211.58,147.09 211.58,147.21
  BOTTOM w0.13: 203.58,167.78 203.23,168.13 198.08,168.13 197.05,167.1 197.05,154.94 198.89,153.1 202.13,153.1 v1(202.87,152.36) 205.48,149.75 209.82,149.75 211.58,147.99 211.58,147.21
DQB0_9: length 48.8
  BOTTOM w0.102: 204.65,167.78 205.13,167.3 205.13,166.99 205.09,166.95 205.09,165.62 204.71,165.24 204.6,165.24 204.3,164.94 204.3,164.49 UV8.F4 ; 211.12,147.21 211.55,146.77 211.55,145.42 211.54,145.41 211.54,144.98 211.75,144.78 211.75,144.15 211.97,143.92 211.97,143.67 212.23,143.41 212.44,143.41 UV1.H6
  BOTTOM w0.13: 211.12,147.21 211.12,147.8 209.63,149.29 205.29,149.29 v1(204.45,150.13) 201.96,152.62 198.72,152.62 196.59,154.75 196.59,167.36 197.84,168.6 203.82,168.6 204.65,167.78
DQB0_10: length 42.6
  BOTTOM w0.102: UV8.F2 203.54,166.06 203.03,166.06 202.78,166.32 202.78,167.3 ; UV1.J4 213.55,144.3 212.91,144.3 212.55,144.67 212.55,145.72 212.56,145.73 212.56,146.41 212.04,146.92 212.04,147.21
  BOTTOM w0.13: 202.78,167.3 202.4,167.67 198.27,167.67 197.51,166.91 197.51,155.13 199.08,153.56 203.56,153.56 205.54,151.58 205.54,151.05 206.29,150.29 v1(207.42,150.29) 209.93,150.29 212.04,148.18 212.04,147.21
DQB0_11: length 41.5
  BOTTOM w0.102: UV1.K6 214.08,143.37 214.08,145.25 213.77,145.55 213.77,146 213.22,146.56 212.85,146.56 212.5,146.91 212.5,147.21 ; UV8.E2 202.73,166.08 202.27,166.08 201.94,166.41 201.94,167.1 201.59,167.44
  BOTTOM w0.13: 212.5,147.21 212.5,148.37 210.12,150.75 206.64,150.75 206.17,151.22 206.17,151.6 v1(205.41,152.36) 203.75,154.02 199.42,154.02 197.97,155.47 197.97,166.52 198.89,167.44 201.59,167.44
DQB0_12: length 38.7
  BOTTOM w0.102: UV1.K5 214.75,143.7 214.75,143.07 214.96,142.85 215.93,142.85 216.15,143.07 216.15,143.46 215.75,143.87 215.75,144.12 215.76,144.14 215.76,144.66 215.75,144.67 215.75,144.92 215.76,144.94 215.76,145.46 215.68,145.53 215.68,146.31 215.59,146.41 215.59,147.21 ; 199.78,162.47 199.59,162.66 199.59,163.77 UV8.A4
  BOTTOM w0.13: 215.59,147.21 215.59,149.81 v1(215.06,150.34) 213.32,152.08 213.32,154.71 213.74,155.14 213.74,160.95 212.48,162.22 210.18,162.22 209.71,161.75 200.5,161.75 199.78,162.47
DQB0_13: length 36.6
  BOTTOM w0.102: UV1.L4 214.88,144.77 214.88,145.6 214.38,146.09 214.38,146.82 214.67,147.1 214.67,147.21 ; 199.8,161.49 199.18,162.11 199.18,165.03 199.84,165.7 UV8.A2
  BOTTOM w0.13: 199.8,161.49 200.33,160.96 210.51,160.96 211.02,161.47 212.02,161.47 213.05,160.44 213.05,155.78 212.4,155.13 212.4,151.7 v1(213.4,150.7) 214.67,149.43 214.67,147.21
DQB0_14: length 38.2
  BOTTOM w0.102: 199.93,161.89 199.38,162.44 199.38,164.91 199.75,165.28 200.29,165.28 UV8.B2 ; UV1.M6 215.85,143.43 215.54,143.74 215.54,144.26 215.55,144.27 215.55,144.52 215.54,144.54 215.54,145.06 215.55,145.07 215.55,145.32 215.48,145.4 215.48,146.09 215.13,146.43 215.13,147.21
  BOTTOM w0.13: 215.13,147.21 v1(215.13,148.87) 215.13,149.62 212.86,151.89 212.86,154.9 213.41,155.45 213.41,160.72 212.29,161.84 210.75,161.84 210.29,161.38 200.44,161.38 199.93,161.89
DQB0_15: length 33.3
  BOTTOM w0.102: 200.87,162.18 200.5,162.18 200.29,162.39 200.29,163.37 200.71,163.79 UV8.B4 ; UV1.M1 215.89,145.76 215.89,147.04 216.05,147.21
  BOTTOM w0.13: 200.87,162.18 209.36,162.18 209.72,162.55 212.89,162.55 214.4,161.04 214.4,157.73 214.2,157.53 214.2,156.05 214.81,155.45 214.81,154.45 216.05,153.21 v1(216.05,151.55) 216.05,147.21
DQB0_16: length 29
  IN1 w0.127: v2(221.37,149.69) 220.81,150.25 220.81,150.78 215.84,155.75 215.84,158.08 214.44,159.49 212.77,159.49 212.57,159.29 208.7,159.29 v2(208.31,158.9)
  BOTTOM w0.102: 216.51,147.21 216.12,146.82 216.12,145.96 216.35,145.72 216.35,145.47 216.05,145.16 UV1.M3 ; v2(208.31,158.9) UV8.M11
  BOTTOM w0.13: 216.51,147.21 216.51,148.2 v1(217.64,149.33) 218.18,149.87 221.19,149.87 v2(221.37,149.69)
DQB0_17: length 17.6
  IN1 w0.127: v2(216.77,145.69) 216.31,145.69 215.33,146.67 215.33,147.6 213.47,149.46 213.47,150.37 209.52,154.33 209.52,156.89 v2(209.11,157.29)
  BOTTOM w0.102: UV8.M13 v2(209.11,157.29) ; v2(216.77,145.69) 216.72,145.69 216.56,145.53 216.56,145.33 216.37,145.14 216.37,145 216.35,144.99 216.35,144.67 216.05,144.36 UV1.M5
DQB0_18: length 17
  IN1 w0.127: v2(209.91,157.29) 210.3,156.9 210.3,154.19 213.93,150.56 213.93,149.65 215.79,147.79 215.79,146.67 216.25,146.21 v2(216.5,146.21)
  BOTTOM w0.102: v2(216.5,146.21) 216.8,146.21 217.25,145.75 217.25,145.4 217.15,145.3 217.15,145.02 217.14,145.01 217.14,144.69 UV1.N4 ; UV8.N13 v2(209.91,157.29)
DQB0_19: length 20
  IN1 w0.127: v2(209.11,158.9) 208.72,158.5 208.72,154.48 212.95,150.25 212.95,149.34 214.88,147.41 214.88,146.7 215.38,146.19 215.38,145.47 217.1,143.75 v2(217.1,143.67)
  BOTTOM w0.102: v2(217.1,143.67) 217.45,143.33 UV1.P6 ; v2(209.11,158.9) UV8.N11
DQB0_20: length 16.3
  IN1 w0.102: 218.1,147.02 218,146.93 218,146.45 v2(217.78,146.23)
  IN1 w0.127: v2(212.31,156.49) 212.51,156.49 218.1,150.9 218.1,147.02
  BOTTOM w0.102: UV8.T13 212.31,156.49 v2(212.31,156.49) ; UV1.P5 217.41,144.24 217.41,144.6 217.35,144.67 217.35,144.92 217.62,145.2 217.83,145.2 217.98,145.35 217.98,145.7 217.78,145.89 v2(217.78,146.23)
DQB0_21: length 16.7
  IN1 w0.102: v2(218.37,146.25) 218.21,146.42 218.21,146.7 218.56,147.05 218.56,147.21
  IN1 w0.127: v2(212.28,157.25) 213.51,156.02 213.63,156.02 218.56,151.09 218.56,147.21
  BOTTOM w0.102: UV8.U13 212.63,156.89 v2(212.28,157.25) ; UV1.R4 218.88,144.83 218.88,145.18 218.74,145.32 218.74,145.83 218.37,146.2 v2(218.37,146.25)
DQB0_22: length 22.5
  IN1 w0.102: v2(218.67,142.9) 218.92,143.15 218.92,144.32 220.45,145.86 220.45,146.35 220.29,146.52
  IN1 w0.127: v2(212.31,158.9) 212.44,159.03 214.25,159.03 214.82,158.46 214.82,156.13 219.82,151.12 219.82,149.26 220.29,148.79 220.29,146.52
  BOTTOM w0.102: v2(212.31,158.9) UV8.U11 ; v2(218.67,142.9) 218.97,143.2 UV1.T6
DQB0_23: length 18.9
  IN1 w0.127: v2(219.01,146.1) 219.19,146.1 219.54,146.46 219.54,147.27 219.02,147.79 219.02,151.28 214.36,155.94 214.36,158.25 214.12,158.5 UV8.T11 v2(211.51,158.9)
  BOTTOM w0.102: v2(219.01,146.1) 219.01,145.84 UV1.T1 ; v2(211.51,158.9) UV8.T11
DQB0_24: length 27.3
  TOP w0.102: UV7.A4 v2(213.11,164.5)
  IN4 w0.102: v2(213.11,164.5) 213.16,164.44 213.16,164.05 213.72,163.49
  IN4 w0.127: 213.72,163.49 213.95,163.26 214.43,163.26 216.78,160.9 216.78,155.48 217.2,155.06 217.2,153.48 218.19,152.49 218.19,151.76 220.4,149.55 v2(220.4,149.42)
  BOTTOM w0.102: UV1.U4 220.05,144.45 219.72,144.78 219.72,144.78 219.48,145.02 219.48,145.39 219.55,145.47 219.55,145.72 219.48,145.8 219.48,146.17 219.17,146.48 218.7,146.48 218.05,147.13 218.05,147.21
  BOTTOM w0.13: v2(220.4,149.42) 218.37,149.42 218.05,149.1 218.05,147.21
DQB0_25: length 27.7
  TOP w0.102: UV7.B4 v2(212.31,164.5)
  IN4 w0.102: v2(212.31,164.5) 212.44,164.5 212.96,163.97 212.96,163.22 213.59,162.59 213.72,162.59
  IN4 w0.127: v2(219.87,148.46) 219.87,149.43 217.74,151.57 217.74,152.3 216.75,153.29 216.75,154.87 216.33,155.29 216.33,160.71 214.45,162.59 213.72,162.59
  BOTTOM w0.102: 218.61,147.21 218.61,147 218.93,146.69 219.25,146.69 219.68,146.26 219.68,145.88 219.76,145.81 219.76,145.39 219.72,145.35 219.72,145.07 219.97,144.82 220.1,144.82 220.35,144.56 220.35,144.27 220.3,144.22 220.3,143.81 220.65,143.46 UV1.V6
  BOTTOM w0.13: 218.61,147.21 218.61,147.9 v1(218.74,148.03) 219.17,148.46 v2(219.87,148.46)
DQB0_26: length 25.4
  TOP w0.102: UV7.B2 v2(211.51,165.3)
  IN4 w0.102: 213.72,164.48 213.32,164.88 212.05,164.88 211.64,165.3 v2(211.51,165.3) ; 220.94,147.21 220.94,147.13 v2(220.98,147.09)
  IN4 w0.127: 213.72,164.48 214.49,163.72 214.62,163.72 217.24,161.09 217.24,155.67 217.66,155.25 217.66,153.67 218.65,152.68 218.65,152.19 220.94,149.9 220.94,147.21
  BOTTOM w0.102: UV1.V1 220.95,145.7 220.95,146 221.28,146.32 221.28,146.79 v2(220.98,147.09)
DQB0_27: length 30.6
  TOP w0.102: UV7.A2 v2(213.11,166.1)
  IN4 w0.127: v2(213.11,166.1) 213.41,166.4 214.6,166.4 215.03,165.96 218.61,165.96 219.24,165.34 219.24,156.54 219.86,155.92 219.86,154.04 220.91,152.99 220.91,152.3 222.64,150.57 222.64,147.6 221.56,146.51 v2(220.87,146.51)
  BOTTOM w0.102: UV1.V3 220.85,145.16 220.55,145.47 220.55,145.72 220.75,145.93 220.75,146.08 220.78,146.11 220.78,146.43 v2(220.87,146.51)
DQB0_28: length 28.6
  TOP w0.102: UV7.E4 v2(209.91,164.5)
  IN4 w0.102: v2(209.91,164.5) 210.15,164.5 210.56,164.08 210.92,164.08 211.12,163.88 211.12,163.44 211.46,163.1 211.46,162.85 213.72,160.58 213.72,160.25 ; v2(219.06,147.1) 218.95,147.21
  IN4 w0.127: 218.95,147.21 218.14,148.01 218.14,148.72 215.81,151.05 215.81,151.78 214.57,153.03 214.57,154.57 214.36,154.78 214.36,159.62 213.72,160.25
  BOTTOM w0.102: UV1.Y6 222.43,143.2 222.13,143.5 221.58,143.5 221.58,143.5 221.32,143.5 221.32,143.5 220.9,143.5 220.52,143.88 220.52,144.15 220.56,144.18 220.56,144.65 220.48,144.72 220.48,145.25 220.34,145.39 220.34,145.81 220.51,145.97 220.51,146.18 220.23,146.46 219.77,146.46 219.33,146.89 219.27,146.89 v2(219.06,147.1)
DQB0_29: length 39.7
  TOP w0.102: UV7.F4 v2(208.31,163.7)
  IN4 w0.102: v2(222.28,146.05) 222.42,146.05 223.48,147.1 ; v2(208.31,163.7) 208.31,163.7 207.93,164.07 207.93,165.45 208.19,165.71 208.47,165.71 208.73,165.98 208.73,166.25 208.97,166.5 209.25,166.5 209.53,166.78 209.53,167.05 209.75,167.28 212.42,167.28 212.56,167.42 213.72,167.42
  IN4 w0.127: 213.72,167.42 219.13,167.42 220.1,166.45 220.1,158.85 221.03,157.92 221.03,156.16 220.85,155.98 220.85,154.34 221.83,153.37 221.83,152.78 222.07,152.54 222.65,152.54 223.55,151.63 223.55,147.18 223.48,147.1
  BOTTOM w0.102: v2(222.28,146.05) 222.45,145.88 UV1.Y1
DQB0_30: length 34.5
  TOP w0.102: UV7.E2 v2(209.91,166.1)
  IN4 w0.102: v2(222.29,146.63) 222.32,146.63 222.89,147.21 ; v2(209.91,166.1) 209.91,166.19 210.21,166.48 212.45,166.48 212.94,166.97 213.72,166.97
  IN4 w0.127: 213.72,166.97 218.28,166.97 219.16,166.09 219.45,166.09 219.74,165.8 219.74,156.69 220.4,156.04 220.4,154.15 221.37,153.18 221.37,152.49 223.1,150.76 223.1,147.41 222.89,147.21
  BOTTOM w0.102: UV1.Y3 222.45,145.16 222.75,145.47 222.75,145.77 222.69,145.83 222.69,146.52 222.58,146.63 v2(222.29,146.63)
DQB0_31: length 29.2
  TOP w0.102: UV7.F2 v2(209.11,165.3)
  IN4 w0.102: 219.53,147.21 219.53,146.93 219.69,146.76 219.69,145.45 221.05,144.09 221.2,144.09 v2(221.33,143.96) ; 213.72,161.02 213.67,161.07 213.67,161.32 211.91,163.08 211.91,163.84 211.65,164.1 211.34,164.1 211.12,164.31 211.12,164.67 210.89,164.9 209.44,164.9 209.11,165.23 v2(209.11,165.3)
  IN4 w0.127: 213.72,161.02 214.83,159.91 214.83,154.99 215.48,154.34 215.48,152.76 216.27,151.97 216.27,151.24 218.6,148.91 218.6,148.2 219.53,147.27 219.53,147.21
  BOTTOM w0.102: UV1.Y5 221.37,144 v2(221.33,143.96)
DQB1_0: length 43.4
  BOTTOM w0.102: UV10.F4 225.33,164.52 225.33,164.98 225.67,165.32 225.79,165.32 226.19,165.71 226.19,166.63 226.22,166.67 226.22,167.24 225.68,167.78 ; 222.56,147.21 222.56,147.17 222.9,146.83 222.9,145.98 222.97,145.91 222.97,145.39 222.81,145.24 222.81,144.66 223.07,144.4 UV1.AA4
  BOTTOM w0.13: 225.68,167.78 224.44,169.02 218.27,169.02 215.27,166.01 215.27,157.95 214.83,157.51 214.83,156.08 215.27,155.64 215.27,154.65 v1(218.36,151.55) 219.58,150.33 221.57,150.33 221.89,150.02 221.89,148.99 222.56,148.32 222.56,147.21
DQB1_1: length 40.8
  BOTTOM w0.102: 223.02,147.21 223.02,147.13 223.8,146.35 223.8,146.06 223.54,145.81 223.54,145.3 223.71,145.13 223.71,143.74 UV1.AB6 ; UV10.F2 225.39,166.17 225.39,166.63 225.46,166.7 225.46,167.33 225.01,167.78
  BOTTOM w0.13: 223.02,147.21 223.02,148.51 222.37,149.16 222.37,150.19 221.77,150.79 219.77,150.79 215.73,154.84 215.73,165.82 v1(217.17,167.27) 218.47,168.56 224.23,168.56 225.01,167.78
DQB1_2: length 33.8
  BOTTOM w0.102: 219.57,167.64 223.4,167.64 223.77,167.27 223.77,166.04 UV10.E2 ; 223.94,147.21 223.94,147.04 224.28,146.7 224.28,145.95 224.14,145.82 224.14,145.68 UV1.AB1
  BOTTOM w0.13: 219.57,167.64 219.4,167.64 216.65,164.89 216.65,155.22 220.15,151.71 222.15,151.71 v1(222.87,150.99) 223.29,150.57 223.29,149.54 223.94,148.89 223.94,147.21
DQB1_3: length 38.6
  BOTTOM w0.102: UV1.AB3 224.05,145.08 223.75,145.38 223.75,145.72 224.07,146.05 224.07,146.45 223.48,147.04 223.48,147.21 ; UV10.E4 224.47,164.45 224.47,166.78 224.58,166.89 224.58,167.21 224.01,167.78
  BOTTOM w0.13: 224.01,167.78 223.69,168.1 218.66,168.1 216.19,165.63 216.19,155.03 v1(217.81,153.4) 219.96,151.25 221.96,151.25 222.83,150.38 222.83,149.35 223.48,148.7 223.48,147.21
DQB1_4: length 31.2
  BOTTOM w0.102: UV1.AD6 225.85,143.72 226.09,143.96 226.09,144.47 226.48,144.86 226.54,144.86 226.95,145.26 226.95,145.75 227.55,146.36 227.55,147.21
  BOTTOM w0.13: UV10.A2 221.25,166.03 221.95,166.03 222.09,165.89 222.09,163.98 221.8,163.69 221.6,163.69 221.31,163.41 221.31,160.47 220.4,159.56 220.4,158.03 220.07,157.69 220.07,156.3 221.19,155.18 225.22,155.18 225.94,154.46 225.94,154.46 226.19,154.22 226.19,154.21 226.61,153.79 226.62,153.79 226.86,153.54 226.86,153.54 227.55,152.85 v1(227.55,150.39) 227.55,147.21
DQB1_5: length 27.6
  BOTTOM w0.102: UV1.AD1 225.57,145.67 225.57,146.3 226.16,146.89 226.16,147.21
  BOTTOM w0.13: UV10.B2 221.71,165.43 221.58,165.3 220.4,165.3 219.58,164.48 219.58,164.19 218.87,163.48 218.87,156.07 220.72,154.21 223.69,154.21 224.76,153.15 v1(224.76,152.69) 224.76,152.24 225,151.99 226.02,151.99 226.16,151.85 226.16,147.21
DQB1_6: length 27.1
  BOTTOM w0.102: UV1.AD3 225.67,144.78 225.99,144.78 226.11,144.9 226.11,145.3 226.2,145.39 226.2,146.06 227.09,146.96 227.09,147.21
  BOTTOM w0.13: 227.09,147.21 v1(227.09,149.1) 227.09,152.66 226.8,152.95 226.26,152.95 225.18,154.03 225.18,154.71 224.94,154.95 221.1,154.95 219.84,156.2 219.84,162.66 219.97,162.79 220.35,162.79 220.49,162.93 220.49,163.55 220.63,163.69 220.99,163.69 221.39,164.1 UV10.B4
DQB1_7: length 27.7
  BOTTOM w0.102: UV1.AD5 225.51,144.14 225.51,144.5 225.27,144.74 225.27,145.05 225.48,145.26 225.78,145.26 226,145.48 226,146.15 226.63,146.78 226.63,147.21
  BOTTOM w0.13: UV10.A4 220.86,164.05 220.26,164.05 219.33,163.12 219.33,156.34 221,154.67 224.46,154.67 224.71,154.42 224.71,153.85 225.22,153.34 225.22,152.65 225.38,152.49 226.51,152.49 226.63,152.37 v1(226.63,151.5) 226.63,147.21
DQB1_8: length 16.4
  TOP w0.102: 228.28,147.21 228.28,146.72 v2(228.8,146.2) ; UV9.N11 223.73,158.12 223.73,155.33 224.49,154.57
  TOP w0.13: 228.28,147.21 v1(226.1,149.38) 224.55,150.93 224.55,154.51 224.49,154.57
  BOTTOM w0.102: UV1.AF1 227.25,145.72 227.51,145.98 228.58,145.98 v2(228.8,146.2)
DQB1_9: length 22.7
  TOP w0.102: 219.57,158.11 219.95,158.49 UV9.U11
  TOP w0.13: 219.57,158.11 219.45,158 219.45,155.14 218.72,154.4 v1(218.72,152.19) 218.21,151.68 218.21,148.64 220.15,146.7 220.15,146.6 221.34,145.4 222.6,145.4 222.98,145.02 225.91,145.02 226.08,144.85 226.44,144.85 v2(226.93,144.36)
  BOTTOM w0.102: UV1.AF3 227.25,144.68 v2(226.93,144.36)
DQB1_10: length 24.4
  TOP w0.102: 220.36,158.04 220.92,158.04 221.37,158.49 UV9.T11
  TOP w0.13: 220.36,158.04 219.87,157.56 219.87,154.91 219.17,154.21 219.17,148.32 v1(219.61,147.88) 219.93,147.56 221.19,147.56 221.47,147.28 222.69,147.28 223.85,146.12 223.85,145.63 224.16,145.31 226.13,145.31 226.36,145.08 226.85,145.08 227.45,144.48 227.45,143.23 v2(227.85,142.83)
  BOTTOM w0.102: v2(227.85,142.83) 227.57,142.83 227.41,142.99 227.41,143.16 UV1.AF6
DQB1_11: length 18.1
  TOP w0.102: UV9.U13 221.23,156.57 221.23,154.97 220.84,154.57
  TOP w0.13: 220.84,154.57 220.09,153.83 220.09,150.35 221.36,149.09 221.98,149.09 222.86,148.2 224.21,148.2 v1(224.82,147.59) 226.15,146.26 226.75,146.26 227.41,145.6 v2(227.73,145.6)
  BOTTOM w0.102: v2(227.73,145.6) 227.75,145.58 227.75,144.7 UV1.AG4
DQB1_12: length 21.5
  TOP w0.102: UV9.T13 221.71,156.97 221.39,157.29 220.84,157.29 220.15,156.6 220.15,155.94 220.57,155.53 220.57,154.95 220.19,154.57
  TOP w0.13: v2(228.38,143.76) 228.38,143.99 227.03,145.34 226.55,145.34 225.76,146.13 224.49,146.13 222.88,147.74 222.67,147.74 221.95,148.46 220.74,148.46 219.63,149.56 v1(219.63,150.43) 219.63,154.02 220.19,154.57
  BOTTOM w0.102: v2(228.38,143.76) 228.61,144 UV1.AH5
DQB1_13: length 17.1
  TOP w0.102: UV9.N13 224.11,156.56 224.55,156.11 224.55,155.17 225.01,154.71 225.01,154.57 ; v2(229.43,142.88) 229.38,142.93 229.38,144.04 229.88,144.54 229.88,145.52 229.26,146.14 229.26,146.44 228.8,146.9 228.8,147.21
  TOP w0.13: v1(227.61,148.53) 227.61,148.53 ; 227.61,148.53 228.8,147.33 228.8,147.21 ; 227.61,148.53 225.01,151.12 225.01,154.57
  BOTTOM w0.102: v2(229.43,142.88) 229.12,143.2 UV1.AH6
DQB1_14: length 18.3
  TOP w0.102: UV9.M11 224.91,158.15 224.5,157.74 224.5,156.77 224.77,156.49 225,156.49 225.34,156.15 225.34,155.42 226.19,154.57 ; v2(229.76,143.74) 230.18,144.16 230.18,146.46 229.43,147.21
  TOP w0.13: 226.19,154.57 227.31,153.45 v1(227.31,150.85) 227.31,149.47 229.43,147.35 229.43,147.21
  BOTTOM w0.102: UV1.AJ4 229.65,143.85 v2(229.76,143.74)
DQB1_15: length 16.4
  TOP w0.102: 226.84,154.57 226.69,154.57 226.15,155.11 226.15,156.2 225.86,156.48 225.6,156.48 225.19,156.89 UV9.M13 ; v2(230.77,144.39) 230.5,144.65 230.5,146.65 230.41,146.74 230.41,147.21
  TOP w0.13: 226.84,154.57 227.95,153.47 227.95,150.57 228.2,150.32 v1(228.85,150.32) 229.11,150.32 230.41,149.01 230.41,147.21
  BOTTOM w0.102: v2(230.77,144.39) 230.45,144.7 UV1.AK3
DQB1_16: length 29.1
  TOP w0.102: v2(232.51,163.64) 232.91,164.04 UV9.B4
  IN4 w0.127: v2(227.82,141.49) 227.44,141.87 227.44,143.66 227.94,144.16 228.28,144.16 228.94,144.82 228.94,145 229.36,145.41 229.52,145.41 230.21,146.1 230.21,148.08 230.34,148.21 231.1,148.21 231.22,148.33 231.22,148.69 231.1,148.82 230.87,148.82 230.74,148.95 230.74,149.2 230.87,149.33 231.1,149.33 231.22,149.45 231.22,149.71 231.1,149.83 230.87,149.83 230.74,149.96 230.74,150.22 230.87,150.34 231.1,150.34 231.22,150.47 231.22,150.72 231.1,150.85 230.87,150.85 230.74,150.98 230.74,151.23 230.87,151.36 231.1,151.36 231.22,151.49 231.22,151.74 231.1,151.87 230.87,151.87 230.74,151.99 230.74,157.53 230.51,157.76 230.51,160.45 232.26,162.2 232.26,163.39 v2(232.51,163.64)
  BOTTOM w0.102: v2(227.82,141.49) 227.72,141.6 UV1.AF8
DQB1_17: length 30.1
  TOP w0.102: v2(233.24,163.7) 233.64,164.1 UV9.A4
  IN4 w0.127: v2(227.84,140.86) 228.28,141.31 228.28,142.74 228.26,142.76 228.26,143.09 228.49,143.32 228.71,143.32 230.51,145.12 230.51,146.72 230.67,146.88 230.67,147.62 230.79,147.75 231.14,147.75 231.26,147.62 231.26,147.35 231.39,147.22 231.76,147.22 231.88,147.35 231.88,148.49 231.68,148.69 231.68,152.26 231.55,152.38 231.33,152.38 231.2,152.51 231.2,152.76 231.33,152.89 231.55,152.89 231.68,153.02 231.68,153.27 231.55,153.4 231.33,153.4 231.2,153.53 231.2,153.78 231.33,153.91 231.55,153.91 231.68,154.03 231.68,154.46 231.55,154.58 231.35,154.58 231.22,154.71 231.22,157.66 231.45,157.89 231.45,159.03 231.32,159.17 231.32,160.39 233.24,162.32 v2(233.24,163.7)
  BOTTOM w0.102: UV1.AF9 227.77,140.8 v2(227.84,140.86)
DQB1_18: length 39.1
  TOP w0.102: v2(234.11,166.1) UV9.A2
  IN4 w0.102: 237.85,146.42 237.54,146.1 237.54,141.35 235.15,138.96 232.57,138.96 232.13,139.4 232.13,139.62 230.98,140.77 229.87,140.77 v2(229.01,141.63)
  IN4 w0.127: 237.85,146.42 238.06,146.62 238.06,147.88 237.77,148.17 237.77,155.18 237.37,155.57 237.37,156.13 236.99,156.51 236.99,164.23 235.12,166.1 v2(234.11,166.1)
  BOTTOM w0.102: v2(229.01,141.63) 228.97,141.6 UV1.AG8
DQB1_19: length 33.2
  TOP w0.102: v2(232.51,165.3) UV9.B2
  IN4 w0.102: 234.19,164.4 234.18,164.4 233.67,164.91 233.02,164.91 232.64,165.3 v2(232.51,165.3) ; v2(228.65,142.92) 228.56,142.83 228.56,142.2 228.75,142.01 229.63,142.01 229.93,142.3 230.96,142.3 231.68,141.58 233.04,141.58 235.31,143.85 235.31,146.16 234.84,146.63 234.84,147.17
  IN4 w0.127: 234.19,164.4 234.72,163.87 234.72,147.3 234.84,147.17
  BOTTOM w0.102: v2(228.65,142.92) 228.65,142.92 228.65,142.59 UV1.AG7
DQB1_20: length 43.4
  TOP w0.102: v2(230.91,166.1) UV9.E2
  IN4 w0.102: v2(230.25,140.37) 230.68,139.94 230.68,139.44 231.52,138.59 235.59,138.59 237.85,140.86 237.85,141.38 ; v2(230.91,166.1) 231.3,166.48 231.84,166.48 232.13,166.77 232.13,167.05 232.35,167.28 233.76,167.28 234.01,167.03 234.83,167.03 235.06,166.81
  IN4 w0.127: 235.06,166.81 237.52,164.34 237.52,156.62 237.83,156.32 237.83,155.76 238.22,155.37 238.22,148.36 238.51,148.07 238.51,146.05 237.9,145.44 237.9,141.43 237.85,141.38
  BOTTOM w0.102: v2(230.25,140.37) 230.25,140.37 230.25,140.41 230.63,140.8 UV1.AK9
DQB1_21: length 28.8
  TOP w0.102: v2(229.31,163.7) UV9.F4
  IN4 w0.127: v2(229.31,163.7) 229.71,164.1 233.41,164.1 233.64,163.87 233.64,161.94 232.12,160.42 232.12,155.86 232.14,155.84 232.14,148.88 232.34,148.68 232.34,145.1 231.96,144.72 231.96,143.94 232.26,143.64 232.26,142.38 v2(231.84,141.96)
  BOTTOM w0.102: UV1.AL7 231.82,142.02 231.82,141.98 v2(231.84,141.96)
DQB1_22: length 30.5
  TOP w0.102: v2(232.65,141.99) 233.26,141.99 v1(233.4,142.13) ; v2(230.11,165.3) UV9.F2
  IN4 w0.102: 234.41,146.35 234.41,144.81 233.68,144.07 233.68,143.47 233.52,143.32 233.41,143.32 233.07,142.98 233.07,142.41 v2(232.65,141.99) ; 234.36,163.87 233.52,164.71 232.56,164.71 232.13,165.14 232.13,165.43 231.87,165.69 230.5,165.69 v2(230.11,165.3)
  IN4 w0.127: 234.41,146.35 233.71,147.05 233.71,159.95 234.36,160.6 234.36,163.87
  BOTTOM w0.102: UV1.AM8 232.26,141.6 v2(232.65,141.99)
DQB1_23: length 30.5
  TOP w0.102: v2(230.91,164.5) UV9.E4
  IN4 w0.102: 232.8,147.21 232.8,144.17 232.66,144.03 v2(232.66,142.89)
  IN4 w0.127: v2(230.91,164.5) 231.3,164.89 232.05,164.89 232.5,164.44 233.39,164.44 233.99,163.83 233.99,161.43 232.92,160.35 232.92,156.33 233.26,155.99 233.26,153.3 233.13,153.18 232.72,153.18 232.6,153.05 232.6,152.7 232.72,152.58 233.13,152.58 233.26,152.45 233.26,152.17 233.13,152.04 232.72,152.04 232.6,151.92 232.6,151.55 232.72,151.42 233.13,151.42 233.26,151.29 233.26,149.97 233.13,149.85 232.72,149.85 232.6,149.72 232.6,149.44 232.72,149.31 233.13,149.31 233.26,149.19 233.26,148.91 233.13,148.78 232.93,148.78 232.8,148.65 232.8,148.27 232.93,148.15 233.13,148.15 233.26,148.02 233.26,147.62 233.13,147.5 232.93,147.5 232.8,147.37 232.8,147.21
  BOTTOM w0.102: UV1.AM7 232.25,142.48 v2(232.66,142.89)
DQB1_24: length 15.6
  IN1 w0.102: 231.12,154.57 231.12,154.81 231.02,154.91 231.02,157.28 230.51,157.78 230.51,158.49 v2(230.11,158.9) ; 231.31,147.21 231.52,147 231.52,146.3 v2(231.76,146.06)
  IN1 w0.127: 231.31,147.21 231.12,147.4 231.12,154.57
  BOTTOM w0.102: v2(231.76,146.06) 230.87,146.06 230.45,145.64 UV1.AK1 ; UV10.N11 v2(230.11,158.9)
DQB1_25: length 16.6
  IN1 w0.102: v2(229.31,158.9) 229.31,158.86 229.69,158.48 229.69,156.3 229.31,155.92 229.31,154.57
  IN1 w0.127: 229.31,154.57 229.31,153.56 229.23,153.48 229.23,150.29 229.03,150.09 229.03,147.65 v2(231.03,145.64)
  BOTTOM w0.102: UV10.M11 v2(229.31,158.9) ; UV1.AL4 231.25,144.53 230.84,144.93 230.84,145.45 v2(231.03,145.64)
DQB1_26: length 15.9
  IN1 w0.102: v2(230.11,157.29) 230.67,156.74 230.67,154.57 ; 230.67,147.21 230.67,147.08 230.82,146.93 231.03,146.93 231.31,146.65 231.31,145.98 231.44,145.85 231.44,145.57 231.94,145.07 231.94,144.56 231.73,144.35 v2(231.73,143.62)
  IN1 w0.127: 230.67,154.57 230.67,147.21
  BOTTOM w0.102: UV1.AM6 232.15,143.2 v2(231.73,143.62) ; v2(230.11,157.29) UV10.M13
DQB1_27: length 13.3
  IN1 w0.102: 229.76,154.57 229.76,155.33 229.69,155.41 229.69,155.96 230.09,156.36 v2(230.09,156.48) ; 230.21,147.21 230.21,147.18 v2(230.91,146.48)
  IN1 w0.127: 230.21,147.21 230.21,149.62 229.76,150.07 229.76,154.57
  BOTTOM w0.102: UV1.AM1 232.16,145.71 232.16,146.2 231.88,146.48 v2(230.91,146.48) ; v2(230.09,156.48) 230.09,156.48 UV10.N13
DQB1_28: length 16.2
  IN1 w0.102: v2(232.51,158.9) 232.51,158.75 232.92,158.34 232.92,156.09 234.01,155 234.01,154.57 ; 234.01,147.21 234.01,146.75 233.61,146.35 233.61,145.45 v2(233.35,145.19)
  IN1 w0.127: 234.01,154.57 234.01,147.21
  BOTTOM w0.102: UV10.T11 v2(232.51,158.9) ; v2(233.35,145.19) 232.85,144.69 UV1.AN4
DQB1_29: length 16.5
  IN1 w0.102: 234.92,147.21 234.92,146.01 233.61,144.7 233.61,144.03 v2(233.25,143.67) ; 234.92,154.57 234.92,156.49 v2(234.11,157.29)
  IN1 w0.127: 234.92,147.21 234.92,154.57
  BOTTOM w0.102: v2(233.25,143.67) 233.25,144.41 233.63,144.8 UV1.AP3 ; v2(234.11,157.29) UV10.U13
DQB1_30: length 13.1
  IN1 w0.102: v2(233.31,157.29) 233.7,156.9 233.7,156.16 234.46,155.4 234.46,154.57 ; v2(233.99,146.09) 234.46,146.56 234.46,147.21
  IN1 w0.127: 234.46,154.57 234.46,147.21
  BOTTOM w0.102: v2(233.99,146.09) 233.65,145.74 UV1.AP1 ; v2(233.31,157.29) UV10.T13
DQB1_31: length 18.6
  IN1 w0.102: 236.24,147.21 236.24,146.7 234.48,144.94 234.48,144.09 v2(234.07,143.68) ; v2(233.31,158.9) 233.31,158.72 233.72,158.31 233.72,157.92 233.94,157.7 234.24,157.7 235.06,156.88
  IN1 w0.127: 235.06,156.88 235.8,156.14 235.8,155.72 236.24,155.28 236.24,147.21
  BOTTOM w0.102: UV10.U11 v2(233.31,158.9) ; v2(234.07,143.68) 233.75,144 UV1.AP5
DRAM_RST#: length 129.3
  TOP w0.102: RV179.1 225.26,139.09 v2(225.66,138.68) 225.7,138.68 226.07,138.32 v1(226.07,138.24) ; UV3.J2 193.45,134.9 v2(193.05,135.31) ; RV177.2 205.77,169.68 205.77,168.87 206.77,167.87 206.77,166.16 UV7.J2 206.25,165.7 v2(205.85,165.3) ; v2(193.05,124.3) UV5.J2 ; v2(226.91,165.3) UV9.J2
  IN1 w0.102: v2(226.91,165.3) 224.83,165.3 224.13,164.59 224.13,161.92 223.12,160.92 223.12,159.65 222.53,159.06 222.53,157.92 222.61,157.84 222.61,156.6 222.01,156 222.01,149.4 221.22,148.6 221.22,147.59 221.6,147.21 221.6,146.57 220.95,145.92 220.95,143.8 221.22,143.53 221.22,139.84 221.98,139.08 225.28,139.08 225.66,138.7 v2(225.66,138.68) ; v2(200.96,160.3) 200.96,160.31 200.55,160.72 199.89,160.72 198.29,159.12 198.29,153.81 193.85,149.36 193.85,144.22 193.31,143.69 192.92,143.69 192.89,143.71 192.01,143.71 191.78,143.48 191.78,142.43 191.88,142.33 191.88,141.49 191.47,141.08 191.47,136.06 191.85,135.68 192.49,135.68 192.86,135.31 v2(193.05,135.31)
  IN4 w0.102: v2(193.05,124.3) 193.05,124.37 192.64,124.78 192.64,128.37 193.1,128.83 193.1,132.77 192.62,133.25 192.62,134.66 193.05,135.09 v2(193.05,135.31) ; v2(226.91,165.3) 226.54,165.67 226.54,167.54 226.17,167.91 207.37,167.91 206.71,167.24 206.71,166.22 205.85,165.36 v2(205.85,165.3) 204.52,165.3 204.11,165.71 199.03,165.71 198.08,164.76 198.08,162.15 199.36,160.87 200.39,160.87 v2(200.96,160.3)
  BOTTOM w0.102: UV7.J2 206.25,165.7 v2(205.85,165.3) ; v2(193.05,135.31) 193.45,134.9 UV3.J2 ; v2(193.05,124.3) UV5.J2 ; v2(226.91,165.3) UV9.J2
DRAM_RST#_R: length 3.9
  TOP w0.102: RV178.2 228.16,139.37 RV180.2 229.04,138.26 v2(228.61,137.83)
  BOTTOM w0.102: UV1.AH11 228.88,139.2 228.47,138.79 228.47,137.97 v2(228.61,137.83)
DSCHRG_MOSFET_GC: length 3
  TOP w0.254: PU800.29 148.04,169.03 147.83,169.24 v1(147.38,169.24) 146.93,169.24 146.62,168.92 PR893.2
DSWODVREN: length 8.3
  BOTTOM w0.089: 210.36,59.77 210.19,59.94 210.19,60.92 209.95,61.16 209.95,61.29 209.75,61.49 209.75,61.82 209.52,62.06 UH1.C8
  BOTTOM w0.102: 210.36,59.77 210.38,59.75 210.73,59.75 211.13,60.15 211.6,60.15 211.89,59.86 v1(211.89,59.65) 211.3,59.06 211.3,58.1 RH67.1 RH81.2
DVPDATA_0: length 5.5
  BOTTOM w0.102: UV1.AU1 236.17,146.32 240.52,146.32 T109.1
DVPDATA_1: length 6.4
  BOTTOM w0.102: UV1.AU3 234.97,145.27 234.97,146.35 235.31,146.7 239.25,146.7 T110.1
DVPDATA_2: length 6.3
  BOTTOM w0.102: T111.1 241.66,145.94 237.35,145.94 236.25,144.84 UV1.AW3
DYN_TUR_CURRNT_SET#: length 315.9
  TOP w0.102: U51.A35 281.35,116.66 281.15,116.87 281.15,117.06 280.72,117.48 v2(280.7,117.48) 280.47,117.72 R1171.2
  TOP w0.254: v2(73.63,177.11) 73.72,177.03 73.72,175.44 73.88,175.27 PQ709.2
  IN3 w0.127: v2(75.33,181.58) 75.75,181.17 75.75,179.35 78.18,176.92 81.9,176.92 86.37,172.45 86.37,171.79 90.11,168.06 94.47,168.06 94.96,168.55 96.72,168.55 96.94,168.34 97.66,168.34 97.9,168.58 101.89,168.58 102.68,167.79 108.98,167.79 111.64,165.13 111.64,163.98 112.19,163.44 112.19,161.62 112.52,161.29 114.71,161.29 115.93,162.51 119.3,162.51 120.15,163.36 120.82,163.36 121.24,162.94 137.37,162.94 137.52,163.09 140.5,163.09 140.8,162.79 141.08,162.51 146.67,162.51 148.83,164.67 149.04,164.67 153.66,164.67 156.22,167.23 156.22,167.93 155.7,168.45 155.7,169.32 156.4,170.01 156.4,170.97 156.7,171.28 156.94,171.52 156.94,172.18 157.72,172.96 159.62,172.96 162.27,175.6 163.07,175.6 163.77,176.31 163.77,177.22 164.02,177.47 164.51,177.47 165.09,176.89 169.52,176.89 171.49,178.86 171.49,179.51 171.82,179.84 172.8,179.84 173.12,180.16 173.86,180.16 174.37,180.67 178.23,180.67 179.77,182.21 180.64,182.21 181.36,181.48 186,181.48 187.98,183.46 189.64,183.46 190.5,182.6 192.92,182.6 193.65,183.32 202.9,183.32 204.53,181.69 206.4,181.69 206.8,182.09 206.95,182.09 207.45,182.59 211.2,182.59 213.24,184.63 216.91,184.63 221.09,188.81 221.16,188.81 221.18,188.83 239.15,188.83 240.27,187.72 247.7,187.72 248.79,188.81 252.26,188.81 252.98,188.1 257.42,188.1 258.08,188.76 259.52,188.76 261.7,186.58 264.62,186.58 273.12,178.08 273.12,177.01 273.83,176.29 273.83,174.39 273.17,173.73 273.17,171.69 273.44,171.43 273.44,168.38 274.01,167.81 274.01,165.69 272.17,163.85 272.17,149.75 274.24,147.68 274.24,147.36 277.01,144.59 277.01,134 277.22,133.78 277.22,127.14 276.22,126.14 276.22,121.59 276.49,121.32 276.94,121.32 277.36,121.74 277.36,122.44 277.61,122.68 278.07,122.68 278.3,122.45 279.05,122.45 279.88,121.63 279.88,118.31 v2(280.7,117.48)
  BOTTOM w0.102: v2(75.33,181.58) 75.33,178.82 v1(74.49,177.98) v2(73.63,177.11)
DYN_TURB_PWR_ALRT#: length 4.3
  TOP w0.102: v1(261.04,47.78) 260.26,48.56 R796.2 260.71,48.91 261.15,49.34 261.46,49.34 261.86,49.73 262.2,49.73 262.35,49.89 U46.A46
EC5048_TX: length 264.1
  TOP w0.102: v2(302.1,173) 302.56,173.46 v2(302.56,179.98) ; v2(272.07,49.36) 272.29,49.14 U46.B2 ; R806.1 v2(278.04,46.81) 279.65,46.81 v1(281.33,48.49) 281.33,53.99 281.53,54.19 281.53,58.97 283.54,60.97 283.54,61.15 v2(283.61,61.23)
  IN3 w0.127: v2(288.51,100.66) 288.51,100.28 287.75,99.52 287.14,99.52 285.61,97.98 282.37,97.98 278.49,94.1 278.49,67.35 283.85,62 283.85,61.46 v2(283.61,61.23) ; v2(278.04,46.81) 277.2,47.65 274.13,47.65 273.63,48.15 273.63,48.78 273.05,49.36 v2(272.07,49.36)
  BOTTOM w0.102: R849.2 324.83,159.12 326.03,159.12 326.72,159.8 326.72,160.75 326.64,160.82 326.64,161.19 326.91,161.46 JDEG2.9 ; R849.2 324.09,158.89 322.94,158.89 319.01,162.83 319.01,163.05 317.81,164.25 317.81,171.41 316.23,173 302.13,173 302.1,173.02 v2(302.1,173) ; R849.2 323.52,157.81 322.22,157.81 320.63,156.22 320.63,154.01 319.54,152.91 319.54,132 319.35,131.81 319.35,123.15 314.75,118.55 314.75,106.6 307.86,99.7 289.47,99.7 v2(288.51,100.66) ; JMINI2.17 260.65,190.31 261.81,191.46 274.18,191.46 274.6,191.05 290.19,191.05 291.02,190.22 292.45,190.22 293.68,188.99 293.68,182.99 292.27,181.58 292.27,179.84 292.72,179.4 295.12,179.4 295.89,180.17 302.43,180.17 302.56,180.05 v2(302.56,179.98)
EC_32KHZ_ECE5048: length 93.2
  TOP w0.102: U51.B62 288.47,109.74 288.32,109.88 288.32,110.27 v2(288.75,110.69) ; v2(261.81,57.58) 261.97,57.58 262.64,56.91 262.95,56.91 263.23,56.64 U46.B35
  IN1 w0.102: v2(261.81,57.58) 262.23,57.58 262.52,57.86 262.52,60.32 263.45,61.25 265.87,61.25 267.55,62.93 267.55,64.71 269.17,66.33 270.33,66.33 272.46,68.47 272.46,68.75 273.71,69.99 v2(273.71,70.71)
  IN2 w0.127: v2(269.15,109.25) 269.21,109.31 269.39,109.31 271.15,111.07 274.26,111.07 274.86,110.46 275.46,110.46 276.04,109.88 277.14,109.88 277.39,110.13 278.02,110.13 278.42,110.53 279.23,110.53 279.41,110.35 279.9,110.35 280.11,110.14 281,110.14 281.33,110.46 285.83,110.46 286.06,110.69 286.06,111.1 286.36,111.39 287.23,111.39 287.28,111.34 288.1,111.34 v2(288.75,110.69)
  BOTTOM w0.102: v2(269.15,109.25) 269.21,109.18 269.21,102.87 267.44,101.1 267.44,97.84 266.09,96.49 v1(266.09,94.23) 266.09,89.35 265.15,88.4 265.15,85.9 265.62,85.43 266.01,85.43 266.95,84.49 266.95,74.3 271.23,70.01 273.46,70.01 273.71,70.26 v2(273.71,70.71)
EC_WAKE#: length 212.5
  TOP w0.102: v2(288.34,117.13) 288.97,117.76 U51.B23 ; v2(219.36,54.71) 220.67,54.71 224.68,50.7 224.68,50.45 225.21,49.92 v1(227.63,49.92) 237.07,49.92 237.92,49.07 239.34,49.07 242.57,45.85 242.57,44.26 v2(243.37,43.46)
  IN1 w0.089: 212.14,61.54 210.71,62.97 210.71,64.9 208.61,66.99 207.12,66.99 206.81,66.68 v2(206.81,66.12)
  IN1 w0.102: v2(280.08,54.24) 280.08,55.55 280.64,56.11 280.64,61.46 277.83,64.27 277.63,64.47 277.63,91.85 287.01,101.23 306.16,101.23 312.44,107.52 v2(312.44,107.68) ; 212.14,61.54 212.14,61.33 213.3,60.16 213.3,59.33 214.31,58.33 215.82,58.33 216.51,57.65 216.51,56.8 218.1,55.21 218.1,55.1 218.64,54.56 219.21,54.56 v2(219.36,54.71)
  IN2 w0.127: v2(280.08,54.24) 280.74,53.58 280.74,50.8 278.49,48.55 277.99,48.55 275.84,46.4 275.84,46.1 273.46,43.73 265.43,43.73 264.13,42.43 263.56,42.43 262.4,43.59 262.4,44.25 262.01,44.64 260.45,44.64 259.76,43.95 255.96,43.95 253.37,41.36 245.02,41.36 243.77,42.61 243.76,42.61 243.37,43 v2(243.37,43.46)
  BOTTOM w0.089: UH1.R11 206.64,66.28 v2(206.81,66.12)
  BOTTOM w0.102: v2(312.44,107.68) 310.76,109.36 299.79,109.36 295.38,113.77 295.38,114.16 294.49,115.05 291.76,115.05 291.62,115.19 289.31,115.19 288.34,116.17 v2(288.34,117.13) ; v2(219.36,54.71) 219.71,55.06 RH196.1 219.51,55.31 RH216.1
ECE5048_PWRGD: length 12.5
  TOP w0.102: U50.1 277.49,122.71 277.16,122.38 277.16,122.19 v2(276.72,121.74) ; v2(281.34,117.45) 281.63,117.16 U51.A34
  IN3 w0.127: v2(281.34,117.45) 280.13,118.66 280.13,121.73 279.16,122.71 278.41,122.71 278.18,122.94 277.5,122.94 277.11,122.54 277.11,122.08 276.77,121.74 v2(276.72,121.74)
  BOTTOM w0.102: v2(281.34,117.45) v1(281.34,116.93)
EDCA0_0: length 34.1
  TOP w0.102: v2(207.94,119.96) 208.49,119.4 208.49,116.99 208.11,116.61 208.11,116.22
  TOP w0.13: UV5.R13 188.24,115.48 188.24,114.3 188.43,114.11 188.77,114.11 191.03,111.85 196.06,111.85 196.4,112.19 199.5,112.19 199.84,111.85 202.11,111.85 202.65,112.38 202.99,112.38 203.12,112.51 203.12,113.07 203.25,113.19 203.66,113.19 203.79,113.07 203.79,112.53 203.89,112.43 204.52,112.43 204.73,112.65 204.73,112.83 204.3,113.26 204.3,113.44 204.57,113.72 204.75,113.72 205.19,113.29 205.37,113.29 205.65,113.56 205.65,113.75 205.5,113.89 205.5,114.07 205.78,114.35 205.96,114.35 206.1,114.2 206.29,114.2 208.11,116.03 208.11,116.22
  BOTTOM w0.102: UV1.C34 209.07,120.22 208.19,120.22 v2(207.94,119.96)
EDCA0_1: length 34.1
  BOTTOM w0.102: UV4.C2 188.24,125.11 187.55,125.11 187.38,125.27 187.38,125.69 187.3,125.78 187.3,126.16 187.52,126.39 ; 207.12,124.29 207.44,124.29 207.69,124.04 208.17,124.04 208.44,124.3 208.86,124.3 208.88,124.28 209.22,124.28 209.53,124.6 UV1.D29
  BOTTOM w0.13: 187.52,126.39 187.84,126.71 187.84,126.95 188.21,127.31 189.54,127.31 189.67,127.19 189.67,127.01 189.8,126.89 190.06,126.89 190.19,127.01 190.19,127.19 190.32,127.31 190.58,127.31 190.71,127.19 190.71,127.01 190.84,126.89 191.1,126.89 191.23,127.01 191.23,127.19 191.36,127.31 191.62,127.31 191.75,127.19 191.75,127.01 191.88,126.89 192.13,126.89 192.26,127.01 192.26,127.19 192.39,127.31 192.65,127.31 192.78,127.19 192.78,127.01 192.91,126.89 193.17,126.89 193.3,127.01 193.3,127.19 193.43,127.31 193.69,127.31 193.82,127.19 193.82,127.01 193.95,126.89 194.21,126.89 194.34,127.01 194.34,127.19 194.47,127.31 194.73,127.31 194.86,127.19 194.86,127.01 194.98,126.89 195.24,126.89 195.37,127.01 195.37,127.19 195.5,127.31 195.76,127.31 195.89,127.19 195.89,127.01 196.02,126.89 196.28,126.89 196.41,127.01 196.41,127.19 196.54,127.31 196.8,127.31 196.93,127.19 196.93,127.01 197.06,126.89 197.32,126.89 197.45,127.01 197.45,127.19 197.58,127.31 197.83,127.31 197.96,127.19 197.96,127.01 198.09,126.89 198.35,126.89 198.48,127.01 198.48,127.19 198.61,127.31 199.45,127.31 199.65,127.11 199.65,126.61 199.93,126.33 200.26,126.33 201.15,125.44 201.15,125.02 201.44,124.73 201.44,124.17 201.57,124.04 201.95,124.04 202.08,124.17 202.08,124.47 202.21,124.6 202.56,124.6 202.69,124.47 202.69,124.19 202.84,124.04 v1(203.75,124.04) 204.7,124.04 204.95,124.29 207.12,124.29
EDCA0_2: length 22.6
  IN1 w0.127: v2(198.65,115.49) 199.08,115.06 200.36,115.06 200.63,115.33 200.63,115.66 200.56,115.73 200.87,116.04 200.87,116.07 201.28,116.48 201.28,116.66 203.28,118.67 203.28,120.4 205.55,122.66 205.55,125.31 205.4,125.45 v2(205.4,127.39)
  BOTTOM w0.102: UV1.D25 209.85,127.55 209.8,127.5 209.23,127.5 209.14,127.42 208.95,127.42 208.86,127.5 207.93,127.5 207.39,128.05 207.12,128.05 ; UV4.R13 v2(198.65,115.49)
  BOTTOM w0.13: 207.12,128.05 v1(206.17,128.05) 205.63,128.05 205.4,127.81 v2(205.4,127.39)
EDCA0_3: length 16.2
  TOP w0.102: v2(198.65,125.1) UV5.C2
  IN4 w0.127: v2(208.04,129.63) 207.62,129.22 201.69,129.22 199.04,126.57 199.04,125.49 v2(198.65,125.1)
  BOTTOM w0.102: UV1.E20 209.75,131.3 208.89,131.3 208.67,131.08 208.48,131.08 208.24,130.84 208.24,129.84 v2(208.04,129.63)
EDCA1_0: length 16.5
  IN1 w0.127: v2(198.65,134.49) 199.05,134.9 199.57,134.9 200.75,136.08 200.75,136.55 200.63,136.68 200.63,137.32 200.81,137.5 203.22,137.5 203.67,137.95 207.03,137.95 207.75,137.22 v2(207.75,136.02)
  BOTTOM w0.102: v2(198.65,134.49) UV6.C2 ; v2(207.75,136.02) 207.75,135.97 208.21,135.51 208.87,135.51 208.95,135.43 209.66,135.43 210.1,135 UV1.E16
EDCA1_1: length 20.3
  TOP w0.102: UV3.R13 v2(198.65,144.1)
  IN4 w0.102: v2(207.96,138.44) 208.27,138.44 208.52,138.7 208.52,140.89 207.48,141.93 207.12,141.93
  IN4 w0.127: 207.12,141.93 206.93,141.93 206.2,142.66 203.23,142.66 203.13,142.76 201.28,142.76 200.93,142.41 200.93,141.88 200.32,141.27 199.31,141.27 199.06,141.53 199.06,143.47 198.65,143.88 v2(198.65,144.1)
  BOTTOM w0.102: UV1.E12 210.05,138.2 209.95,138.29 209.95,138.46 209.66,138.75 209.25,138.75 209.1,138.6 209,138.6 208.89,138.71 208.35,138.71 208.07,138.44 v2(207.96,138.44)
EDCA1_2: length 38.1
  TOP w0.102: 207.12,134.21 207.75,134.21 208.72,135.18 210.27,135.18 210.88,135.79 210.88,136.46 211.21,136.8 211.21,137.42 211.48,137.68 212.57,137.68 212.81,137.92 213.08,137.92 213.52,138.36 213.52,139.27 v2(213.87,139.62)
  TOP w0.13: UV3.C2 188.31,135.23 186.91,135.23 186.31,134.64 186.31,133.31 188.79,130.83 200.19,130.83 203.56,134.21 v1(204.2,134.21) 207.12,134.21
  BOTTOM w0.102: UV1.J10 213.49,140 v2(213.87,139.62)
EDCA1_3: length 28
  BOTTOM w0.102: UV1.D7 209.48,142.2 209.18,141.89 208.92,141.89 208.91,141.9 208.14,141.9 207.86,142.18 207.86,142.61 208.02,142.77 208.02,143.21 207.58,143.65 207.12,143.65
  BOTTOM w0.13: 207.12,143.65 206.58,143.65 205.92,144.31 v1(204.44,144.31) 204.02,144.31 203.75,144.04 203.57,144.04 203.39,144.23 203.39,144.41 203.71,144.73 203.71,144.91 203.51,145.11 203.33,145.11 202.97,144.75 202.79,144.75 202.6,144.94 202.6,145.12 202.96,145.48 202.96,145.66 202.7,145.92 202.52,145.92 202.19,145.59 201.96,145.59 201.55,146 189.9,146 189.02,145.12 189.02,144.07 UV6.R13
EDCB0_0: length 28.7
  TOP w0.102: v2(210.61,143.45) 210.78,143.62 210.92,143.62 211.33,143.21 212.32,143.21 212.53,143.43 212.54,143.43 212.76,143.64 212.76,144.17 209.95,146.98 209.95,147.21 ; UV7.R13 201.51,156.7 201.97,156.25 201.97,155.33 202.44,154.86 202.44,154.57
  TOP w0.13: 209.95,147.21 209.95,147.69 210.24,147.98 210.45,147.98 210.91,147.52 211.09,147.52 211.36,147.79 211.36,148.04 210.5,148.9 210.32,148.9 209.55,148.13 209.37,148.13 209.18,148.32 209.18,148.5 209.47,148.79 209.48,148.97 209.29,149.16 209.11,149.16 208.82,148.87 208.63,148.87 208.34,149.16 v1(207.84,149.16) 203.97,149.16 202.44,150.7 202.44,154.57
  BOTTOM w0.102: UV1.F6 210.86,143.2 v2(210.61,143.45)
EDCB0_1: length 40.7
  BOTTOM w0.102: UV1.K3 214.45,145.16 213.98,145.64 213.98,146.41 213.29,147.1 213.29,147.21 ; 199.71,167.17 199.77,167.23 200.66,167.23 201.03,166.86 201.03,166.41 201.51,165.94 UV8.C2
  BOTTOM w0.13: 199.71,167.17 199.42,167.17 198.5,166.24 198.5,155.64 199.54,154.6 204.29,154.6 205.81,153.08 206.71,153.08 206.89,152.9 206.89,151.93 207.02,151.8 207.36,151.8 207.49,151.93 207.49,152.7 207.62,152.83 208.01,152.83 208.14,152.7 208.14,151.83 208.26,151.7 208.62,151.7 208.75,151.83 208.75,152.3 208.87,152.43 209.22,152.43 209.34,152.3 209.34,151.89 209.47,151.76 210.38,151.76 210.89,151.25 210.89,151.09 v1(212.4,149.59) 213.29,148.69 213.29,147.21
EDCB0_2: length 23
  IN1 w0.127: v2(211.51,156.49) 211.11,156.09 211.11,154.85 211.32,154.63 211.32,154.35 212.05,153.63 212.23,153.63 212.4,153.81 212.58,153.81 212.76,153.63 212.76,153.45 212.59,153.27 212.59,153.09 212.77,152.91 212.95,152.91 213.12,153.09 213.3,153.09 213.48,152.91 213.48,152.73 213.31,152.55 213.31,152.37 213.49,152.19 213.66,152.19 213.84,152.37 214.02,152.37 214.2,152.19 214.2,152.01 214.02,151.83 214.02,151.65 214.99,150.68 214.99,150.52 214.77,150.29 214.77,150 214.95,149.82 215.13,149.82 215.76,150.45 215.94,150.45 216.12,150.27 216.12,150.09 215.49,149.46 215.49,149.28 215.71,149.06 215.89,149.06 216.21,149.37 216.39,149.37 216.63,149.13 216.63,148.96 216.37,148.69 216.37,148.4 216.63,148.14 216.63,146.64 217.33,145.94 217.33,145.53 218.22,144.64 v2(218.22,143.8)
  BOTTOM w0.102: UV1.P3 217.65,144.71 218.22,144.14 v2(218.22,143.8) ; UV8.R13 v2(211.51,156.49)
