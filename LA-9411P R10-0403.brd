# Allegro board LA-9411P R10-0403.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
+SM_VREF_Q: length 6.3
  TOP w0.102: RD20.1 168.22,15.58 v3(168.44,15.37)
  TOP w0.381: QD7.1 167.02,18.34 166.51,18.86 RD29.1
  TOP w0.508: QD7.1 167.02,17.62 167.88,16.76 CD48.1 168.16,16.5 RD20.1
+SW_LX:
  vias: v1(175.12,133.62)
+SWR_V12: length 19.4
  TOP w0.178: C112.1 175.62,142.96 175.25,142.59 175.25,141.84 175.42,141.67 U27.43
  TOP w0.203: v2(171.7,136.07) 171.77,136.07 171.97,136.26 U27.11 ; U27.15 174.22,134.52 174.1,134.39 v2(174.1,134.04)
  TOP w0.457: v2(176.55,143.65) 176.55,143.64 176.17,143.26 C112.1
  IN4 w0.508: v2(174.1,134.04) 174.1,135.95 172.87,137.19 172.87,143.43 173,143.56 176.46,143.56 v2(176.55,143.65)
  vias: v1(171.05,132.98) v2(174.2,129.2) v2(174.61,128.66) v2(174.99,129.21)
+TRM_CT1: length 3.5
  TOP w0.508: 299.96,209.58 299.96,208.29 v2(300.08,208.17)
  BOTTOM w0.102: v1(299.04,207.77) 299.44,208.17 v2(300.08,208.17)
  BOTTOM w0.508: C479.1 v2(300.08,208.17)
+TRM_CT2: length 3.6
  TOP w0.508: T156.4 v2(301.23,208.04)
  BOTTOM w0.102: v2(301.23,208.04) 302,208.04 v1(302.2,207.84)
  BOTTOM w0.508: v2(301.23,208.04) 301.23,208.86 C480.1
+TRM_CT3: length 3.9
  TOP w0.508: T156.9 307.58,208.17 v2(307.7,208.04)
  BOTTOM w0.102: C483.1 v1(306.33,208.99)
  BOTTOM w0.508: v2(307.7,208.04) C483.1
+TRM_CT4: length 4.4
  TOP w0.508: T156.10 v2(308.85,208.04)
  BOTTOM w0.102: v1(310.5,209.69) 309.8,208.99 C484.1
  BOTTOM w0.508: C484.1 308.85,208.86 v2(308.85,208.04)
+TSVDD: length 17.2
  TOP w0.508: CV93.1 229.77,120.99 230.18,121.4 v2(230.18,121.5)
  IN2 w0.508: v2(230.18,121.5) 230.18,117.24 230.98,116.43 233.66,116.43 234.25,115.85 v2(234.46,115.85)
  BOTTOM w0.102: LV16.2 237.45,115 238.53,115 v1(238.7,114.82)
  BOTTOM w0.254: UV1.AJ32 229.69,122 v2(230.18,121.5)
  BOTTOM w0.508: v2(234.46,115.85) 234.3,115.68 CV92.1 235.63,114.64 CV98.1 237.08,114.63 LV16.2
+UIM_VPP: length 117.6
  TOP w0.102: v1(247.8,173.6) 247.8,173.99 C628.1
  TOP w0.203: JSIM1.6 249.15,176.58 248.67,176.11 248.67,175.07 C628.1
  TOP w0.381: v2(249.93,187.53) 249.07,186.66 249.07,177.86 249.15,177.79 JSIM1.6
  IN1 w0.381: v2(323.32,208.17) 322.61,208.88 308.61,208.88 308.28,208.55 308.28,207.67 307.08,206.48 297.09,206.48 295.78,205.16 295.78,192.62 293.52,190.36 292.69,190.36 291.63,189.29 282.09,189.29 280.64,187.85 259.54,187.85 259.44,187.74 258.94,187.74 258.64,188.04 251.72,188.04 251.21,187.53 v2(249.93,187.53)
  BOTTOM w0.381: JMINI1.16 332.15,204.1 330.93,205.32 329.84,205.32 326.58,208.58 323.74,208.58 v2(323.32,208.17)
+UTLGND: length 5.6
  TOP w0.102: v1(171.05,132.42) R104.1
  TOP w0.203: U27.16 174.62,134.59 174.57,134.54 174.57,133.51 174.35,133.3 173.78,133.3
  TOP w0.254: 173.78,133.3 172.91,132.42 R104.1
+V_DDR_REF: length 147.4
  TOP w0.102: v1(118.84,37.35) RD3.1
  TOP w0.508: RD5.1 163.89,20.73 160.82,17.65 v2(160.82,16.43) ; RD3.1 120.21,36.64 120.51,36.34 v2(120.51,36.33) ; v2(125.12,22.67) 124.58,23.2 RD9.1 ; v2(161.69,16.26) 161.69,17.2 162.87,18.38 RD10.1
  IN2 w0.508: v2(126.3,28.13) 125.75,28.13 125.12,27.5 v2(125.12,22.67)
  IN3 w0.508: v2(161.69,16.26) 160.99,16.26 v2(160.82,16.43) 160.82,17.65 161.73,18.57 163.47,18.57 164.11,19.2 164.11,20.74 163.81,21.03 163.81,26.06 164.7,26.95 v2(164.7,27.88) ; v2(120.51,36.33) 120.58,36.41 123.62,36.41 124.24,35.79 124.24,33.07 125.61,31.7 125.61,28.82 v2(126.3,28.13)
  IN4 w0.508: v4(210.93,11.44) 211.9,12.41 211.9,14.54 211.31,15.13 210.28,15.13 209.72,15.68 209.72,16.56 205.93,20.35 205.93,20.92 203.82,23.02 203.82,25.03 202.04,26.81 189.59,26.81 188.22,25.43 186.95,25.43 186.22,26.16 165.88,26.16 164.7,27.34 v2(164.7,27.88) 162.12,25.3 143.57,25.3 142.5,26.36 128.9,26.36 127.14,28.13 v2(126.3,28.13)
+VCHGR: length 64
  TOP w0.508: PR834.1 160.64,167.75 v4(160.83,167.56)
  IN3 w0.508: v2(131.67,164.22) 122.22,164.22 121.84,164.6 116.45,164.6 116.34,164.49 115.64,164.49 115.48,164.33 v2(115.48,164.27)
  IN4 w0.508: v2(115.48,164.27) 116.1,164.9 116.1,173.56 117.08,174.54 v4(117.08,175.02)
  BOTTOM w0.508: v2(131.67,164.22) 132.22,163.68 147.58,163.68 148.76,164.86 153.67,164.86 154.93,166.11 157.21,166.11 158.99,164.33 160.51,164.33 162.05,165.86 162.05,166.37 160.85,167.56 v4(160.83,167.56)
  vias: v3(110.68,183.32) v4(110.77,182.71) v4(111.36,183.12) v4(112.15,183.13) v4(112.12,182.37) v4(112.84,182.37) v4(112.91,183.13) v4(113.01,177.43) v4(113.55,182.37) v4(113.77,177.43) v4(114.54,177.43) v4(115.78,176.61) v4(115.81,175.02) v4(116.06,175.65) v4(116.42,176.28) v4(116.44,175.02) v4(116.82,175.65) v4(116.99,176.62)
+VCHGR_C2:
  vias: v1(160.32,170.32)
+VCOMP_OUT: length 3.3
  TOP w0.089: v1(167.61,100.69) 167.31,100.69 v2(166.75,100.13)
  TOP w0.508: RC73.1 RC1.1 166.46,99.94 166.49,99.96 166.58,99.96 v2(166.75,100.13)
  BOTTOM w0.279: v2(166.75,100.13) 166.83,100.13 167.15,100.45 JCPU1.F22
+VDISPLAY_VCC:
  vias: v1(14.54,209.28)
+VGA_B+: length 12.4
  TOP w0.508: v4(308.59,156.22) 308.59,156.24 307.4,157.43 305.33,157.43 303.75,159 298.22,159
  BOTTOM w0.508: PR643.2 308.21,156.6 v4(308.59,156.22)
  vias: v1(297.29,158.76)
+VGA_COREP: length 51.4
  TOP w0.254: v4(313.84,158.46) 313.19,159.11 313.19,160.44 313.75,161 PR646.1
  IN3 w0.254: v2(282.08,151.46) 282.79,150.75 282.79,149.24 288.06,143.97 293.78,143.97 293.91,143.84 304.45,143.84 308.07,147.46 309.89,147.46 312.87,150.44 312.87,151.18 313.6,151.9 314.31,151.9 314.56,152.16 314.56,153.07 313.51,154.13 313.51,155.3 312.83,155.98 312.83,157.45 v4(313.84,158.46)
  vias: v1(280.27,164.73)
+VGA_PCIE: length 63.2
  TOP w0.457: v2(215.86,124.55) 215.85,124.53 CV68.1 ; CV71.1 218.37,126.01 v2(218.63,125.74)
  TOP w0.508: RV296.2 224.25,124.11 v2(224.37,123.99) ; CV68.1 215.83,123.88 CV72.1 ; LV21.2 240.74,141.4 241.38,140.75 v2(241.59,140.75) ; CV113.1 234.47,120.57 CV213.1 233.92,120.67 233.45,121.14 v2(233.45,121.59) 233.47,121.61 CV114.1 233.32,122.32 232.65,122.99 v2(232.65,123.19) ; CV69.1 232.14,121.05 v2(231.85,120.77) ; v2(218.23,124.46) 217.91,124.78 CV70.1 217.91,126 CV71.1 ; v2(215.86,124.55) 216.14,124.82 CV67.1 ; v2(220.52,125.74) 220.79,125.48 CV214.1 220.95,124.94 RV298.2
  IN1 w0.508: v2(242.27,130.54) 242.27,132.16 241,133.43 241,134.85 240.56,135.29 240.56,140.2 241.12,140.75 v2(241.59,140.75)
  IN4 w0.508: v2(242.27,130.54) 242.27,128.85 242.98,128.14 242.98,126.87 238.74,122.63 236.67,122.63 235.63,121.59 v2(233.45,121.59)
  BOTTOM w0.254: 231.82,120.77 232.25,121.19 UV1.AM33 ; 231.82,120.77 v2(231.85,120.77) ; 231.82,120.77 231.45,121.14 UV1.AL33 231.28,121.03 230.81,121.03 UV1.AK33 UV1.AK34 ; UV1.AN33 233.06,121.2 v2(233.45,121.59) ; UV1.AP33 233.84,121.2 v2(233.45,121.59) ; v2(233.45,121.59) 233.85,121.99 UV1.AP32 233.79,122.05 233.79,122.74 UV1.AP31 ; UV1.H29 212.65,124.63 213.01,124.99 213.01,124.99 v2(213.03,125.01) 213.44,124.6 UV1.J29 ; v2(232.65,123.19) 233.05,122.8 UV1.AN31
  BOTTOM w0.381: UV1.L28 215.21,125.2 v2(215.86,124.55) 216.05,124.74 UV1.M28 UV1.N28 ; UV1.G31 UV1.G30 211.95,123.49 212.55,123.49 UV1.H30 ; UV1.H30 212.66,123.6 v2(213.05,123.2) 213.06,123.2 UV1.J30 213.45,123.61 213.06,124 v2(213.05,124) UV1.H30 ; UV1.T27 219.05,126.16 v2(218.63,125.74) 218.63,125.54 218.98,125.2 UV1.T28 219.07,125.17 220.02,125.17 UV1.U28 220.05,125.3 220.49,125.74 v2(220.52,125.74) ; UV1.N28 UV1.R28 218.23,125.01 v2(218.23,124.46) ; UV1.N28 217.14,125.29 217.14,126.11 UV1.N27
  BOTTOM w0.508: v2(201.39,108.2) 201.63,108.45 CV212.1
  vias: v2(209.23,106.66) v2(211.11,115.45) v2(212.28,110.22) v2(212.25,106.99) v2(215.85,122.34) v2(220.66,116.01) v2(221.83,123.45) v2(221.8,122.44) v3(193.3,99.1) v4(189.34,99.45) v4(189.72,99.96) v4(190.23,99.45) v4(190.61,99.96) v4(191.12,99.45) v4(191.5,99.96) v4(191.88,99.45) v4(192.26,99.96) v4(192.65,99.43) v4(193.11,99.91)
+VGA_PCIE_SPLL_VDDC: length 8.5
  TOP w0.508: LV21.1 240.38,140.35 CV224.1 239.26,140.31 CV225.1 CV223.1 236.72,140.31 236.1,140.93 v1(236.1,141.15) 235.69,141.55 233.83,141.55 v2(233.47,141.2)
  BOTTOM w0.254: UV1.AN9 233.08,140.8 v2(233.47,141.2)
+VGA_PCIEP: length 21.3
  TOP w0.102: v2(200.77,98.69) v1(200.77,99.58)
  TOP w0.254: v2(200.77,98.69) PR683.1 PC668.1
  IN1 w0.254: v2(191.12,89.29) 191.12,88.02 191.43,87.71 194.81,87.71 200.77,93.66 v2(200.77,98.69)
+VR_CAP: length 9.9
  TOP w0.254: U51.B12 291.67,115.41 291.59,115.34 290.93,115.34 290.64,115.63 v2(290.64,115.86)
  TOP w0.508: v2(296.43,115.06) 297.01,115.65 C779.1
  IN3 w0.508: v2(290.64,115.86) 290.64,115.56 291.02,115.17 291.61,115.17 291.62,115.15 296.34,115.15 v2(296.43,115.06)
  BOTTOM w0.127: v2(296.43,115.06) v1(296.43,115.96)
+VREFOUT: length 29
  TOP w0.102: v2(353.09,170.09) v1(353.83,170.09)
  TOP w0.254: U74.23 v2(343.48,166.8)
  IN1 w0.508: v2(350.05,181.19) 350.55,181.19 355.1,176.64 355.1,171.77 353.42,170.09 v2(353.09,170.09)
  IN2 w0.508: v2(353.09,170.09) 353.09,170.08 350.41,167.4 345.66,167.4 345.07,166.8 v2(343.48,166.8)
  BOTTOM w0.508: R1146.2 349.54,181.7 v2(350.05,181.19) ; R1145.2 352.67,169.71 353.06,170.09 v2(353.09,170.09)
-DCIN_JACK:
  vias: v1(143.06,176.01) v4(140.06,176.29) v4(140.83,176.29) v4(141.21,177.69) v4(141.21,176.92) v4(141.59,176.29) v4(141.97,177.69) v4(141.97,176.92) v4(142.35,176.29) v4(142.73,177.69) v4(142.73,176.92)
A_DE_0A: length 3.7
  BOTTOM w0.102: R3694.2 R3701.1 333.51,190.13 332.9,189.53 v1(332.6,189.53) 332.19,189.53 332.09,189.63 U90.16
A_DE_0B: length 5.8
  BOTTOM w0.102: v1(338.72,225.09) 338.53,225.09 337.82,224.38 337.82,223.6 R3725.2 R3731.1 338.81,222.57 U92.16
A_DE_0C: length 3.9
  BOTTOM w0.102: U94.16 35.67,187 v1(36.48,187.82) 36.94,188.28 R3740.1 R3739.2
A_DE_0D: length 3.9
  BOTTOM w0.102: U95.16 344.48,190.64 v1(344.83,190.3) 345.5,189.62 R3779.1 R3780.2
A_DE_1A: length 6.1
  BOTTOM w0.102: U90.18 331.76,188.63 332.14,188.25 332.14,187.59 R3702.1 R3695.2 333.66,183.83 v1(333.7,183.79)
A_DE_1B: length 5.1
  BOTTOM w0.102: v1(343.59,223.47) 343.2,223.08 R3732.1 R3726.2 340.64,222.35 340.38,222.35 339.81,221.79 U92.18
A_DE_1C: length 8
  BOTTOM w0.102: U94.18 36.67,187.04 37.08,187.45 39.54,187.45 R3743.1 R3747.2 v1(43.37,188.91)
A_DE_1D: length 6.5
  BOTTOM w0.102: U95.18 344.03,189.64 344.36,189.32 344.36,188 v1(344.89,187.46) 345.46,186.89 345.46,186 R3776.1 R3768.2
A_EQ_0A: length 4.1
  BOTTOM w0.102: U90.17 332.05,189.13 332.6,188.58 v1(332.6,188.1) R3692.2 R3699.1
A_EQ_0B: length 5.2
  BOTTOM w0.102: U92.17 339.31,223.06 R3729.1 R3723.2 340.34,223.18 339.85,223.67 339.85,224.42 v1(340.37,224.94)
A_EQ_0C: length 5.5
  BOTTOM w0.102: U94.17 36.17,186.94 37.13,187.91 v1(38.76,187.91) 38.97,188.12 R3752.2 R3736.1
A_EQ_0D: length 5.1
  BOTTOM w0.102: U95.17 344.27,190.14 344.81,189.6 v1(344.81,188.91) 344.81,188.68 R3774.2 R3773.1
A_EQ_1A: length 3.8
  BOTTOM w0.102: U90.15 331.93,190.13 v1(332.63,190.83) 332.95,191.15 R3700.1 R3693.2
A_EQ_1B: length 4.1
  BOTTOM w0.102: R3730.1 R3724.2 336.85,222.5 337.41,222.5 338.31,221.6 U92.15
A_EQ_1C: length 3.5
  BOTTOM w0.102: U94.15 35.17,187.52 35.19,187.54 v1(35.19,187.85) 35.19,188.1 34.91,188.38 R3733.2 R3745.1
A_EQ_1D: length 3.7
  BOTTOM w0.102: R3759.1 R3762.2 v1(344.86,191.66) 344.61,191.66 344.1,191.14 U95.15
A_ON: length 317.9
  TOP w0.102: v2(288.37,117.79) 288.47,117.89 U51.B24 ; v2(303.16,103.99) v1(303.16,103.42) ; v2(290.43,124.75) 290.3,124.88 R424.2
  TOP w0.254: PR308.1 v2(240.14,3.31)
  IN1 w0.102: v2(303.16,103.99) 303.16,121.63 297.29,127.5 293.18,127.5 v2(290.43,124.75) 290.43,124.55 290.1,124.22 287.24,124.22 286.63,123.6 286.63,122.05 286.9,121.78 286.9,119.85 288.37,118.39 v2(288.37,117.79)
  IN3 w0.127: v2(240.14,3.31) 241.37,4.55 245.73,4.55 269.98,28.8 269.98,31.19 271.53,32.74 271.53,36.87 272.44,37.78 274.3,37.78 274.84,38.32 275.33,38.32 275.57,38.56 275.57,39.61 276.21,40.25 280.35,40.25 289.26,49.16 289.26,58.25 286.36,61.15 285.78,61.15 279.25,67.67 279.25,93.78 282.69,97.22 285.92,97.22 287.45,98.74 287.66,98.74 288.08,98.74 290.77,101.43 300.1,101.43 302.65,103.99 v2(303.16,103.99) ; v2(307.92,197.36) 308.06,197.22 309.28,197.22 310.25,196.24 312.46,196.24 315.32,193.38 315.32,190.98 317.04,189.27 317.04,185.97 317.57,185.43 317.57,182.61 316.76,181.8 316.76,176.89 318.38,175.26 318.38,174.81 319.58,173.61 319.95,173.61 320.22,173.61 320.52,173.31 320.52,172.24 320.12,171.85 320.12,168.27 321.13,167.27 321.13,162.12 321.51,161.73 321.51,157.81 322.19,157.12 322.19,154.23 320.62,152.66 320.62,146.47 316.48,142.32 316.48,141.34 312.44,137.3 309.17,137.3 302.92,131.05 294.43,131.05 291.9,128.52 291.9,126.45 290.43,124.98 v2(290.43,124.75)
  BOTTOM w0.102: R1616.1 302.94,188.01 304.3,186.64 308.18,186.64 308.39,186.85 308.39,190.87 306.36,192.9 306.36,195.8 v2(307.92,197.36)
AC_DIS: length 428.8
  TOP w0.102: v2(270.87,19.79) 270.84,19.75 270.84,17.72 266.98,13.86 266.98,8.43 264.79,6.25 v2(264.13,6.25) ; U46.B12 271.85,54.14 271.79,54.08 v2(271.74,54.08) ; v2(102.13,151.27) v1(101.33,151.27)
  TOP w0.254: PQ6.5 140.83,159.91 140.15,160.59 139.66,160.59 v2(139.58,160.52) ; v4(144.14,178.02) 144.51,178.38 PR828.2
  IN1 w0.102: v2(271.74,54.08) 271.7,54.04 271.7,53.48 272.77,52.41 272.77,48.7 272.28,48.21 272.28,46.6 272.78,46.1 272.78,43.08 272.23,42.53 272.23,38.53 271.65,37.94 271.65,31.13 271.88,30.9 271.88,29.95 271.7,29.77 271.13,29.77 270.94,29.96 270.34,29.96 270.1,29.72 270.1,20.56 v2(270.87,19.79) ; v2(264.13,6.25) 251.91,6.25 238.13,20.03 212.18,20.03 211.31,20.89 205.82,20.89 204.55,19.62 195.14,19.62 193.55,18.03 192.28,18.03 187.71,13.46 160.75,13.46 160.64,13.58 157.33,13.58 156.69,14.21 145.62,14.21 145.16,13.75 122.86,13.75 122.27,13.17 120.91,13.17 119.49,14.59 119.49,16.91 116.2,20.2 116.2,23.55 113.62,26.13 113.62,36.9 112.73,37.79 112.73,56 113.2,56.46 113.2,58.9 113.2,58.9 113.2,59.09 115.26,61.16 115.26,81.97 115.93,82.64 115.93,89.07 113.18,91.83 113.18,92.02 113.18,98.89 109.2,102.86 109.2,118.85 110.18,119.83 110.18,137.65 107.2,140.63 107.2,145.36 102.13,150.43 v2(102.13,151.27)
  IN3 w0.127: v2(139.58,160.52) 139.51,160.44 135.52,160.44 135.19,160.11 128.57,160.11 127.67,159.21 127.09,159.21 126.93,159.05 123.71,159.05 123.09,159.66 118.24,159.66 117.69,159.11 110.74,159.11 v2(110.61,158.99)
  IN4 w0.254: v4(144.14,178.02) 145.3,176.86 145.3,174 144.5,173.2 144.5,169.16 143.79,168.45 139.98,168.45 139.24,167.72 139.24,161.26 139.58,160.92 v2(139.58,160.52)
  BOTTOM w0.102: v2(102.13,151.27) 102.13,154.55 103.01,155.43 107.56,155.43 110.61,158.48 v2(110.61,158.99)
AC_PRESENT: length 150.4
  TOP w0.102: v2(265.26,107.2) v1(264.27,107.2) ; U51.A54 286.22,108.17 285.99,107.94 285.99,107.53 285.6,107.14 v2(285.53,107.14) 285.51,107.14 284.91,106.54 R835.2
  IN2 w0.127: v2(265.26,107.2) 271.99,107.2 273.01,108.22 274.85,108.22 275.43,107.63 276.89,107.63 277.2,107.94 278.09,107.94 278.28,108.13 280.05,108.13 280.31,107.87 282.12,107.87 282.41,108.17 282.86,108.17 283.65,107.38 283.65,107.19 284.05,106.79 285.18,106.79 v2(285.53,107.14)
  IN4 w0.089: 212.78,59.32 212.78,60.61 211.58,61.81 208.42,61.81 v2(208.37,61.86)
  IN4 w0.102: v2(265.26,107.2) 265.26,103.99 264.48,103.21 264.48,101.62 260.9,98.04 260.9,96.71 256.43,92.24 256.43,87.97 255.65,87.18 255.65,70.32 257.01,68.96 257.01,54.87 256.09,53.95 256.09,48.04 254.72,46.67 252.54,46.67 252.39,46.82 245.63,46.82 245.49,46.96 245.49,46.96 244.64,47.82 243.58,47.82 242.58,48.82 242.58,49.68 241.3,50.96 241.11,50.96 239.81,52.26 229.52,52.26 228.37,53.42 224.76,53.42 224.29,52.95 213.51,52.95 212.78,53.68 212.78,55.71 212.48,56.01 212.48,56.5 212.78,56.8 212.78,59.32
  BOTTOM w0.089: UH1.E6 208.47,61.96 v2(208.37,61.86)
ACAV_DOCK_SRC#: length 58.7
  TOP w0.254: v2(164.04,165.87) 164.14,165.77 164.14,163.61 162.8,162.27 v1(160.13,162.27) 159.57,162.27 156.61,159.31 PR846.2 155.65,159.31 155.15,158.81 152.26,158.81 151.75,159.32 151.75,160.95 PR847.1
  IN1 w0.254: v2(160.9,179.73) 161.93,178.7 162.29,178.7 163.43,177.56 163.43,176.03 164.32,175.15 164.32,172.35 163.43,171.46 163.43,166.48 v2(164.04,165.87)
  IN3 w0.254: v2(177.27,187.55) 177.27,187.46 176.61,186.8 173.28,186.8 173.16,186.92 172.19,186.92 171.81,186.54 171.81,184.6 170.84,183.63 167.85,183.63 166.91,182.68 166.91,182.62 166.16,181.88 164.96,181.88 164.57,182.26 161.65,182.26 160.64,181.24 160.64,179.99 v2(160.9,179.73)
  BOTTOM w0.254: JDOCK1.42 177.25,187.62 177.27,187.59 v2(177.27,187.55)
ACAV_IN: length 381.8
  TOP w0.102: v2(74.53,187.46) 74.07,187.92 v3(74.07,188.57) ; PQ710.2 87.27,162.56 87.71,162.12 87.71,161.38 88.4,160.69 90.23,160.69 90.57,160.35 90.57,160.15 90.81,159.91 91.12,159.91 91.59,160.38 91.59,161.68 92.63,162.72 94.87,162.72 v2(96.27,164.13) ; U51.A64 291.22,108.18 291.31,108.09 291.53,108.09 291.91,107.71 v2(291.91,107.64)
  TOP w0.254: v2(79.85,178.66) 79.85,180.31 80.86,181.32 PR741.2 ; v2(173.9,178.07) 173.9,175.48 172.45,174.03 172.45,171.14 172.07,170.76 PR872.1 ; v2(74.53,187.46) 75.22,188.15 PR717.1 ; PR859.1 155.23,160.15 v2(154.59,159.51)
  IN1 w0.254: v2(79.85,178.66) 79.85,179.58 79.12,180.31 75.93,180.31 75.31,179.69 72.36,179.69 71.97,180.09 71.97,187.03 72.4,187.46 v2(74.53,187.46)
  IN3 w0.127: v2(96.27,164.13) 96.28,164.13 96.74,163.66 105.94,163.66 106.83,164.55 108.21,164.55 108.5,164.26 108.5,158.56 109.56,157.51 113.07,157.51 113.85,158.28 118.06,158.28 118.67,158.89 120.09,158.89 120.79,158.19 122.12,158.19 122.2,158.11 127.12,158.11 127.43,158.43 128.09,158.43 129,159.35 135.36,159.35 136.03,158.67 150.9,158.67 151.39,159.17 154.25,159.17 v2(154.59,159.51) ; v2(291.91,107.64) 291.49,108.05 291.11,108.05 290.72,107.67 288.74,107.67 287.26,106.18 281.55,106.18 278.12,109.61 276.58,109.61 274.95,111.24 274.95,136.08 274.94,136.09 274.94,137.05 275.74,137.85 275.74,144.07 272.97,146.83 272.97,147.13 270.84,149.26 270.84,149.47 270.84,167.66 271.17,167.99 271.17,171.53 271.9,172.27 271.9,175.96 271.58,176.28 271.58,177.8 270.26,179.12 269.71,179.12 263.53,185.31 256.92,185.31 255.77,186.45 253.09,186.45 252.87,186.22 248.33,186.22 248.1,186.45 245.49,186.45 245.15,186.11 238.76,186.11 237.32,187.54 226.48,187.54 221.79,182.85 218.59,182.85 216.8,181.06 213.36,181.06 210.83,178.54 206.91,178.54 205.38,180.07 196.21,180.07 195.89,179.76 193.46,179.76 192.74,179.04 191.71,179.04 190.34,177.67 187.05,177.67 186.06,176.68 184.28,176.68 184.07,176.48 182.82,176.48 182.2,177.1 180.75,177.1 180.48,176.83 179.66,176.83 178.96,177.53 174.73,177.53 174.2,178.07 v2(173.9,178.07) 173.45,178.07 172.75,177.37 172,177.37 170.38,175.74 168.15,175.74 167.25,174.84 166.21,174.84 163.76,172.39 160.17,172.39 159.94,172.16 159.08,172.16 157.17,170.25 157.17,167.02 153.58,163.42 v2(152.18,163.42)
  IN4 w0.102: v2(154.59,159.51) 154.3,159.22 152.65,159.22 152.08,159.79 152.08,163.32 v2(152.18,163.42) ; v2(96.27,164.13) 96.27,164.16 97.65,165.53 97.65,169.3 97.09,169.86 87.76,169.86 79.85,177.76 v2(79.85,178.66)
  BOTTOM w0.254: PR743.1 74.87,187.12 v2(74.53,187.46)
ACAV_IN#: length 144.6
  TOP w0.203: PR864.2 166.84,172.42 PU808.8
  TOP w0.254: PQ819.5 61.7,175.65 61.39,175.97 61.39,177.23 v2(61.27,177.34) ; v2(72.8,170.19) 72.55,169.94 72.2,169.94 PR820.2 ; v2(165.38,171.45) 165.77,171.84 PR864.2 167.5,171.77 167.5,170.6 167.7,170.4 168.18,170.4 168.77,169.81 PQ825.1
  IN1 w0.102: v2(74.34,177.16) 74.34,176.9 73.82,176.38 70.12,176.38 69.32,177.18 63.59,177.18 63,177.77 61.71,177.77 v2(61.27,177.34)
  IN3 w0.127: v2(74.34,177.16) 76.56,174.94 81.39,174.94 83.86,172.47 83.86,170.98 85.26,169.58 85.99,169.58 88.02,167.55 88.36,167.55 89.77,166.14 101.73,166.14 102.13,165.74 108.86,165.74 109.78,164.82 109.78,161.38 111.4,159.77 115.34,159.77 115.8,160.22 117.72,160.22 117.93,160.43 123.49,160.43 123.95,159.97 127.1,159.97 128.33,161.2 138.27,161.2 138.62,161.54 139.86,161.54 140.47,160.94 147.25,160.94 148.28,161.96 154.77,161.96 155.95,163.14 156.7,163.14 158.52,164.96 158.52,169.75 159.03,170.26 164.04,170.26 165.24,171.45 v2(165.38,171.45)
  IN4 w0.254: v2(74.34,177.16) 74.34,175.72 72.8,174.18 v2(72.8,170.19)
  BOTTOM w0.102: v2(72.8,170.19) v1(72.8,170.9)
ACAV_IN_NB: length 281.9
  TOP w0.102: v2(103.74,169.07) 103.74,168.8 v1(104.25,168.29)
  TOP w0.254: PR855.2 v4(150.53,174.33) ; v2(275.81,185.65) 276.02,185.65 279.51,182.16 279.51,175.44 278.24,174.17 278.24,171.78 277.49,171.03 v2(277.49,170.57) ; U51.B20 290.47,118.27 290.22,118.02 290.22,117.67 290.52,117.36 290.62,117.36 v2(290.71,117.27)
  IN1 w0.254: v2(277.49,170.57) 277.49,170.18 277.74,169.93 277.74,168.18 276.27,166.71 276.27,155.05 276.72,154.6 276.72,146.89 279.57,144.03 279.57,140.61 278.87,139.92 278.87,138.18 279.19,137.86 279.19,137.43 279.99,136.63 279.99,132.46 281.19,131.27 281.19,125.62 280.56,124.99 280.56,120.53 282.22,118.88 282.22,117.39 282.81,116.79 283.19,116.79 283.19,116.79 283.95,116.79 284.19,116.55 285.49,116.55 286.6,115.44 288.02,115.44 289.06,116.48 290.3,116.48 290.51,116.69 290.51,117.07 v2(290.71,117.27)
  IN2 w0.254: v2(103.74,169.07) 104.24,168.58 105.93,168.58 106.59,169.24 113.07,169.24 113.35,169.52 116.98,169.52 117.64,170.18 120.19,170.18 120.37,170 122.47,170 123.7,171.23 130.15,171.23 131.01,170.37 144.13,170.37 148.09,174.33 v4(150.53,174.33) 158.33,174.33 158.76,174.76 161.67,174.76 162.42,175.51 165.16,175.51 166.07,176.43 166.07,180.77 167.97,182.66 170.9,182.66 173.47,185.23 174.9,185.23 176.18,186.51 181.09,186.51 183.15,184.45 187.56,184.45 189.21,186.11 193.53,186.11 194.36,185.28 199.2,185.28 200.89,183.59 204,183.59 205.85,181.74 206.76,181.74 207.09,182.07 212.35,182.07 212.57,181.85 227.08,181.85 227.95,180.99 228.37,180.99 228.37,180.98 232.75,180.98 232.77,180.99 236.23,184.44 246.17,184.44 246.81,185.08 259.38,185.08 259.81,185.51 265.36,185.51 265.58,185.29 271.43,185.29 271.9,185.76 275.7,185.76 v2(275.81,185.65)
  BOTTOM w0.254: v2(103.74,169.07) 103.74,168.72 103.92,168.54 103.92,166.92 103.26,166.26 PR737.2
ACAVDK_SRC: length 5.8
  TOP w0.102: v1(151.29,159.5) 151.1,159.69 151.1,161.8 151.35,162.05 PR847.2
  TOP w0.254: PR847.2 151.56,162.28 151.06,162.78 151.06,163.91 151.25,164.09 PU800.4
ACAVIN: length 3.4
  TOP w0.254: PR859.2 155.23,162.22 v1(154.26,163.18) 154.18,163.18 153.25,164.12 PU800.8
ADBIA0: length 30
  TOP w0.102: UV5.J4 v2(193.85,122.7)
  IN4 w0.102: v2(213.51,131.2) 212.97,130.66 211.8,130.66 211.11,129.97 211.11,128.7 210.74,128.33
  IN4 w0.127: v2(193.85,122.7) 194.09,122.7 195.48,121.31 201.07,121.31 202.33,122.57 202.65,122.57 202.78,122.69 202.78,123 202.9,123.13 203.16,123.13 203.28,123 203.28,122.69 203.41,122.57 203.67,122.57 203.79,122.69 203.79,123 203.92,123.13 204.17,123.13 204.3,123 204.3,122.69 204.43,122.57 204.71,122.57 204.83,122.69 204.83,122.97 204.96,123.1 205.16,123.1 205.29,122.97 205.29,122.8 205.42,122.67 205.7,122.67 205.82,122.8 205.82,122.92 205.95,123.05 206.05,123.05 207.88,124.88 208.7,124.88 209.19,125.37 209.19,126.78 210.74,128.33
  BOTTOM w0.102: UV1.J21 213.45,131.14 213.51,131.2 v2(213.51,131.2) ; UV5.J4 v2(193.85,122.7)
ADBIA1: length 25.9
  TOP w0.109: UV3.J4 v2(193.85,136.09)
  IN4 w0.102: 207.12,133.15 207.66,133.15 207.83,133.32 208.68,133.32 209.05,133.69 210.42,133.69 v2(211.69,132.41)
  IN4 w0.127: 207.12,133.15 204.87,133.15 204.74,133.28 204.74,133.46 204.61,133.58 204.36,133.58 204.23,133.46 204.23,133.28 204.11,133.15 203.85,133.15 203.72,133.28 203.72,133.72 203.6,133.85 203.34,133.85 203.22,133.72 203.22,133.28 203.09,133.15 202.84,133.15 202.71,133.28 202.71,133.72 202.58,133.85 202.33,133.85 202.2,133.72 202.2,133.28 202.07,133.15 201.76,133.15 201.69,133.22 201.69,133.34 201.57,133.47 201.31,133.47 201.18,133.34 201.18,133.23 201.11,133.15 200.17,133.15 200.1,133.08 195.02,133.08 193.85,134.25 v2(193.85,136.09)
  BOTTOM w0.102: v2(211.69,132.41) 211.85,132.57 UV1.G19 ; UV3.J4 v2(193.85,136.09)
ADBIB0: length 31.9
  TOP w0.102: v2(206.71,164.5) UV7.J4
  IN4 w0.102: 211.03,162.1 207.74,162.1 207.11,162.72 207.11,164.09 v2(206.71,164.5) ; 216.45,147.21 216.91,146.75 216.91,146.13 217.26,145.78 217.26,145.45 219.5,143.21 v2(219.5,142.16)
  IN4 w0.127: 211.03,162.1 211.98,161.15 211.98,160.73 212.71,160.01 212.71,155.46 212.2,154.95 212.2,153.19 214.26,151.13 214.26,150.41 216.45,148.22 216.45,147.21
  BOTTOM w0.102: v2(206.71,164.5) UV7.J4 ; UV1.T7 219.26,142.4 v2(219.5,142.16)
ADBIB1: length 30.8
  TOP w0.102: UV9.J4 v2(227.71,163.7)
  IN4 w0.102: 225.56,147.21 225.56,146.99 225.28,146.71 225.28,146.38 224.79,145.89 224.79,145.61 223.19,144.01 222.86,144.01 222.02,143.17 v2(222.02,142.93) ; v2(227.71,163.7) 228.11,163.29 228.11,162.65 227.86,162.39 227.29,162.39 227.15,162.53 227.15,162.93 226.96,163.11 226.67,163.11 226.61,163.17 226.32,163.17 226.11,162.95 226.11,162.55 225.92,162.36 224.39,162.36 223.3,161.26 223.3,158.11 223.73,157.68 223.73,154.59 223.75,154.57
  IN4 w0.127: 223.75,154.57 225.56,152.76 225.56,147.21
  BOTTOM w0.102: UV1.W7 221.25,142.4 221.79,142.94 222.04,142.94 222.04,142.93 222.02,142.93 222.02,142.93 v2(222.02,142.93) ; UV9.J4 v2(227.71,163.7)
ALERT#: length 4.7
  BOTTOM w0.102: PR506.2 PR503.1 117.19,150.62 v1(117.67,151.1) 117.67,151.59 118.22,152.15 118.64,152.15 118.85,152.36 PU500.32
ALW_PWRGD_3V_5V: length 284.4
  TOP w0.254: v2(187.19,3.17) 187.18,3.17 184.97,5.38 176.22,5.38 175.57,4.74 175.57,1.85 175.17,1.45 155.39,1.45 v2(154.16,2.68) ; U51.A1 293.14,110.16 293.48,109.82 v2(293.71,109.82)
  IN2 w0.254: v2(154.16,2.68) 153.91,2.93 152.76,2.93 151.62,4.08 149.39,4.08 148.62,4.84 148.48,4.84 v2(148.45,4.88) ; v2(187.19,3.17) 188.2,2.17 198.87,2.17 200.26,3.57 200.45,3.57 203.91,7.03 204.17,7.03 213.12,7.03 214.61,8.52 216.73,8.52 223.94,15.74 253.37,15.74 v2(255.49,13.61) ; v2(293.71,109.82) 292.61,109.82 291.7,108.91 289.88,108.91 289.44,108.48 282.28,108.48 281.99,108.19 280.44,108.19 280.19,108.45 278.14,108.45 277.96,108.27 277.02,108.27 276.7,107.95 275.59,107.95 275,108.53 272.54,108.53 271.59,107.58 265.82,107.58 265.32,108.08 253.84,108.08 253.82,108.05 252.48,108.05 v2(252.42,107.99)
  IN3 w0.254: v2(272.35,31.61) 272.4,31.56 272.4,30.29 255.72,13.61 v2(255.49,13.61)
  BOTTOM w0.254: v2(252.42,107.99) 251.95,107.52 251.95,106.91 252.88,105.98 252.88,104.62 252.41,104.15 252.41,98.48 251.62,97.69 251.62,96.56 252.88,95.3 252.88,91.42 253.24,91.06 253.28,91.06 253.56,90.78 253.56,86.18 254.2,85.55 v1(254.2,68.85) 254.2,58.91 256.99,56.11 256.99,54.83 258.05,53.78 258.05,52.83 258.52,52.36 259.13,52.36 259.63,51.86 259.63,47.46 259.79,47.31 259.79,38.33 261.27,36.84 261.27,34.12 264.31,31.09 269.57,31.09 270.09,31.61 v2(272.35,31.61) ; v2(148.45,4.88) 148.45,4.81 148.32,4.69 145.54,4.69 145.19,5.03 PR118.1
ALWON: length 270.8
  TOP w0.102: U51.A60 289.22,107.91 289.36,107.76 289.36,107.59 289.68,107.27 289.68,107.27 290.7,106.25 v2(290.7,105.52) ; v2(252.15,105.28) 252.05,105.18 252.05,98.58 251,97.52 251,95.78 v2(250.88,95.67) ; v2(215.25,6.36) v3(216.14,6.36)
  IN2 w0.127: v2(252.15,105.28) 252.36,105.08 258.23,105.08 258.89,104.42 278.09,104.42 278.18,104.51 279.42,104.51 280.66,103.26 282.74,103.26 283.49,102.51 283.84,102.51 285.6,104.28 286.58,104.28 287.26,104.96 287.27,104.96 287.99,105.68 290.55,105.68 v2(290.7,105.52) ; v2(215.25,6.36) 214.74,6.87 213.58,6.87 213.43,6.71 204.04,6.71 200.58,3.25 200.4,3.25 199,1.85 187.92,1.85 186.29,3.48 186.29,4.76 185.17,5.88 176.21,5.88 174.86,4.53 174.86,2.31 174.3,1.75 154.45,1.75 153.59,2.62 152.63,2.62 152.49,2.76 146.49,2.76 145.63,1.89 v4(145.63,1.77)
  IN3 w0.127: v2(244.24,2.57) 243.31,1.64 225.41,1.64 223.91,3.14 223.91,4.6 222.78,5.73 215.88,5.73 v2(215.25,6.36) ; v2(250.88,95.67) 250.88,95.46 249.28,93.86 249.28,87.01 250.96,85.33 250.96,82.71 252.33,81.34 252.33,70.43 248.6,66.7 248.6,61.41 247.85,60.66 247.85,57.1 247.4,56.65 247.4,54.95 245.99,53.54 245.99,51.06 245.56,50.63 245.56,44.98 244.71,44.12 244.71,37.82 247.04,35.5 247.04,32.93 247.67,32.29 247.67,31.94 245.87,30.14 245.87,28.13 244.19,26.46 v2(244.19,26.34)
  BOTTOM w0.102: v2(244.19,26.34) 244,26.15 242.53,26.15 242.17,25.79 242.17,24.66 244.41,22.43 244.41,2.73 v2(244.24,2.57)
  BOTTOM w0.254: PR110.1 145.22,2.65 145.22,2.17 v4(145.63,1.77)
AND_PWRGD: length 80.9
  TOP w0.102: U50.4 275.71,121.24 275.68,121.27 R840.2 274.39,122.08 v1(273.29,122.08) 272.91,122.08 v2(271.43,120.61) ; U46.A4 274.5,50.39 v2(274.56,50.33)
  IN3 w0.127: v2(271.43,120.61) 271.99,120.05 271.99,105.28 274.98,102.29 274.98,94.49 276.21,93.26 276.21,64.41 276.77,63.85 276.77,61.87 274.75,59.85 274.75,59.3 273.68,58.23 273.68,51.06 274.42,50.33 v2(274.56,50.33)
AUD_HP_NB_SENSE: length 222.4
  TOP w0.254: U46.A41 262.35,52.39 262.28,52.31 261.83,52.31 261.35,51.83 v2(261.35,51.73)
  TOP w0.381: v2(333.99,155.02) 333.31,155.02 330.91,152.62 v1(329.48,152.62) 327.53,152.62 325.83,154.32 322.49,154.32 v2(321.62,155.18) ; C972.1 342.39,159.7 C1247.1 344.2,159.82 344.72,160.34 344.72,162.57 v2(344.78,162.62) 346.73,162.62 348.01,163.9 Q324.2
  IN1 w0.381: v2(321.62,155.18) 321.5,155.05 321.5,153.99 321,153.49 321,147.01 317.17,143.17 317.17,142.2 312.67,137.71 312.11,137.71 310.71,136.31 310.71,127.99 309.9,127.17 309.9,105.86 305.9,101.86 286.75,101.86 276.79,91.9 276.79,62.31 274.81,60.32 274.81,58.44 272.35,55.97 271.32,55.97 270.62,55.27 270.62,53.81 270.18,53.37 266.33,53.37 265.59,52.63 263.14,52.63 262.85,52.34 261.73,52.34 261.35,51.96 v2(261.35,51.73)
  IN3 w0.381: v2(344.78,162.62) 343.66,161.51 343.56,161.51 343.24,161.19 343.24,160.76 337.39,154.91 334.23,154.91 334.13,155.02 v2(333.99,155.02)
  BOTTOM w0.381: v2(344.78,162.62) 345.82,161.58 349.23,161.58 351.01,163.36 351.01,166.75 350.72,167.04 350.72,175.06 R1088.1 352.34,175.18 354.36,177.2 D83.3 356.69,175.39 356.69,173.6 358.29,172 362.49,172 363.16,172.66 JHP1.6
AUD_HP_OUT_L: length 9
  TOP w0.254: U74.33 346.08,172.59 346.35,172.31 346.38,172.34 v2(346.38,172.38)
  BOTTOM w0.381: R1677.2 348.26,177.79 v1(348.26,176.97) 348.26,173.32 347.32,172.38 v2(346.38,172.38)
AUD_HP_OUT_L1: length 19.1
  IN1 w0.381: v2(349.11,179.69) 350.7,178.1 350.7,175.17 350.52,174.99 350.52,171.33 351.11,170.73 351.11,168.27 349.14,166.3 v2(349.14,166.27)
  BOTTOM w0.381: v2(349.11,179.69) 348.61,179.2 R1677.1 348.66,179.01 R56.1 ; R209.1 R198.2 v2(349.14,166.27)
AUD_HP_OUT_L2: length 13.5
  BOTTOM w0.381: R56.2 350.15,180.4 350.55,180 C1213.1 351.43,180 351.91,179.51 D81.3 v1(356.95,179.51) 357.28,179.51 357.74,179.97 357.74,181.9 358.72,182.88 JHP1.1
AUD_HP_OUT_R: length 9.9
  TOP w0.127: v2(352.03,172.73) 352.03,172.52 v1(352.51,172.03)
  TOP w0.254: v2(345.68,172.09) U74.32
  TOP w0.381: R1679.2 352.41,173.11 v2(352.03,172.73)
  IN2 w0.381: v2(352.03,172.73) 351.52,172.73 351.07,173.18 346.35,173.18 345.68,172.5 v2(345.68,172.09)
AUD_HP_OUT_R1: length 19.5
  TOP w0.381: R57.1 R1679.1 352.56,174.49 352.56,175.63 351.95,176.24 v1(351.26,176.24) 350.88,176.24 350.26,175.62 v2(349.93,175.62)
  IN1 w0.381: v2(349.93,175.62) 349.75,175.44 349.75,171.01 350.33,170.44 350.33,168.56 347.94,166.18 v2(346.63,166.18)
  BOTTOM w0.381: v2(346.63,166.18) 347.26,166.18 R199.2 R210.1
AUD_HP_OUT_R2: length 19.9
  TOP w0.102: v1(353.7,175.6) 353.75,175.6 354.39,174.97 354.39,173.47 C1212.1
  TOP w0.381: C1212.1 353.79,172.91 R57.2 353.77,172.22 v2(353.82,172.17)
  BOTTOM w0.381: v2(353.82,172.17) 354.08,172.17 D82.2 356.24,172.81 358.11,170.94 363.57,170.94 364.6,171.97 364.6,172.99 364.93,173.32 JHP1.2
AUD_NB_MUTE#: length 228.8
  TOP w0.102: R40.1 352.97,163.88 346.71,157.62 339.1,157.62 335.62,161.1 v2(334.29,161.1) ; v2(261.36,52.83) 261.36,52.95 261.72,53.3 262.27,53.3 262.35,53.39 U46.A39 ; U74.47 338.98,175.36 338.6,175.74 v2(337.02,175.74) 336.66,176.1 R1099.2
  IN1 w0.102: v2(337.02,175.74) 336.1,176.66 331.2,176.66 330.22,175.68 326.79,175.68 326.16,175.04 324.27,175.04 322.49,173.27 321.38,173.27 318.27,170.15 318.27,166.72 318.7,166.29 318.7,158.9 319.5,158.1 319.5,154.57 319.11,154.17 319.11,147.67 308.36,136.93 308.36,106.64 305.12,103.39 286.12,103.39 275.26,92.53 275.26,67.59 272.58,64.91 272.58,63.97 271.37,62.76 271.37,59.52 269.7,57.85 268.58,57.85 268.16,57.43 268.16,55.69 267.89,55.42 263.67,55.42 262.66,54.41 261.17,54.41 260.87,54.1 260.87,53.33 v2(261.36,52.83)
  IN4 w0.102: v2(334.29,161.1) 334.29,164.5 337.37,167.59 337.37,175.39 v2(337.02,175.74)
  BOTTOM w0.102: C967.1 336.91,175.89 337.02,175.79 v2(337.02,175.74) v1(337.02,175.02)
AUD_PC_BEEP: length 4.3
  TOP w0.102: C1105.2 C1106.2 335.09,168.41 335.49,168.01 v1(335.95,168.01) 336.75,168.01 337.33,168.59 U74.12
AUD_SENSE_A: length 6
  TOP w0.254: U74.13 338.48,167.24 336.62,165.38 v1(336.62,164.5) 336.62,162.94 R1086.1
AUD_SENSE_B: length 4.4
  TOP w0.102: v2(338.4,166.08) 337.98,166.08 v1(337.8,165.9)
  TOP w0.254: U74.14 338.98,166.86 338.4,166.28 v2(338.4,166.08)
  BOTTOM w0.254: R1080.1 338.4,165.91 v2(338.4,166.08) 338.49,166.08 338.95,165.62 R1079.1
AUDIO_BACKLITE#: length 496.6
  TOP w0.102: U46.B68 272.19,47.68 272.33,47.54 272.33,47.05 272.73,46.65 273.97,46.65 274.52,47.19 v2(274.58,47.19) ; R940.2 52.03,194.14 52.29,193.88 Q80.2 52.54,192.89 53.03,192.4 54.35,192.4 Q82.2 54.83,193.33 55.04,193.54 56.4,193.54 57.04,192.89 Q86.2 57.79,192.89 58.7,193.8 60.33,193.8 v1(60.57,193.56) 70.21,193.56 v2(70.59,193.94)
  IN3 w0.127: v2(101.91,158.88) 102,158.88 105.52,155.36 111.87,155.36 112.96,154.27 112.96,147.4 115.03,145.33 115.03,141.78 114.83,141.58 114.83,107.81 113.2,106.18 113.2,99.2 119.4,93 119.4,82.31 117.43,80.34 117.43,69.99 108.16,60.72 108.16,33.79 114.07,27.89 114.07,12.83 112.96,11.73 112.96,4.88 116.75,1.09 146.35,1.09 147.7,2.44 152.88,2.44 154.18,1.14 174.84,1.14 175.54,1.84 175.54,4.03 176.67,5.17 184.99,5.17 185.92,4.24 185.92,2.16 186.94,1.14 198.82,1.14 200.5,1.14 201.85,2.49 201.85,4.14 204.01,6.3 211,6.3 211.83,5.47 222.68,5.47 223.66,4.5 223.66,3.04 225.52,1.17 246.24,1.17 250.69,5.63 261.37,5.63 271.15,15.4 277.9,15.4 280.04,17.54 280.04,18.33 285.81,24.09 287.51,24.09 288.53,25.11 288.53,36.33 287.64,37.22 286.63,37.22 283.95,39.9 276.35,39.9 275.85,39.4 275.85,38.25 275.22,37.62 v2(274.89,37.62)
  IN4 w0.102: v2(101.91,158.88) 101.52,159.27 96.17,159.27 92.83,162.61 89.12,162.61 87.03,164.71 87.03,167.04 82.75,171.31 80.92,171.31 76.69,175.54 76.69,176.67 75.73,177.63 70.99,177.63 70.07,178.55 70.07,193.42 v2(70.59,193.94) ; v2(274.58,47.19) 274.56,47.17 274.56,45.45 275.05,44.96 275.05,39.66 274.3,38.91 274.3,38.2 v2(274.89,37.62)
AUX_EN_WOWL: length 221
  TOP w0.102: v2(272.08,48.72) 271.69,48.32 U46.B67
  IN2 w0.127: v2(285.35,184.66) 285.35,184.68 285.97,185.31 287.46,185.31 287.99,184.77 288.37,184.77 288.78,185.18 309.86,185.18 312.66,182.38 320.66,182.38 321.17,181.88 321.17,179.13 322.94,177.36 322.94,172.96 321.65,171.66 321.65,169.81 322.18,169.28 322.18,167.53 323.13,166.58 323.62,166.58 324.72,165.48 324.72,159.29 324.47,159.04 324.47,156.73 318.14,150.41 318.14,147 311.49,140.35 310.24,140.35 310.08,140.5 308.47,140.5 308.32,140.35 v2(305.67,140.35)
  IN3 w0.127: v2(305.67,140.35) 302.43,137.11 301.8,137.11 301.28,136.59 301.27,136.59 301.02,136.34 301.02,136.33 300.33,135.64 v2(293.23,135.64)
  IN4 w0.102: v2(293.23,135.64) 291.87,134.28 291.87,132.49 289.56,130.17 289.56,120.04 290.03,119.57 290.66,119.57 292.72,117.51 292.72,109.6 291.74,108.62 290.84,108.62 290.58,108.37 290.58,106.33 289.72,105.47 289.72,103.99 288.18,102.45 286.66,102.45 283.26,99.05 283.2,99.05 282.1,97.95 282.1,96.04 277.96,91.9 277.96,67.19 279.85,65.3 279.85,63.59 280.46,62.98 280.46,58.08 278.68,56.3 276.51,56.3 275.74,57.07 275.22,57.07 274.8,56.65 274.29,56.65 273.57,55.94 273.57,51.3 274.1,50.77 274.1,49.85 274.34,49.61 275.1,49.61 v2(275.8,50.3)
  BOTTOM w0.102: v2(272.08,48.72) 272.09,48.72 273.05,49.67 273.05,49.94 v1(273.22,50.11) 273.93,50.83 275.38,50.83 275.8,50.41 v2(275.8,50.3) ; v2(285.35,184.66) R1631.1
B_DE_0A: length 5.2
  BOTTOM w0.102: U90.3 326.31,189.63 325.38,188.7 325.27,188.7 R3684.1 R3676.2 325.51,187.08 v1(325.55,187.12)
B_DE_0B: length 2.8
  BOTTOM w0.102: R3716.1 R3706.2 338.81,215.86 U92.3
B_DE_0C: length 6.6
  BOTTOM w0.102: 36.13,179.67 35.67,179.21 35.67,177.56 v1(35.54,177.43) ; 36.13,179.67 R3748.1 ; 36.13,179.67 R3737.2 35.67,180.17 U94.3
B_DE_0D: length 3.6
  BOTTOM w0.102: R3764.1 R3767.2 337.57,191.1 338.21,190.47 v1(338.21,190.47) 338.72,190.47 338.9,190.64 U95.3
B_DE_1A: length 5.3
  BOTTOM w0.102: v1(324.7,194.36) 324.67,194.34 R3677.2 R3685.1 325.24,192.16 326.28,191.13 U90.6
B_DE_1B: length 5
  BOTTOM w0.102: R3717.1 R3707.2 334.5,216.08 334.97,216.55 v1(335.3,216.55) 337.04,216.55 337.31,216.82 U92.6
B_DE_1C: length 5.7
  BOTTOM w0.102: R3741.1 R3738.2 v1(32.7,181.27) 33.61,181.27 34.17,181.82 U94.6
B_DE_1D: length 5.7
  BOTTOM w0.102: R3777.2 R3760.1 337.96,194.91 v1(338.2,194.67) 338.51,194.35 338.51,192.42 338.79,192.14 U95.6
B_EQ_0A: length 7.4
  BOTTOM w0.102: U90.2 326.39,189.13 325.79,188.53 325.79,187.73 325.88,187.64 325.88,186.65 325.29,186.07 R3674.2 R3682.1 324.67,183.88 v1(324.71,183.84)
B_EQ_0B: length 3.4
  BOTTOM w0.102: R3704.2 R3714.1 340.04,216.17 339.58,216.17 339.31,216.43 U92.2
B_EQ_0C: length 4.3
  BOTTOM w0.102: U94.2 v1(36.17,181.11) 36.17,180.69 R3734.1 R3735.2
B_EQ_0D: length 4.6
  BOTTOM w0.102: U95.2 338.84,190.14 338.76,190.06 337.87,190.06 R3758.2 R3765.1 338.13,188.43 v1(338.16,188.46)
B_EQ_1A: length 5
  BOTTOM w0.102: v1(325.79,189.61) 325.29,189.12 R3683.1 R3675.2 327.32,190.13 U90.4
B_EQ_1B: length 3
  BOTTOM w0.102: R3715.1 R3705.2 338.31,216.37 U92.4
B_EQ_1C: length 6.8
  BOTTOM w0.102: 33.18,179.67 R3751.1 ; 33.18,179.67 33.64,179.21 v1(33.64,177.43) ; 33.18,179.67 R3750.2 35.17,180.69 U94.4
B_EQ_1D: length 3.6
  BOTTOM w0.102: U95.4 338.8,191.14 v1(338.11,191.83) 337.96,191.99 R3772.2 R3766.1
BAT1_LED#: length 184.7
  TOP w0.254: R953.1 330.56,164.2 329.97,164.79 v2(329.64,164.79) 328.8,164.79 Q83.1 ; v2(270.26,48.75) 270.19,48.67 U46.B64
  IN2 w0.254: v2(270.26,48.75) 270.26,48.67 270.71,48.22 272.58,48.22 272.97,48.62 273.35,48.62 274.28,49.54 276.23,49.54 276.95,50.27 278.26,50.27 278.64,49.89 279.04,49.89 279.41,50.26 279.61,50.26 v2(280.03,50.69)
  IN3 w0.254: v2(315.3,103.54) 315.3,103.64 313.93,105.02 313.87,105.02 312.23,106.65 311.08,106.65 303.94,99.52 290.44,99.52 288.57,97.64 287.87,97.64 286.37,96.14 283.14,96.14 280.21,93.21 280.21,68.06 285.95,62.32 286.54,62.32 290.22,58.64 290.22,58.23 v2(290.67,57.77)
  BOTTOM w0.254: v2(280.03,50.69) 280.03,50.72 v1(281.85,52.54) 287.65,58.34 290.1,58.34 v2(290.67,57.77) ; v2(315.3,103.54) 316.12,104.37 316.12,117.18 319.51,120.57 325.54,120.57 326.6,121.63 326.6,141.33 328.25,142.98 328.25,149.53 333.08,154.36 333.08,161.79 332.3,162.56 331.87,162.56 v2(329.64,164.79)
BAT1_LED#_Q: length 10.3
  TOP w0.102: v1(328.19,160.81) 328.19,161.82 328.91,162.55 v2(328.91,162.79)
  TOP w0.254: R951.1 327.94,166.14 v2(328.95,166.14) ; v2(328.91,162.79) 328.65,162.79 328.42,163.02 Q83.6
  IN1 w0.254: v2(328.91,162.79) 328.52,162.79 328.02,163.28 328.02,166.21 328.25,166.44 328.66,166.44 v2(328.95,166.14)
BAT2_LED#: length 163.8
  TOP w0.254: Q83.4 327.12,162.28 R958.1 326.89,162.14 326.17,161.42 v2(325.89,161.42) ; v2(274.36,52.83) 274.32,52.87 273.65,52.87 U46.A9
  IN1 w0.254: v2(325.89,161.42) 326.18,161.42 326.82,162.05 329.99,162.05 330.22,161.82 330.22,161.65 v2(330.24,161.64)
  BOTTOM w0.254: v2(274.36,52.83) 274.36,53.04 274.65,53.33 v1(276.21,53.33) 277.2,53.33 281.66,57.78 281.66,65.61 279.5,67.77 279.5,93.14 284.19,97.83 287,97.83 288.11,98.94 308.38,98.94 315.51,106.07 315.51,118 318.7,121.18 325.29,121.18 325.99,121.88 325.99,141.68 327.31,143 327.31,150.19 332.41,155.28 332.41,160.98 331.71,161.68 330.29,161.68 v2(330.24,161.64)
BAT2_LED#_Q: length 2
  TOP w0.254: Q83.3 327.12,165.57 v1(326.77,165.92) 326.77,166.05 326.25,166.57 R949.1
BATDRV#: length 59.1
  TOP w0.508: PR722.2 74.71,179.51 74.35,179.87 v1(74.35,181.88) 74.35,182.33 73.99,182.69 v2(73.9,182.69) ; PQ800.4 110.18,178.19 109.57,178.8 v4(109.57,184.04)
  IN3 w0.508: v4(109.57,184.04) 108.96,184.04 103.05,189.94 99.03,189.94 98.27,190.7 74.16,190.7 71.61,188.15 71.61,185.89 73.9,183.6 v2(73.9,182.69)
BATT_WHITE#: length 6.2
  TOP w0.102: v1(328.11,169.13) 328.11,170.31 327.54,170.88 326.69,170.88 326.33,170.51 JLED2.3 326.33,167.81 R949.2
BATT_WHITE_LED#: length 227.4
  TOP w0.102: v2(323.6,159.77) 323.97,160.13 v1(324.98,160.13) 325.74,160.13 326.83,161.23 R958.2
  IN2 w0.127: v2(323.6,159.77) 321.8,159.77 319.64,161.92 319.64,166.7 314,172.34 308.94,172.34 308.64,172.63 303.61,172.63 302.99,172.01 301.28,172.01 300.43,172.86 295.36,172.86 293.73,174.49 291.14,174.49 290.61,175.02 289.95,175.02 288.53,173.6 288.53,171.31 287.28,170.07 281.16,170.07 278.57,167.47 278.57,166.33 276.89,164.65 276.89,158.79 268.35,150.24 260.2,150.24 256.43,146.47 255.02,146.47 v2(254.44,147.05)
  IN3 w0.102: 198.48,167.63 213.72,167.63 ; 221.47,167.78 221.32,167.63 219.57,167.63
  IN3 w0.127: 213.72,167.63 219.57,167.63 ; 221.47,167.78 223.99,170.29 225.81,170.29 226.42,170.9 232.86,170.9 233.54,171.58 239.05,171.58 239.8,172.33 246.58,172.33 246.81,172.1 249.84,172.1 252.05,169.89 252.37,169.89 253.12,169.14 253.12,162.79 253.68,162.23 253.68,158.18 255.39,156.46 255.39,147.42 254.94,146.96 254.53,146.96 v2(254.44,147.05) ; 198.48,167.63 197.63,167.63 196.62,166.62 187.97,166.62 187.51,166.17 186.97,166.17 186.81,166.32 180.41,166.32 179.61,165.52 173.82,165.52 172.33,164.03 172.33,157.77 173.71,156.39 173.71,150.13 v2(174.47,149.37)
  BOTTOM w0.102: v2(174.47,149.37) 175.37,148.47 JLVDS1.2
BATT_YELLOW#: length 3.6
  TOP w0.102: v1(328.27,167.17) 327.71,167.73 R951.2 326.83,168.16 JLED2.2
BATT_YELLOW_LED#: length 263.5
  TOP w0.102: v2(330.49,162.51) 330.56,162.59 R953.2 ; v2(254.74,128.96) v1(254.74,129.55)
  IN1 w0.102: v2(328.94,153.71) 327.8,153.71 324.24,150.15 324.24,148.02 319.08,142.86 319.08,141.75 312.93,135.6 v2(312.56,135.6)
  IN2 w0.127: v2(254.74,128.96) 256.01,128.96 256.57,129.51 260.6,129.51 261.79,130.7 272.43,130.7 272.9,131.17 272.9,131.18 273.15,131.42 273.15,131.42 273.3,131.57 274.93,131.57 276.08,132.73 276.97,132.73 277.33,132.37 279.85,132.37 280.48,132.37 281.27,131.58 282.11,131.58 282.41,131.88 285.01,131.88 285.35,132.22 286.03,132.22 286.48,132.22 289.74,135.48 292.68,135.48 292.96,135.2 293.39,135.2 293.97,135.79 299.98,135.79 301.11,136.92 302.51,136.92 303.88,135.55 312.5,135.55 v2(312.56,135.6)
  IN3 w0.127: v2(328.94,153.71) 329.92,153.71 331.35,155.14 331.35,161.51 330.49,162.37 v2(330.49,162.51) ; v2(174.46,149.99) 174.9,149.55 174.9,146.34 175.62,145.62 175.62,142.88 175.27,142.53 175.27,142.06 174.19,140.97 174.19,136.31 174.52,135.98 174.52,132.63 175.15,131.99 175.15,131.27 176.67,129.76 176.67,121.84 176.04,121.21 176.04,115.19 180.13,111.1 180.13,107.35 179.73,106.95 179.73,105.42 181.35,103.8 181.35,100.88 182.57,99.66 184.59,99.66 184.88,99.95 184.88,100.18 184.59,100.47 184.59,100.65 184.76,100.81 188.03,100.81 189.56,102.34 193.86,102.34 194.5,101.7 199.73,101.7 200.05,101.38 202.47,101.38 203.5,100.36 213.81,100.36 217.34,96.82 219.5,96.82 222.54,93.79 224.68,93.79 225.26,93.22 237.15,93.22 247.16,103.23 247.16,104.28 251.2,108.32 251.2,110.02 251.77,110.59 251.77,111.39 252.84,112.46 252.84,112.84 255.34,115.34 255.34,118.98 254.62,119.71 254.62,123.34 253.72,124.24 253.72,128.45 254.22,128.96 v2(254.74,128.96)
  BOTTOM w0.102: JLVDS1.3 175.28,148.97 174.91,149.34 174.91,149.54 174.46,149.99 v2(174.46,149.99)
BAY_SMBCLK: length 118.6
  TOP w0.102: PR4.2 243.77,63.39 244.6,63.39 244.74,63.52 ; 244.74,63.52 v2(244.73,63.52) ; 244.74,63.52 244.98,63.52 247.94,66.48 250.61,66.48 251.77,67.64 257.89,67.64 258.63,68.38 267.38,68.38 268.12,67.64 277.29,67.64 278.66,69 278.66,95.7 279.26,96.3 279.26,97.43 v2(279.23,97.46) ; R856.2 294.37,113.55 294.37,113.54 v2(294.27,113.44) 293.95,113.12 293.95,113.12 293.83,113 293.41,113 293.26,113.16 U51.A7
  IN1 w0.102: v2(294.27,113.44) 295.64,112.06 295.64,109.03 293.01,106.4 290.65,106.4 289.18,104.93 288.19,104.93 286.89,103.62 286.02,103.62 280.71,98.31 280.32,98.31 279.69,97.69 279.46,97.69 v2(279.23,97.46)
  BOTTOM w0.102: v2(244.73,63.52) 244.99,63.26 245.54,63.26 245.83,62.97 245.83,62.27 243.39,59.84 243.39,57.27 237.88,51.76 237.88,45.26 237.83,45.21 JSATA2.30
BAY_SMBDAT: length 130.1
  TOP w0.102: 244.71,62.88 244.94,63.1 244.94,63.16 248.03,66.26 250.71,66.26 251.86,67.41 257.99,67.41 258.73,68.15 267.29,68.15 268.02,67.41 277.39,67.41 278.89,68.91 278.89,95.61 279.65,96.37 279.65,97.62 v2(279.23,98.04) ; 244.71,62.88 244.43,63.16 243.8,63.16 PR3.2 ; 244.71,62.88 v2(244.74,62.88) ; v2(298.7,113.98) 298.27,113.55 R854.2 ; U51.B7 291.48,112.91 v2(291.35,112.78)
  IN1 w0.102: v2(279.23,98.04) 279.36,97.92 279.6,97.92 280.22,98.54 280.61,98.54 285.93,103.85 286.79,103.85 288.1,105.16 289.09,105.16 290.56,106.63 292.92,106.63 295.41,109.12 295.41,111.97 294.4,112.98 292.47,112.98 292.27,112.78 v2(291.35,112.78)
  IN3 w0.127: v2(298.7,113.98) 297.67,112.95 291.52,112.95 v2(291.35,112.78)
  BOTTOM w0.102: JSATA2.29 236.63,44.36 237.65,45.38 237.65,51.85 243.16,57.37 243.16,59.93 245.6,62.37 245.6,62.88 245.45,63.03 244.9,63.03 244.89,63.03 v2(244.74,62.88)
BBS_BIT0_R: length 227.2
  TOP w0.102: v2(264.1,29.59) 263.89,29.37 263.89,28.64 263.04,27.79 256.7,27.79 256.18,27.27 252.98,27.27 251.58,25.87 250.21,25.87 248.81,27.27 247.33,27.27 245.91,28.69 245.91,29.96 244.48,31.38 240.76,31.38 239.39,30.01 239.39,26.83 240.15,26.07 240.15,25.27 238.58,23.7 232.14,23.7 230.44,25.4 230.44,33.26 v2(229,34.7) ; RH13.1 v2(268.54,88.33)
  IN1 w0.102: v2(190.97,70.17) 190.47,70.17 189.99,69.68 188.14,69.68 185.26,66.8 185.09,66.63 185.09,65.85 185.17,65.77 185.17,62.69 186.73,61.13 186.73,56.89 192.25,51.37 197.3,46.32 197.3,45.59 198.05,44.84 198.05,40.63 206.14,32.54 227.01,32.54 229,34.53 v2(229,34.7)
  IN2 w0.127: v2(268.54,88.33) 268.4,88.47 267.95,88.47 265.63,90.79 263.25,90.79 262.52,90.06 253.91,90.06 253.11,89.26 v2(253.08,89.26)
  BOTTOM w0.089: 195.93,69.24 196.22,69.52 196.66,69.52 196.67,69.53 196.67,69.53 196.81,69.68 197.19,69.68 197.61,70.09 UH1.AU2
  BOTTOM w0.102: v2(264.1,29.59) 262.94,30.76 v1(262.94,31.06) 260.94,33.06 260.94,36.72 259.48,38.18 259.48,47.18 259.33,47.33 259.33,51.73 259.01,52.06 258.2,52.06 257.73,52.53 257.73,53.66 256.68,54.71 256.68,55.99 253.89,58.78 253.89,62.17 253.42,62.64 253.42,85.23 253.08,85.58 v2(253.08,89.26) ; 195.93,69.24 195.89,69.19 195.65,69.19 195.13,68.67 194.13,68.67 194.12,68.67 194.1,68.67 194,68.57 193.57,68.57 193.35,68.78 192.64,68.78 191.25,70.17 v2(190.97,70.17) 190.45,70.17 190.27,69.99 190.09,69.81 188,69.81 QH2.1 187.17,68.1 187.72,68.1
BBS_BIT1: length 6.9
  BOTTOM w0.089: UH1.C10 210.41,62.46 210.88,62.46 211.06,62.28 211.06,61.92 211.79,61.19
  BOTTOM w0.102: 211.79,61.19 212.13,60.85 212.13,60.71 212.77,60.07 212.77,59.92 213.48,59.2 RH119.1 214.08,57.85 v1(214.08,57.77)
BC_CLK_ECE1117: length 41.7
  TOP w0.102: v2(290.53,121.09) 290.17,120.73 289.95,120.73 289.62,120.4 289.62,119.84 289.72,119.75 U51.A20 ; JKB1.9 314.89,130.62 314.78,130.73 314.78,131.24 314.56,131.46 308.89,131.46 302.89,125.46 v1(301.2,125.46) 293.99,125.46 v2(293.89,125.36)
  IN1 w0.102: v2(290.53,121.09) 291.07,120.56 291.28,120.56 291.41,120.69 291.41,121.75 291.28,121.88 289.26,121.88 289.14,121.75 289.14,121.17 289.04,121.08 288.62,121.08 288.18,121.51 288.18,122.21 288.41,122.44 289.35,122.44 291.27,124.36 291.27,124.6 292.03,125.36 v2(293.89,125.36)
BC_CLK_ECE5048: length 78
  TOP w0.102: U51.A43 282,112.65 v2(281.3,112.65) ; U46.A30 265.44,58.41 265.25,58.6 265.25,59.33 265.37,59.46 v2(265.67,59.46)
  IN2 w0.127: v2(275.42,59.51) 275.5,59.43 275.5,59.25 275.26,59.02 273.01,59.02 272.3,59.73 271.79,59.73 271.13,59.07 271.13,58.7 270.32,57.88 267.32,57.88 265.74,59.46 v2(265.67,59.46)
  IN4 w0.102: v2(281.3,112.65) 281.3,113.11 281.43,113.24 282.46,113.24 282.58,113.11 282.58,112.65 282.46,112.52 282.15,112.52 282.08,112.45 282.08,111.87 281.41,111.21 280.2,111.21 279.93,110.94 279.93,110.02 279.09,109.18 278.21,109.18 276.74,107.71 276.74,106.7 276.82,106.62 276.82,106.16 275.95,105.3 275.95,99.16 276.56,98.55 276.56,96.05 276.23,95.72 275.66,95.72 273.66,93.72 273.66,92.73 272.86,91.92 272.86,76.67 273.1,76.43 273.1,75.65 274.35,74.4 274.35,64.95 275.94,63.35 275.94,61.79 275.6,61.44 275.6,59.69 v2(275.42,59.51)
BC_DAT_ECE1117: length 41.1
  TOP w0.102: U51.B21 289.97,118.27 289.73,118.03 v2(289.73,117.82) ; v2(293.91,125.97) v1(297.59,125.97) 302.94,125.97 308.82,131.85 314.4,131.85 315.16,132.62 JKB1.7 ; v2(287.19,123.24) 287.19,123.25 287.02,123.43 287.02,123.81 R817.2
  IN1 w0.102: v2(293.91,125.97) 292.31,125.97 290.95,124.61 290.95,124.46 289.25,122.76 287.68,122.76 v2(287.19,123.24) 287.19,122.16 288.72,120.64 288.72,118.88 289.24,118.36 289.24,118.31 v2(289.73,117.82)
BC_DAT_ECE5048: length 84.8
  TOP w0.102: R814.2 276.94,113.3 277.35,112.88 v2(277.35,112.66) 278.41,112.66 v1(278.8,112.27) ; U46.B31 265.69,56.65 v2(265.58,56.54) ; v2(283.59,112.9) 283.58,112.91 U51.B45
  IN2 w0.127: v2(283.59,112.9) 282.78,112.9 282.32,113.36 279.64,113.36 278.9,112.62 277.98,112.62 277.94,112.66 v2(277.35,112.66) ; v2(265.58,56.54) 265.58,56.97 265.98,57.37 267.02,57.37 267.28,57.63 270.43,57.63 271.39,58.59 271.39,58.97 271.89,59.47 272.19,59.47 272.9,58.76 275.37,58.76 276,59.4 v2(276,59.51)
  IN4 w0.102: v2(283.59,112.9) 283.54,112.9 281.63,110.99 280.3,110.99 280.16,110.85 280.16,109.93 279.19,108.95 278.31,108.95 276.97,107.61 276.97,106.79 277.05,106.72 277.05,106.06 276.18,105.2 276.18,99.25 276.79,98.64 276.79,95.96 276.32,95.49 275.76,95.49 273.99,93.72 273.99,92.66 273.21,91.88 273.21,76.68 273.36,76.53 273.36,75.76 274.58,74.54 274.58,65.04 276.17,63.45 276.17,61.69 275.83,61.35 275.83,59.69 v2(276,59.51)
BC_INT#_ECE1117: length 35.5
  TOP w0.102: U51.A19 290.22,119.9 290.05,120.07 v2(290.05,120.13) ; v1(317.24,132.69) 316.32,133.62 JKB1.6 308.86,133.62 v2(308.85,133.6)
  IN3 w0.127: v2(308.85,133.6) 308.85,131.06 299.21,121.43 297.72,121.43 296.93,120.64 290.74,120.64 290.23,120.13 v2(290.05,120.13)
BC_INT#_ECE5048: length 72.8
  TOP w0.102: U46.A29 265.94,58.58 265.68,58.84 v2(265.68,58.88) ; U51.A42 280.86,113.16 280.73,113.03 280.73,112.62 v2(280.7,112.6)
  IN4 w0.102: v2(273.95,59.45) 274.72,60.22 274.72,63.62 274.06,64.27 273.34,64.27 273.17,64.44 273.17,69.2 272.3,70.08 272.3,71.98 272.98,72.67 272.98,74.94 271.23,76.7 271.23,90.72 273.33,92.82 273.33,93.73 275.58,95.99 276.12,95.99 276.33,96.2 276.33,98.41 275.7,99.05 275.7,106.34 276.46,107.1 276.46,107.8 279.48,110.82 279.48,111.84 279.84,112.19 280.3,112.19 v2(280.7,112.6)
  BOTTOM w0.102: v2(265.68,58.88) 265.76,58.88 266.21,58.42 267.33,58.42 267.66,58.09 v1(271.13,58.09) 272.59,58.09 v2(273.95,59.45)
