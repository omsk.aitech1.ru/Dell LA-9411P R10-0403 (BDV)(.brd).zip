# Allegro board LA-9411P R10-0403.brd (continued)
## Nets (continued)
GND: C1.2 C7.2 C18.2 C25.2 C26.2 C27.2 C28.2 C29.2 C30.2 C31.2 C32.2 C40.2 C41.2 C43.2 C44.2 C45.2 C46.2 C47.2 C49.2 C51.2 C52.2 C53.2 C106.2 C107.2 C108.2 C109.2 C110.2 C111.2 C112.2 C113.2 C114.2 C115.2 C116.2 C117.2 C246.2 C247.2 C284.2 C288.2 C289.2 C290.2 C296.2 C298.2 C299.2 C300.2 C301.2 C340.2 C342.2 C344.2 C354.2 C355.2 C356.2 C365.2 C366.2 C369.2 C387.2 C388.2 C395.2 C396.2 C397.2 C398.2 C399.2 C400.2 C401.2 C402.2 C412.2 C423.2 C445.2 C446.2 C447.2 C448.2 C449.2 C450.2 C451.2 C452.2 C454.2 C455.2 C456.2 C462.2 C463.2 C464.2 C465.2 C466.2 C467.2 C468.2 C469.2 C470.1 C471.1 C472.2 C473.2 C474.2 C475.2 C476.2 C477.2 C478.2 C479.2 C480.2 C481.2 C482.2 C483.2 C484.2 C485.1 C486.2 C487.2 C488.2 C550.2 C551.2 C552.2 C553.2 C559.1 C560.1 C561.1 C562.1 C564.1 C566.1 C570.2 C572.2 C573.2 C574.2 C575.2 C576.2 C577.2 C578.2 C579.2 C580.2 C581.2 C595.2 C603.2 C604.2 C605.2 C606.1 C607.1 C608.2 C610.2 C611.2 C612.2 C613.2 C614.2 C615.2 C616.2 C621.2 C622.2 C623.2 C624.1 C625.1 C626.2 C628.2 C629.2 C630.2 C631.2 C633.2 C634.2 C635.2 C636.2 C637.2 C638.2 C639.2 C640.2 C641.2 C642.2 C643.2 C645.2 C646.2 C649.2 C651.2 C654.2 C667.2 C668.2 C675.2 C676.2 C677.2 C678.2 C695.2 C696.2 C701.2 C702.2 C703.2 C704.2 C705.2 C706.2 C707.2 C708.2 C709.2 C710.2 C712.2 C713.2 C714.2 C715.2 C716.2 C717.2 C718.2 C719.2 C720.2 C721.2 C722.2 C723.2 C724.2 C725.2 C726.2 C733.2 C734.2 C735.2 C736.2 C737.2 C739.2 C740.2 C741.2 C742.2 C743.2 C744.2 C746.2 C747.2 C749.2 C750.2 C751.2 C752.2 C755.2 C756.2 C757.2 C758.2 C759.2 C760.2 C761.2 C762.2 C765.2 C771.2 C772.2 C773.2 C774.2 C775.2 C776.2 C777.2 C778.2 C779.2 C780.2 C781.2 C782.2 C783.2 C800.1 C801.1 C802.1 C952.2 C953.2 C954.2 C958.2 C959.2 C960.2 C961.2 C967.2 C977.2 C978.2 C984.2 C986.2 C987.2 C989.2 C994.2 C998.2 C1001.2 C1004.2 C1167.2 C1176.2 C1177.2 C1178.2 C1206.2 C1207.2 C1216.2 C1501.1 C1502.1 C1503.1 C1504.1 C1505.1 C1506.1 C1507.1 C1508.1 C1509.1 C1510.1 C1511.1 C1512.2 C1513.2 C1514.2 C1515.2 C1522.2 C1523.2 C1524.2 C1525.2 C1526.2 C1527.2 C1528.2 C1529.2 C1530.2 C1537.2 C1538.2 C1539.2 C1540.2 C1541.2 C1542.2 C1544.2 C1545.2 C1548.2 C1549.2 C1552.2 C1557.2 C1558.2 C1559.2 CC17.2 CC18.2 CC19.2 CC21.2 CC24.2 CC25.2 CC26.2 CC27.2 CC28.2 CC29.2 CC30.2 CC31.2 CC32.2 CC33.2 CC34.2 CC35.2 CC36.2 CC37.2 CC38.2 CC39.2 CC40.2 CC41.2 CC42.2 CC43.2 CC44.2 CC45.2 CC46.2 CC47.2 CC48.2 CC135.2 CC136.2 CC137.2 CD1.2 CD2.2 CD3.2 CD4.2 CD5.2 CD6.2 CD7.2 CD8.2 CD9.2 CD10.2 CD11.2 CD12.2 CD13.2 CD14.2 CD15.2 CD16.2 CD17.2 CD18.2 CD19.2 CD20.2 CD21.2 CD22.2 CD23.2 CD24.2 CD25.2 CD26.2 CD27.2 CD28.2 CD29.2 CD30.2 CD31.2 CD32.2 CD33.2 CD34.2 CD35.2 CD36.2 CD37.2 CD38.2 CD39.2 CD40.2 CD41.2 CD42.2 CD43.2 CD44.2 CD45.2 CE1.2 CE2.2 CE3.2 CE5.2 CE6.2 CE7.2 CE8.2 CE9.2 CE10.2 CE11.2 CE12.2 CE13.2 CE14.2 CE15.2 CE16.2 CE17.2 CE18.2 CE759.2 CH2.2 CH4.1 CH5.1 CH6.1 CH7.1 CH8.2 CH9.2 CH10.2 CH11.2 CH12.2 CH13.1 CH14.1 CH15.2 CH16.2 CH17.2 CH18.2 CH19.2 CH20.2 CH21.2 CH22.2 CH23.2 CH24.2 CH25.2 CH26.2 CH27.2 CH28.2 CH29.2 CH30.2 CH31.2 CH32.2 CH33.2 CH34.2 CH35.2 CH36.2 CH37.2 CH38.2 CH39.2 CH40.2 CH41.2 CH42.2 CH43.2 CH44.2 CH45.2 CH46.2 CH47.2 CH48.2 CH49.2 CH50.2 CH51.2 CH52.2 CH53.2 CH54.2 CH55.2 CH56.2 CH57.2 CH58.2 CH59.2 CH60.2 CH61.2 CH62.2 CH63.2 CH64.2 CH65.2 CH66.2 CH67.2 CH68.2 CH69.2 CH70.2 CH71.2 CH72.2 CH73.2 CH74.2 CH75.2 CH76.2 CH77.2 CH78.2 CH79.2 CH80.2 CLIP1.1(TP-1) CMOS1.1 CV13.2 CV20.2 CV22.2 CV23.2 CV25.2 CV27.2 CV29.2 CV31.2 CV33.2 CV35.2 CV37.2 CV39.2 CV41.2 CV42.2 CV43.2 CV44.2 CV45.2 CV46.2 CV47.2 CV48.2 CV49.2 CV50.2 CV51.2 CV52.2 CV53.2 CV54.2 CV55.2 CV56.2 CV57.2 CV58.2 CV59.2 CV60.2 CV61.2 CV62.2 CV63.2 CV64.2 CV65.2 CV66.2 CV67.2 CV68.2 CV69.2 CV70.2 CV71.2 CV72.2 CV73.2 CV74.2 CV87.2 CV92.2 CV93.2 CV94.2 CV95.2 CV98.2 CV113.2 CV114.2 CV115.2 CV116.2 CV117.2 CV118.2 CV119.2 CV129.2 CV130.2 CV131.2 CV133.2 CV134.2 CV135.2 CV137.2 CV138.2 CV139.2 CV140.2 CV141.2 CV142.2 CV143.2 CV144.2 CV145.2 CV146.2 CV147.2 CV148.2 CV149.2 CV150.2 CV151.2 CV152.2 CV153.2 CV154.2 CV155.2 CV156.2 CV157.2 CV158.2 CV159.2 CV162.2 CV163.2 CV168.2 CV170.2 CV173.2 CV176.2 CV177.2 CV178.2 CV179.2 CV180.2 CV181.2 CV182.2 CV185.2 CV188.2 CV189.2 CV191.2 CV192.2 CV198.2 CV199.2 CV200.2 CV201.2 CV202.2 CV203.2 CV204.2 CV206.2 CV207.2 CV210.2 CV211.2 CV212.2 CV213.2 CV214.2 CV215.2 CV216.2 CV217.2 CV218.2 CV219.2 CV220.2 CV221.2 CV222.2 CV223.2 CV224.2 CV225.2 CV226.2 CV227.2 CV237.2 CV238.2 CV274.2 CV275.2 CV278.2 CV279.2 CV280.2 CV281.2 CV283.2 CV284.2 CV285.2 CV286.2 CV287.2 CV288.2 CV290.2 CV291.2 CV292.2 CV293.2 CV294.2 CV295.2 CV296.2 CV297.2 CV298.2 CV299.2 CV301.2 CV302.2 CV303.2 CV304.2 CV305.2 CV306.2 CV307.2 CV308.2 CV309.2 CV310.2 CV311.2 CV312.2 CV313.2 CV315.2 CV316.2 CV318.2 CV319.2 CV320.2 CV324.2 CV326.2 CV327.2 CV329.2 CV331.2 CV332.2 CV340.2 CV341.2 CV342.2 CV343.2 CV349.2 CV351.2 CV353.2 CV355.2 CV357.2 CV358.2 D1.2 D8.1 D23.1 D33.1 D37.1 D72.1 D74.1 D78.3 D78.8 D79.3 D79.8 D88.3 D88.8 D89.1 D90.1 D91.3 D91.8 H1.1(TP-1) H2.1(TP-1) H3.1(TP-1) H4.1(TP-1) H5.1(TP-1) H6.1(TP-1) H7.1(TP-1) H8.1(TP-1) H9.1(TP-1) H10.1(TP-1) H11.1(TP-1) H12.1(TP-1) H13.1(TP-1) H14.1(TP-1) H15.1(TP-1) H16.1(TP-1) H17.1(TP-1) H18.1(TP-1) H19.1(TP-1) H20.1(TP-1) H21.1(TP-1) H22.1(TP-1) H23.1(TP-1) H24.1(TP-1) H25.1(TP-1) H26.1(TP-1) H27.1(TP-1) H28.1(TP-1) H29.1(TP-1) H30.1(TP-1) JAPS1.8 JAPS1.10 JAPS1.12 JAPS1.14 JAPS1.17 JAPS1.18 JBTB1.1 JBTB1.2 JBTB1.7 JBTB1.13 JBTB1.17 JBTB1.21 JBTB1.25 JBTB1.29 JBTB1.31 JBTB1.32 JCAM1.6 JCAM1.8 JCAM1.9 JCAM1.10 JCPU1.A3 JCPU1.A4 JCPU1.A7 JCPU1.A10 JCPU1.A13 JCPU1.A16 JCPU1.A19 JCPU1.A22 JCPU1.A25 JCPU1.A27 JCPU1.A29 JCPU1.A31 JCPU1.A33 JCPU1.AA11 JCPU1.AA25 JCPU1.AA27 JCPU1.AA29 JCPU1.AA31 JCPU1.AA33 JCPU1.AA35 JCPU1.AB1 JCPU1.AB3 JCPU1.AB4 JCPU1.AB6 JCPU1.AB7 JCPU1.AB9 JCPU1.AB10 JCPU1.AC11 JCPU1.AC25 JCPU1.AC27 JCPU1.AC29 JCPU1.AC31 JCPU1.AC33 JCPU1.AC35 JCPU1.AD7 JCPU1.AD11 JCPU1.AE1 JCPU1.AE3 JCPU1.AE4 JCPU1.AE6 JCPU1.AE7 JCPU1.AE9 JCPU1.AE10 JCPU1.AE25 JCPU1.AE27 JCPU1.AE29 JCPU1.AE31 JCPU1.AE33 JCPU1.AE35 JCPU1.AF6 JCPU1.AF8 JCPU1.AF11 JCPU1.AG6 JCPU1.AG11 JCPU1.AG25 JCPU1.AG27 JCPU1.AG29 JCPU1.AG31 JCPU1.AG33 JCPU1.AG35 JCPU1.AH1 JCPU1.AH2 JCPU1.AH3 JCPU1.AH4 JCPU1.AH5 JCPU1.AH6 JCPU1.AH7 JCPU1.AH8 JCPU1.AH9 JCPU1.AH10 JCPU1.AJ5 JCPU1.AJ11 JCPU1.AK5 JCPU1.AK11 JCPU1.AK25 JCPU1.AK26 JCPU1.AK28 JCPU1.AK29 JCPU1.AK30 JCPU1.AK32 JCPU1.AK34 JCPU1.AL1 JCPU1.AL2 JCPU1.AL3 JCPU1.AL4 JCPU1.AL5 JCPU1.AL6 JCPU1.AL7 JCPU1.AL8 JCPU1.AL9 JCPU1.AL10 JCPU1.AL11 JCPU1.AL12 JCPU1.AL14 JCPU1.AL15 JCPU1.AL17 JCPU1.AL18 JCPU1.AL19 JCPU1.AL20 JCPU1.AL21 JCPU1.AL22 JCPU1.AL23 JCPU1.AL24 JCPU1.AL31 JCPU1.AL32 JCPU1.AM4 JCPU1.AM7 JCPU1.AM10 JCPU1.AM13 JCPU1.AM16 JCPU1.AM19 JCPU1.AM20 JCPU1.AM21 JCPU1.AM22 JCPU1.AM23 JCPU1.AM24 JCPU1.AM25 JCPU1.AM32 JCPU1.AN2 JCPU1.AN4 JCPU1.AN7 JCPU1.AN10 JCPU1.AN13 JCPU1.AN16 JCPU1.AN19 JCPU1.AN21 JCPU1.AN24 JCPU1.AN27 JCPU1.AN30 JCPU1.AN34 JCPU1.AP1 JCPU1.AP4 JCPU1.AP7 JCPU1.AP10 JCPU1.AP13 JCPU1.AP16 JCPU1.AP19 JCPU1.AP27 JCPU1.AP34 JCPU1.AP35 JCPU1.AR2 JCPU1.AR4 JCPU1.AR7 JCPU1.AR10 JCPU1.AR13 JCPU1.AR16 JCPU1.AR19 JCPU1.AR22 JCPU1.AR25 JCPU1.AR26 JCPU1.AR28 JCPU1.AR31 JCPU1.AR34 JCPU1.AT3 JCPU1.AT4 JCPU1.AT7 JCPU1.AT10 JCPU1.AT13 JCPU1.AT16 JCPU1.AT19 JCPU1.AT21 JCPU1.AT24 JCPU1.AT27 JCPU1.AT30 JCPU1.AT32 JCPU1.AT33 JCPU1.AT34 JCPU1.B2 JCPU1.B4 JCPU1.B7 JCPU1.B10 JCPU1.B13 JCPU1.B16 JCPU1.B19 JCPU1.B22 JCPU1.B34 JCPU1.C1 JCPU1.C2 JCPU1.C4 JCPU1.C7 JCPU1.C10 JCPU1.C13 JCPU1.C16 JCPU1.C19 JCPU1.C22 JCPU1.C24 JCPU1.C26 JCPU1.C28 JCPU1.C30 JCPU1.C32 JCPU1.C34 JCPU1.D4 JCPU1.D7 JCPU1.D10 JCPU1.D13 JCPU1.D16 JCPU1.D19 JCPU1.D22 JCPU1.D25 JCPU1.D27 JCPU1.D29 JCPU1.D31 JCPU1.D33 JCPU1.D35 JCPU1.E1 JCPU1.E4 JCPU1.E7 JCPU1.E10 JCPU1.E13 JCPU1.E16 JCPU1.E19 JCPU1.E22 JCPU1.E25 JCPU1.F4 JCPU1.F6 JCPU1.F7 JCPU1.F8 JCPU1.F9 JCPU1.F10 JCPU1.F11 JCPU1.F12 JCPU1.F14 JCPU1.F15 JCPU1.F17 JCPU1.F18 JCPU1.F19 JCPU1.F20 JCPU1.F21 JCPU1.F23 JCPU1.F24 JCPU1.F26 JCPU1.F28 JCPU1.F30 JCPU1.F32 JCPU1.F34 JCPU1.G1 JCPU1.G2 JCPU1.G3 JCPU1.G4 JCPU1.G5 JCPU1.G11 JCPU1.G27 JCPU1.G29 JCPU1.G31 JCPU1.G33 JCPU1.G35 JCPU1.H6 JCPU1.H7 JCPU1.H10 JCPU1.H11 JCPU1.H26 JCPU1.J6 JCPU1.J11 JCPU1.J26 JCPU1.J28 JCPU1.J30 JCPU1.J32 JCPU1.J34 JCPU1.K1 JCPU1.K2 JCPU1.K3 JCPU1.K4 JCPU1.K5 JCPU1.K7 JCPU1.K8 JCPU1.K9 JCPU1.K10 JCPU1.K29 JCPU1.K31 JCPU1.K33 JCPU1.K35 JCPU1.L6 JCPU1.L11 JCPU1.L26 JCPU1.M6 JCPU1.M11 JCPU1.M26 JCPU1.M28 JCPU1.M30 JCPU1.M32 JCPU1.M34 JCPU1.N1 JCPU1.N2 JCPU1.N3 JCPU1.N4 JCPU1.N5 JCPU1.N6 JCPU1.N7 JCPU1.N9 JCPU1.N10 JCPU1.N29 JCPU1.N31 JCPU1.N33 JCPU1.N35 JCPU1.P5 JCPU1.P11 JCPU1.P26 JCPU1.R5 JCPU1.R10 JCPU1.R11 JCPU1.R26 JCPU1.R28 JCPU1.R30 JCPU1.R32 JCPU1.R34 JCPU1.T1 JCPU1.T3 JCPU1.T4 JCPU1.T6 JCPU1.T7 JCPU1.T9 JCPU1.T10 JCPU1.T26 JCPU1.T29 JCPU1.T31 JCPU1.T33 JCPU1.T35 JCPU1.U11 JCPU1.U27 JCPU1.V10 JCPU1.V11 JCPU1.V28 JCPU1.V30 JCPU1.V32 JCPU1.V34 JCPU1.W1 JCPU1.W3 JCPU1.W4 JCPU1.W6 JCPU1.W7 JCPU1.W9 JCPU1.W10 JCPU1.W25 JCPU1.W33 JCPU1.W35 JCPU1.Y11 JDEG2.10 JDEG2.11 JDEG2.12 JDIMM1.2 JDIMM1.3 JDIMM1.8 JDIMM1.9 JDIMM1.11 JDIMM1.13 JDIMM1.14 JDIMM1.19 JDIMM1.20 JDIMM1.25 JDIMM1.26 JDIMM1.28 JDIMM1.31 JDIMM1.32 JDIMM1.37 JDIMM1.38 JDIMM1.43 JDIMM1.44 JDIMM1.46 JDIMM1.48 JDIMM1.49 JDIMM1.54 JDIMM1.55 JDIMM1.60 JDIMM1.61 JDIMM1.63 JDIMM1.65 JDIMM1.66 JDIMM1.71 JDIMM1.72 JDIMM1.127 JDIMM1.128 JDIMM1.133 JDIMM1.134 JDIMM1.136 JDIMM1.138 JDIMM1.139 JDIMM1.144 JDIMM1.145 JDIMM1.150 JDIMM1.151 JDIMM1.153 JDIMM1.155 JDIMM1.156 JDIMM1.161 JDIMM1.162 JDIMM1.167 JDIMM1.168 JDIMM1.170 JDIMM1.172 JDIMM1.173 JDIMM1.178 JDIMM1.179 JDIMM1.184 JDIMM1.185 JDIMM1.187 JDIMM1.189 JDIMM1.190 JDIMM1.195 JDIMM1.196 JDIMM1.205 JDIMM1.206 JDIMM2.2 JDIMM2.3 JDIMM2.8 JDIMM2.9 JDIMM2.11 JDIMM2.13 JDIMM2.14 JDIMM2.19 JDIMM2.20 JDIMM2.25 JDIMM2.26 JDIMM2.28 JDIMM2.31 JDIMM2.32 JDIMM2.37 JDIMM2.38 JDIMM2.43 JDIMM2.44 JDIMM2.46 JDIMM2.48 JDIMM2.49 JDIMM2.54 JDIMM2.55 JDIMM2.60 JDIMM2.61 JDIMM2.63 JDIMM2.65 JDIMM2.66 JDIMM2.71 JDIMM2.72 JDIMM2.127 JDIMM2.128 JDIMM2.133 JDIMM2.134 JDIMM2.136 JDIMM2.138 JDIMM2.139 JDIMM2.144 JDIMM2.145 JDIMM2.150 JDIMM2.151 JDIMM2.153 JDIMM2.155 JDIMM2.156 JDIMM2.161 JDIMM2.162 JDIMM2.167 JDIMM2.168 JDIMM2.170 JDIMM2.172 JDIMM2.173 JDIMM2.178 JDIMM2.179 JDIMM2.184 JDIMM2.185 JDIMM2.187 JDIMM2.189 JDIMM2.190 JDIMM2.195 JDIMM2.196 JDIMM2.205 JDIMM2.206 JDOCK1.1 JDOCK1.7 JDOCK1.8 JDOCK1.13 JDOCK1.14 JDOCK1.19 JDOCK1.20 JDOCK1.25 JDOCK1.26 JDOCK1.31 JDOCK1.32 JDOCK1.37 JDOCK1.38 JDOCK1.43 JDOCK1.44 JDOCK1.47 JDOCK1.49 JDOCK1.50 JDOCK1.51 JDOCK1.52 JDOCK1.55 JDOCK1.57 JDOCK1.58 JDOCK1.61 JDOCK1.63 JDOCK1.64 JDOCK1.69 JDOCK1.70 JDOCK1.75 JDOCK1.76 JDOCK1.81 JDOCK1.82 JDOCK1.87 JDOCK1.88 JDOCK1.91 JDOCK1.93 JDOCK1.94 JDOCK1.95 JDOCK1.96 JDOCK1.101 JDOCK1.102 JDOCK1.107 JDOCK1.108 JDOCK1.113 JDOCK1.114 JDOCK1.119 JDOCK1.120 JDOCK1.123 JDOCK1.125 JDOCK1.126 JDOCK1.131 JDOCK1.132 JDOCK1.137 JDOCK1.138 JDOCK1.145 JDOCK1.152 JDOCK1.153 JDOCK1.154 JDOCK1.155 JDOCK1.156 JDOCK1.157 JDOCK1.158 JDOCK1.159 JDOCK1.160 JDOCK1.161 JDOCK1.162 JDOCK1.163 JDOCK1.164 JEXP1.1 JEXP1.4 JEXP1.7 JEXP1.13 JEXP1.19 JEXP1.20 JEXP1.25 JEXP1.29 JEXP1.30 JEXP1.31 JEXP1.32 JFAN1.4 JFAN1.5 JFAN1.6 JHDMI1.2 JHDMI1.5 JHDMI1.8 JHDMI1.11 JHDMI1.17 JHDMI1.20 JHDMI1.21 JHDMI1.22 JHDMI1.23 JKB1.8 JKB1.10 JKB1.11 JKB1.12 JLED2.6 JLED2.7 JLED2.8 JLOM1.15 JLVDS1.11 JLVDS1.12 JLVDS1.13 JLVDS1.14 JLVDS1.17 JLVDS1.24 JLVDS1.27 JLVDS1.41 JLVDS1.42 JLVDS1.43 JLVDS1.44 JMDC1.1 JMDC1.5 JMDC1.8 JMDC1.10 JMDC1.13 JMDC1.14 JMDC1.15 JMDC1.16 JMDC1.17 JMDC1.18 JMINI1.4 JMINI1.9 JMINI1.15 JMINI1.18 JMINI1.21 JMINI1.26 JMINI1.27 JMINI1.29 JMINI1.34 JMINI1.35 JMINI1.43 JMINI1.50 JMINI1.53 JMINI1.54 JMINI2.4 JMINI2.9 JMINI2.15 JMINI2.18 JMINI2.21 JMINI2.26 JMINI2.27 JMINI2.29 JMINI2.34 JMINI2.35 JMINI2.43 JMINI2.50 JMINI2.53 JMINI2.54 JMINI3.4 JMINI3.9 JMINI3.15 JMINI3.18 JMINI3.21 JMINI3.26 JMINI3.27 JMINI3.29 JMINI3.34 JMINI3.35 JMINI3.43 JMINI3.50 JMINI3.53 JMINI3.54 JRTC1.2 JRTC1.3 JRTC1.4 JSATA1.1 JSATA1.4 JSATA1.7 JSATA1.11 JSATA1.13 JSATA1.17 JSATA1.19 JSATA1.23 JSATA1.24 JSATA2.1 JSATA2.4 JSATA2.7 JSATA2.12 JSATA2.13 JSATA2.14 JSATA2.17 JSATA2.20 JSATA2.21 JSATA2.24 JSATA2.32 JSATA2.33 JSD1.3 JSD1.6 JSD1.10 JSD1.13 JSD1.19 JSD1.20 JSD1.21 JSD1.22 JSD1.23 JSD1.24 JSD1.25 JSF1.2 JSF1.5 JSF1.6 JSIM1.5 JSIM1.10 JSIM1.11 JSIM1.12 JSIM1.13 JSIM1.14 JSIM1.15 JSIM1.16 JSIM1.17 JSIM1.18 JSPI1.17 JSPI1.18 JSPI1.19 JSPI1.20 JSPI1.21 JSPI1.22 JSPK1.5 JSPK1.6 JTAG1.2 JTP1.1 JTP1.9 JTP1.10 JUSB1.4 JUSB1.7 JUSB1.10 JUSB1.11 JUSB1.12 JUSB1.13 JUSB2.4 JUSB2.7 JUSB2.10 JUSB2.11 JUSB2.12 JUSB2.13 JUSB3.4 JUSB3.7 JUSB3.10 JUSB3.11 JUSB3.12 JUSB3.13 JUSB4.4 JUSB4.7 JUSB4.10 JUSB4.11 JUSB4.12 JUSB4.13 JUSH1.2 JUSH1.3 JUSH1.17 JUSH1.20 JUSH1.21 JUSH1.22 JXDP1.1 JXDP1.2 JXDP1.7 JXDP1.8 JXDP1.13 JXDP1.14 JXDP1.19 JXDP1.20 JXDP1.25 JXDP1.26 JXDP1.31 JXDP1.32 JXDP1.37 JXDP1.38 JXDP1.49 JXDP1.50 JXDP1.59 JXDP2.1 JXDP2.2 JXDP2.7 JXDP2.8 JXDP2.13 JXDP2.14 JXDP2.19 JXDP2.20 JXDP2.25 JXDP2.26 JXDP2.31 JXDP2.32 JXDP2.37 JXDP2.38 JXDP2.49 JXDP2.50 JXDP2.59 JXDP2.60 MBATT1.5 MBATT1.6 MBATT1.7 MBATT1.8 ME1.1 PBATT1.1 PBATT1.2 PBATT1.4 PBATT1.10 PBATT1.11 PC1.2 PC2.2 PC3.2 PC4.2 PC5.2 PC7.2 PC9.2 PC10.2 PC11.2 PC12.2 PC13.2 PC14.2 PC15.2 PC16.2 PC17.2 PC101.2 PC102.2 PC103.2 PC104.2 PC105.2 PC106.2 PC107.2 PC108.2 PC109.2 PC110.2 PC114.1 PC116.2 PC117.2 PC118.2 PC119.2 PC120.2 PC201.2 PC202.2 PC203.2 PC204.2 PC205.2 PC207.2 PC208.2 PC209.2 PC210.2 PC212.2 PC213.2 PC214.2 PC215.2 PC216.2 PC301.2 PC302.2 PC303.2 PC304.2 PC305.2 PC307.2 PC308.2 PC309.2 PC400.2 PC401.2 PC403.2 PC404.2 PC405.2 PC406.2 PC407.2 PC500.1 PC502.2 PC503.2 PC504.2 PC505.2 PC506.2 PC507.2 PC509.1 PC510.2 PC511.2 PC512.2 PC513.2 PC514.2 PC515.2 PC516.2 PC518.2 PC525.1 PC526.1 PC527.1 PC530.2 PC531.2 PC532.2 PC533.2 PC534.2 PC535.2 PC536.2 PC537.2 PC541.1 PC546.1 PC547.2 PC548.1 PC601.2 PC602.2 PC603.2 PC604.2 PC606.2 PC607.2 PC608.2 PC610.2 PC619.2 PC620.2 PC621.2 PC622.2 PC628.2 PC629.2 PC631.2 PC660.2 PC661.2 PC662.2 PC663.2 PC664.2 PC665.2 PC666.2 PC667.2 PC669.2 PC670.2 PC672.2 PC673.2 PC674.2 PC675.2 PC676.2 PC677.2 PC679.2 PC680.2 PC701.2 PC702.2 PC706.2 PC707.2 PC710.2 PC711.2 PC712.2 PC713.2 PC714.2 PC717.2 PC718.2 PC719.2 PC720.2 PC724.2 PC725.2 PC726.2 PC727.2 PC728.2 PC729.2 PC730.2 PC731.2 PC732.2 PC733.1 PC734.2 PC735.2 PC736.2 PC737.2 PC738.2 PC739.2 PC740.2 PC800.2 PC801.1 PC802.1 PC803.2 PC804.1 PC805.1 PC806.2 PC808.1 PC810.1 PC811.2 PC812.1 PC813.2 PC814.2 PC815.2 PC816.2 PC817.2 PC818.1 PC900.2 PC901.2 PC902.2 PC903.2 PC904.2 PC905.2 PC906.2 PC907.2 PC908.2 PC909.2 PC910.2 PC911.2 PC912.2 PC913.2 PC914.2 PC915.2 PC916.2 PC917.2 PC918.2 PC919.2 PC920.2 PC921.2 PC922.2 PC923.2 PC924.2 PC925.2 PC926.2 PC927.2 PC928.2 PC929.2 PC930.2 PC931.2 PC932.2 PC933.2 PC934.2 PC935.2 PC936.2 PC937.2 PC938.2 PC939.2 PC940.2 PC941.2 PC942.2 PC943.2 PC944.2 PC945.2 PC946.2 PC947.2 PC948.2 PC949.2 PC950.2 PC951.2 PC952.2 PC953.2 PC954.2 PC955.2 PC956.2 PC957.2 PC958.2 PC959.2 PC960.2 PC961.2 PC962.2 PC963.2 PC964.2 PC965.2 PC966.2 PC967.2 PC968.2 PC969.2 PC970.2 PC971.2 PCV172.2 PCV174.2 PCV175.2 PCV183.2 PD1.2 PD2.1 PD4.1 PJP4.2 PJP62.2 PJP602.2 PJP701.2 PQ2.3 PQ5.3 PQ6.6 PQ103.1 PQ103.2 PQ103.3 PQ104.1 PQ104.2 PQ104.3 PQ203.1 PQ203.2 PQ203.3 PQ303.1 PQ303.2 PQ303.3 PQ503.1 PQ503.2 PQ503.3 PQ504.1 PQ504.2 PQ504.3 PQ507.1 PQ507.2 PQ507.3 PQ508.1 PQ508.2 PQ508.3 PQ511.1 PQ511.2 PQ511.3 PQ512.1 PQ512.2 PQ512.3 PQ602.1 PQ602.2 PQ602.3 PQ603.1 PQ603.2 PQ603.3 PQ606.1 PQ606.2 PQ606.3 PQ607.1 PQ607.2 PQ607.3 PQ610.3 PQ706.1 PQ706.2 PQ706.3 PQ707.1 PQ707.4 PQ709.3 PQ710.3 PQ711.1 PQ711.2 PQ711.3 PQ802.1 PQ802.4 PQ805.1 PQ805.4 PQ806.1 PQ806.4 PQ807.1 PQ807.4 PQ808.4 PQ812.4 PQ813.1 PQ813.4 PQ816.3 PQ817.3 PQ818.3 PQ819.1 PQ819.4 PQ821.1 PQ821.4 PQ824.1 PQ824.4 PQ825.3 PQ827.3 PQ829.3 PQ830.3 PQ910.1 PQ910.4 PR15.1 PR20.2 PR22.2 PR25.2 PR102.1 PR104.1 PR105.2 PR106.2 PR111.1 PR207.1 PR302.1 PR305.2 PR307.1 PR404.2 PR405.2 PR507.1 PR509.1 PR512.1 PR513.2 PR521.2 PR525.1 PR529.1 PR541.2 PR542.1 PR554.2 PR558.2 PR601.1 PR603.1 PR605.1 PR609.1 PR610.1 PR612.1 PR615.1 PR658.1 PR682.2 PR684.2 PR689.2 PR690.2 PR693.2 PR721.1 PR729.1 PR731.2 PR738.2 PR739.2 PR740.2 PR806.2 PR814.1 PR817.2 PR844.2 PR858.2 PR874.2 PU1.2 PU100.21 PU200.1 PU200.3 PU200.14 PU200.21 PU300.11 PU400.11 PU500.33 PU501.4 PU501.9 PU600.22 PU600.27 PU602.11 PU603.11 PU700.14 PU701.4 PU702.4 PU703.1 PU703.2 PU704.3 PU800.5 PU800.14 PU800.23 PU800.32 PU800.37 PU801.3 PU802.3 PU803.3 PU804.3 PU805.3 PU806.3 PU807.3 PU808.15 PU808.29 PU809.3 Q5.3 Q6.3 Q22.3 Q29.1 Q29.4 Q45.3 Q47.3 Q48.3 Q52.1 Q52.4 Q59.3 Q70.3 Q71.3 Q72.3 Q78.3 Q85.3 Q88.3 Q123.1 QC1.3 QC3.3 QC4.1 QC4.4 QH3.3 QV2.3 QV3.3 QV6.3 QV7.3 QV11.3 R3.1 R5.2 R6.2 R15.2 R75.2 R76.2 R81.2 R82.2 R87.2 R88.2 R100.1 R101.1 R104.2 R106.1 R108.1 R111.2 R114.1 R152.1 R169.2 R407.2 R424.1 R491.1 R492.1 R493.2 R512.2 R517.1 R518.1 R557.2 R561.2 R562.2 R657.2 R677.1 R716.2 R726.2 R733.2 R748.2 R751.2 R757.2 R758.2 R767.1 R775.1 R786.1 R789.1 R790.1 R791.1 R793.2 R803.2 R804.2 R812.1 R826.2 R831.2 R836.2 R843.1 R869.1 R876.2 R878.1 R879.1 R880.1 R881.1 R882.1 R889.1 R892.1 R931.2 R938.2 R1069.2 R1137.2 R1138.2 R1139.2 R1141.2 R1142.2 R1154.1 R1583.1 R1611.2 R1636.1 R1640.2 R1680.2 R1681.2 R1682.2 R1683.2 R1684.2 R1685.2 R1686.2 R1687.2 R1688.2 R1689.2 R1701.2 R1702.2 R3682.2 R3683.2 R3684.2 R3685.2 R3686.2 R3687.2 R3688.2 R3699.2 R3700.2 R3701.2 R3702.2 R3714.2 R3715.2 R3716.2 R3717.2 R3718.2 R3719.2 R3720.2 R3729.2 R3730.2 R3731.2 R3732.2 R3734.2 R3736.2 R3740.2 R3741.2 R3742.2 R3743.2 R3745.2 R3748.2 R3749.2 R3751.2 R3755.2 R3757.2 R3759.2 R3760.2 R3761.2 R3764.2 R3765.2 R3766.2 R3773.2 R3775.2 R3776.2 R3779.2 RC16.2 RC56.2 RC58.2 RC59.1 RC61.2 RC62.1 RC63.2 RC67.2 RC68.2 RC75.2 RC76.2 RC77.2 RC78.2 RC79.2 RC80.2 RC81.2 RC82.2 RC83.2 RC84.2 RC89.2 RC94.2 RC100.2 RC108.2 RC109.2 RC110.2 RC143.2 RD6.1 RD7.1 RD11.2 RD16.2 RD18.2 RD21.2 RD24.2 RD27.2 RD28.2 RD30.2 RH18.2 RH47.2 RH53.1 RH54.2 RH55.2 RH56.2 RH70.2 RH76.2 RH81.1 RH97.1 RH115.1 RH116.1 RH117.1 RH118.1 RH119.2 RH120.1 RH136.2 RH138.2 RH141.2 RH143.2 RH146.2 RH176.2 RH187.2 RH215.2 RH223.2 RH226.2 RH227.2 RH230.2 RH231.2 RH248.2 RPH5.5 RPH5.6 RPH5.7 RPH5.8 RV4.2 RV5.2 RV7.2 RV9.2 RV11.2 RV13.2 RV15.2 RV17.2 RV20.2 RV22.2 RV24.2 RV25.1 RV34.1 RV35.1 RV36.1 RV42.2 RV43.2 RV44.2 RV45.2 RV46.2 RV48.1 RV49.2 RV60.1 RV61.1 RV62.2 RV63.2 RV65.2 RV66.2 RV69.2 RV80.2 RV82.1 RV88.1 RV104.1 RV107.1 RV108.1 RV110.2 RV111.1 RV113.1 RV117.1 RV118.1 RV120.2 RV128.2 RV131.2 RV146.2 RV147.2 RV152.2 RV154.2 RV162.1 RV163.1 RV169.1 RV171.1 RV180.1 RV181.2 RV184.2 RV186.2 RV192.2 RV194.2 RV196.2 RV198.2 RV205.2 RV238.2 RV240.2 RV242.2 RV243.2 SW1.1 SW1.3 U1.1 U2.9 U6.3 U6.11 U6.28 U6.31 U6.33 U7.6 U7.21 U8.2 U9.3 U15.3 U19.8 U19.15 U19.35 U19.41 U20.7 U21.3 U23.7 U24.3 U26.1 U26.2 U26.4 U26.7 U27.6 U27.49 U31.49 U32.43 U38.49 U39.1 U39.2 U39.3 U39.4 U39.8 U39.11 U39.18 U39.25 U41.7 U41.21 U46.B27 U46.C1 U48.1 U49.1 U50.3 U51.B11 U51.B18 U51.B54 U51.B60 U51.B66 U51.C1 U52.4 U53.4 U54.3 U55.3 U58.3 U74.7 U74.42 U74.49 U88.5 U88.10 U88.12 U88.13 U88.15 U88.16 U89.2 U90.10 U90.21 U90.25 U91.1 U92.10 U92.21 U92.25 U93.1 U94.10 U94.21 U94.25 U95.10 U95.21 U95.25 U100.11 U100.15 U101.11 U101.15 U102.11 U102.15 U103.11 U103.15 U104.11 U104.15 U105.11 U105.15 UC1.3 UC2.3 UC3.3 UH1.A2 UH1.A4 UH1.A5 UH1.A41 UH1.A43 UH1.A44 UH1.AA4 UH1.AA16 UH1.AA20 UH1.AA22 UH1.AA28 UH1.AB8 UH1.AB12 UH1.AB34 UH1.AB38 UH1.AC2 UH1.AC44 UH1.AD6 UH1.AD8 UH1.AD14 UH1.AD16 UH1.AD18 UH1.AD30 UH1.AD32 UH1.AD40 UH1.AE16 UH1.AE28 UH1.AF8 UH1.AF38 UH1.AG2 UH1.AG16 UH1.AG26 UH1.AG28 UH1.AG44 UH1.AJ6 UH1.AJ8 UH1.AJ16 UH1.AJ18 UH1.AJ20 UH1.AJ22 UH1.AJ24 UH1.AJ34 UH1.AJ38 UH1.AK14 UH1.AK16 UH1.AK24 UH1.AK43 UH1.AK45 UH1.AL2 UH1.AL8 UH1.AL12 UH1.AL34 UH1.AL38 UH1.AM14 UH1.AM16 UH1.AM24 UH1.AM26 UH1.AM28 UH1.AM30 UH1.AM32 UH1.AN8 UH1.AN36 UH1.AN40 UH1.AN42 UH1.AP13 UH1.AP24 UH1.AP31 UH1.AP43 UH1.AR2 UH1.AT10 UH1.AT15 UH1.AT17 UH1.AT20 UH1.AT26 UH1.AT29 UH1.AT36 UH1.AT38 UH1.AT43 UH1.AV6 UH1.AV7 UH1.AV13 UH1.AV22 UH1.AV24 UH1.AV31 UH1.AV33 UH1.AV40 UH1.AW2 UH1.AY7 UH1.AY10 UH1.AY15 UH1.AY20 UH1.AY26 UH1.AY29 UH1.AY36 UH1.B1 UH1.B2 UH1.B7 UH1.B11 UH1.B15 UH1.B19 UH1.B23 UH1.B27 UH1.B31 UH1.B35 UH1.B39 UH1.B44 UH1.B45 UH1.BA1 UH1.BA40 UH1.BB25 UH1.BB42 UH1.BC1 UH1.BC16 UH1.BC22 UH1.BC28 UH1.BD1 UH1.BD2 UH1.BD7 UH1.BD11 UH1.BD15 UH1.BD19 UH1.BD31 UH1.BD35 UH1.BD39 UH1.BD44 UH1.BD45 UH1.BE2 UH1.BE3 UH1.BE5 UH1.BE41 UH1.C45 UH1.D1 UH1.D4 UH1.D25 UH1.D42 UH1.E1 UH1.E45 UH1.F15 UH1.F20 UH1.F29 UH1.F33 UH1.F43 UH1.G2 UH1.G8 UH1.G38 UH1.G44 UH1.H7 UH1.H10 UH1.H13 UH1.H17 UH1.H22 UH1.H24 UH1.H26 UH1.H31 UH1.H36 UH1.H40 UH1.K10 UH1.K15 UH1.K20 UH1.K29 UH1.K33 UH1.K39 UH1.L2 UH1.L44 UH1.M17 UH1.M22 UH1.M24 UH1.N6 UH1.N10 UH1.N12 UH1.N35 UH1.N39 UH1.P22 UH1.P24 UH1.P26 UH1.P28 UH1.P30 UH1.P32 UH1.P43 UH1.R2 UH1.R8 UH1.R12 UH1.R14 UH1.R16 UH1.R34 UH1.R38 UH1.R44 UH1.T43 UH1.U6 UH1.U10 UH1.U16 UH1.U28 UH1.U34 UH1.U38 UH1.U39 UH1.U42 UH1.V14 UH1.V16 UH1.V26 UH1.V43 UH1.W2 UH1.W44 UH1.Y8 UH1.Y14 UH1.Y16 UH1.Y24 UH1.Y28 UH1.Y34 UH1.Y36 UH1.Y40 UH2.3 UH3.3 UV1.A3 UV1.A37 UV1.AA2 UV1.AA6 UV1.AA16 UV1.AA18 UV1.AA21 UV1.AA23 UV1.AA26 UV1.AA28 UV1.AB12 UV1.AB15 UV1.AB17 UV1.AB20 UV1.AB22 UV1.AB24 UV1.AB27 UV1.AB39 UV1.AC2 UV1.AC6 UV1.AC11 UV1.AC13 UV1.AC16 UV1.AC18 UV1.AC21 UV1.AC23 UV1.AC26 UV1.AC28 UV1.AC34 UV1.AD9 UV1.AD15 UV1.AD17 UV1.AD20 UV1.AD22 UV1.AD24 UV1.AD27 UV1.AD35 UV1.AD37 UV1.AE2 UV1.AE6 UV1.AE34 UV1.AE38 UV1.AF10 UV1.AF16 UV1.AF18 UV1.AF21 UV1.AF39 UV1.AG2 UV1.AG6 UV1.AG9 UV1.AG17 UV1.AG20 UV1.AH21 UV1.AH39 UV1.AJ2 UV1.AJ6 UV1.AJ10 UV1.AJ11 UV1.AJ28 UV1.AJ33 UV1.AK7 UV1.AK11 UV1.AK31 UV1.AK39 UV1.AL2 UV1.AL6 UV1.AL8 UV1.AL11 UV1.AL14 UV1.AL17 UV1.AL20 UV1.AL23 UV1.AL26 UV1.AL32 UV1.AL34 UV1.AM9 UV1.AM11 UV1.AM31 UV1.AM35 UV1.AN2 UV1.AN6 UV1.AN8 UV1.AN10 UV1.AN11 UV1.AN17 UV1.AN19 UV1.AN27 UV1.AN29 UV1.AN30 UV1.AN32 UV1.AN34 UV1.AN38 UV1.AP7 UV1.AP9 UV1.AP11 UV1.AP16 UV1.AP17 UV1.AP18 UV1.AP19 UV1.AP27 UV1.AP28 UV1.AP29 UV1.AP30 UV1.AP39 UV1.AR5 UV1.AR18 UV1.AR28 UV1.AR39 UV1.AU37 UV1.AV17 UV1.AV27 UV1.AW14 UV1.AW16 UV1.AW20 UV1.AW22 UV1.AW24 UV1.AW26 UV1.AW30 UV1.AW32 UV1.B7 UV1.B9 UV1.B11 UV1.B13 UV1.B15 UV1.B17 UV1.B19 UV1.B21 UV1.B23 UV1.B25 UV1.B27 UV1.B29 UV1.B31 UV1.B33 UV1.C1 UV1.C39 UV1.E5 UV1.E35 UV1.E39 UV1.F7 UV1.F9 UV1.F11 UV1.F13 UV1.F15 UV1.F17 UV1.F19 UV1.F21 UV1.F23 UV1.F25 UV1.F27 UV1.F29 UV1.F31 UV1.F33 UV1.F34 UV1.F39 UV1.G2 UV1.G6 UV1.G33 UV1.G34 UV1.H9 UV1.H31 UV1.H34 UV1.H39 UV1.J2 UV1.J6 UV1.J8 UV1.J27 UV1.J31 UV1.J34 UV1.K7 UV1.K14 UV1.K31 UV1.K34 UV1.K39 UV1.L2 UV1.L6 UV1.L11 UV1.L17 UV1.L22 UV1.L24 UV1.L31 UV1.L34 UV1.M17 UV1.M22 UV1.M24 UV1.M34 UV1.M39 UV1.N2 UV1.N6 UV1.N16 UV1.N18 UV1.N21 UV1.N23 UV1.N26 UV1.N31 UV1.N34 UV1.P31 UV1.P34 UV1.P39 UV1.R2 UV1.R6 UV1.R15 UV1.R17 UV1.R20 UV1.R22 UV1.R24 UV1.R27 UV1.R34 UV1.T11 UV1.T13 UV1.T16 UV1.T18 UV1.T21 UV1.T23 UV1.T26 UV1.T31 UV1.T34 UV1.T39 UV1.U2 UV1.U6 UV1.U15 UV1.U17 UV1.U20 UV1.U22 UV1.U24 UV1.U27 UV1.U31 UV1.U34 UV1.V11 UV1.V16 UV1.V18 UV1.V21 UV1.V23 UV1.V26 UV1.V34 UV1.V39 UV1.W2 UV1.W6 UV1.W31 UV1.W34 UV1.Y15 UV1.Y17 UV1.Y20 UV1.Y22 UV1.Y24 UV1.Y27 UV1.Y34 UV1.Y39 UV3.A1 UV3.A3 UV3.A12 UV3.A14 UV3.B5 UV3.B10 UV3.C1 UV3.C3 UV3.C4 UV3.C11 UV3.C12 UV3.C13 UV3.C14 UV3.D10 UV3.E1 UV3.E3 UV3.E12 UV3.E14 UV3.F5 UV3.F10 UV3.G5 UV3.G10 UV3.H1 UV3.H2 UV3.H13 UV3.H14 UV3.J10 UV3.K1 UV3.K2 UV3.K13 UV3.K14 UV3.L5 UV3.L10 UV3.M5 UV3.M10 UV3.N1 UV3.N3 UV3.N12 UV3.N14 UV3.P10 UV3.R1 UV3.R3 UV3.R4 UV3.R11 UV3.R12 UV3.R14 UV3.T5 UV3.T10 UV3.U1 UV3.U3 UV3.U12 UV3.U14 UV4.A1 UV4.A3 UV4.A12 UV4.A14 UV4.B5 UV4.B10 UV4.C1 UV4.C3 UV4.C4 UV4.C11 UV4.C12 UV4.C13 UV4.C14 UV4.D10 UV4.E1 UV4.E3 UV4.E12 UV4.E14 UV4.F5 UV4.F10 UV4.G5 UV4.G10 UV4.H1 UV4.H2 UV4.H13 UV4.H14 UV4.J1 UV4.J10 UV4.K1 UV4.K2 UV4.K13 UV4.K14 UV4.L5 UV4.L10 UV4.M5 UV4.M10 UV4.N1 UV4.N3 UV4.N12 UV4.N14 UV4.P10 UV4.R1 UV4.R3 UV4.R4 UV4.R11 UV4.R12 UV4.R14 UV4.T5 UV4.T10 UV4.U1 UV4.U3 UV4.U12 UV4.U14 UV5.A1 UV5.A3 UV5.A12 UV5.A14 UV5.B5 UV5.B10 UV5.C1 UV5.C3 UV5.C4 UV5.C11 UV5.C12 UV5.C13 UV5.C14 UV5.D10 UV5.E1 UV5.E3 UV5.E12 UV5.E14 UV5.F5 UV5.F10 UV5.G5 UV5.G10 UV5.H1 UV5.H2 UV5.H13 UV5.H14 UV5.J10 UV5.K1 UV5.K2 UV5.K13 UV5.K14 UV5.L5 UV5.L10 UV5.M5 UV5.M10 UV5.N1 UV5.N3 UV5.N12 UV5.N14 UV5.P10 UV5.R1 UV5.R3 UV5.R4 UV5.R11 UV5.R12 UV5.R14 UV5.T5 UV5.T10 UV5.U1 UV5.U3 UV5.U12 UV5.U14 UV6.A1 UV6.A3 UV6.A12 UV6.A14 UV6.B5 UV6.B10 UV6.C1 UV6.C3 UV6.C4 UV6.C11 UV6.C12 UV6.C13 UV6.C14 UV6.D10 UV6.E1 UV6.E3 UV6.E12 UV6.E14 UV6.F5 UV6.F10 UV6.G5 UV6.G10 UV6.H1 UV6.H2 UV6.H13 UV6.H14 UV6.J1 UV6.J10 UV6.K1 UV6.K2 UV6.K13 UV6.K14 UV6.L5 UV6.L10 UV6.M5 UV6.M10 UV6.N1 UV6.N3 UV6.N12 UV6.N14 UV6.P10 UV6.R1 UV6.R3 UV6.R4 UV6.R11 UV6.R12 UV6.R14 UV6.T5 UV6.T10 UV6.U1 UV6.U3 UV6.U12 UV6.U14 UV7.A1 UV7.A3 UV7.A12 UV7.A14 UV7.B5 UV7.B10 UV7.C1 UV7.C3 UV7.C4 UV7.C11 UV7.C12 UV7.C13 UV7.C14 UV7.D10 UV7.E1 UV7.E3 UV7.E12 UV7.E14 UV7.F5 UV7.F10 UV7.G5 UV7.G10 UV7.H1 UV7.H2 UV7.H13 UV7.H14 UV7.J10 UV7.K1 UV7.K2 UV7.K13 UV7.K14 UV7.L5 UV7.L10 UV7.M5 UV7.M10 UV7.N1 UV7.N3 UV7.N12 UV7.N14 UV7.P10 UV7.R1 UV7.R3 UV7.R4 UV7.R11 UV7.R12 UV7.R14 UV7.T5 UV7.T10 UV7.U1 UV7.U3 UV7.U12 UV7.U14 UV8.A1 UV8.A3 UV8.A12 UV8.A14 UV8.B5 UV8.B10 UV8.C1 UV8.C3 UV8.C4 UV8.C11 UV8.C12 UV8.C13 UV8.C14 UV8.D10 UV8.E1 UV8.E3 UV8.E12 UV8.E14 UV8.F5 UV8.F10 UV8.G5 UV8.G10 UV8.H1 UV8.H2 UV8.H13 UV8.H14 UV8.J1 UV8.J10 UV8.K1 UV8.K2 UV8.K13 UV8.K14 UV8.L5 UV8.L10 UV8.M5 UV8.M10 UV8.N1 UV8.N3 UV8.N12 UV8.N14 UV8.P10 UV8.R1 UV8.R3 UV8.R4 UV8.R11 UV8.R12 UV8.R14 UV8.T5 UV8.T10 UV8.U1 UV8.U3 UV8.U12 UV8.U14 UV9.A1 UV9.A3 UV9.A12 UV9.A14 UV9.B5 UV9.B10 UV9.C1 UV9.C3 UV9.C4 UV9.C11 UV9.C12 UV9.C13 UV9.C14 UV9.D10 UV9.E1 UV9.E3 UV9.E12 UV9.E14 UV9.F5 UV9.F10 UV9.G5 UV9.G10 UV9.H1 UV9.H2 UV9.H13 UV9.H14 UV9.J10 UV9.K1 UV9.K2 UV9.K13 UV9.K14 UV9.L5 UV9.L10 UV9.M5 UV9.M10 UV9.N1 UV9.N3 UV9.N12 UV9.N14 UV9.P10 UV9.R1 UV9.R3 UV9.R4 UV9.R11 UV9.R12 UV9.R14 UV9.T5 UV9.T10 UV9.U1 UV9.U3 UV9.U12 UV9.U14 UV10.A1 UV10.A3 UV10.A12 UV10.A14 UV10.B5 UV10.B10 UV10.C1 UV10.C3 UV10.C4 UV10.C11 UV10.C12 UV10.C13 UV10.C14 UV10.D10 UV10.E1 UV10.E3 UV10.E12 UV10.E14 UV10.F5 UV10.F10 UV10.G5 UV10.G10 UV10.H1 UV10.H2 UV10.H13 UV10.H14 UV10.J1 UV10.J10 UV10.K1 UV10.K2 UV10.K13 UV10.K14 UV10.L5 UV10.L10 UV10.M5 UV10.M10 UV10.N1 UV10.N3 UV10.N12 UV10.N14 UV10.P10 UV10.R1 UV10.R3 UV10.R4 UV10.R11 UV10.R12 UV10.R14 UV10.T5 UV10.T10 UV10.U1 UV10.U3 UV10.U12 UV10.U14 UV14.3 Y3.2 Y3.4 YH2.2 YH2.4 YV1.2 YV1.4
GND_CHASSIS: C485.2 R571.2 R572.2 R573.2 R574.2
GNDA: C955.2 C956.2 C957.2 C963.2 C965.1 C968.2 C969.2 C970.2 C972.2 C1107.2 C1211.2 C1212.2 C1213.2 C1214.2 C1215.2 C1247.2 D81.1 D82.1 D83.1 JHP1.7 PJP62.1 Q106.1 Q106.4 Q324.3 Q327.1 Q327.4 R5.1 R6.1 R15.1 R1088.2 R1642.2 R1676.2 U74.26 U74.36
GNDA_CHG: PC703.1 PC705.2 PC708.2 PC716.1 PC721.1 PC723.2 PJP701.1 PR714.2 PR743.2 PU700.21
GNDA_GPU_CORE: PC600.1 PC617.2 PC618.2 PC624.2 PC630.1 PC632.2 PJP602.1 PR616.1 PR632.2 PR634.2 PR637.2 PR644.2 PU600.41
V1N: PL503.2 PR516.1 PR546.2 PR556.1
V1N_VGA: PL601.2 PR626.2 PR654.1
V1P_VGA: PL601.3 PR651.1 PR652.1
V2N: PL502.2 PR518.1 PR544.1 PR555.2
V2N_VGA: PL600.2 PR624.1 PR656.2
V2P_VGA: PL600.3 PR619.1 PR623.1
V3N: PL501.2 PR515.2 PR547.2 PR557.2
VCC_PGOOD: PR522.2 PU500.3
VCCPWRGOOD_0_R: JCPU1.AL34 RC33.2 RC56.1
VCCSENSE: PC541.2 PC545.1 PR531.1 PR540.2 RC91.2 RC92.2
VCCSENSE_R: JCPU1.AL35 RC92.1
VDD_1.35V: PC210.1 PR201.1 PR203.2 PU200.11
VDDCI_VID: RV64.1
VSSSENSE: PC545.2 PC546.2 PU500.13 RC93.2 RC94.1
VSSSENSE_R: JCPU1.AK35 RC93.1
3301_ACAV_IN_NB: PR855.1 PU800.24
3301_DSCHRG_FET_GC: PR892.2 PR893.1
3301_PWRSRC: PR877.1 PU800.15
+BATT_SUM: PD800.2 PD800.3 PD801.1 PD806.1 PQ800.5 PQ800.6 PQ800.7 PQ800.8 PQ803.1 PQ803.2 PQ803.3 PQ809.1 PQ809.2 PQ809.3 PQ815.5 PQ815.6 PQ815.7 PQ815.8 PR803.2 PR813.2
+BL_PWR_SRC: C246.1 C247.1 C296.1 JLVDS1.5 JLVDS1.6 JLVDS1.7 Q21.1 Q21.2 Q21.5 Q21.6
+CAMERA_VDD: C299.1 C300.1 JCAM1.4 Q23.1
+CAP_LDO: C714.1 U46.B46
+CHGR_DC_IN: PR708.1 PR833.1
+COINCELL: JRTC1.1 PR1.1
+DC1_PWR_SRC: PC103.1 PC104.1 PC105.1 PC106.1 PC107.1 PC108.1 PC109.1 PC110.1 PC117.1 PJP104.2 PL103.2 PQ101.5 PQ102.5 PU100.12
+DC_IN: PC8.2 PC14.1 PL5.2 PQ4.1 PQ4.2 PQ4.3 PQ6.3 PR18.1 PR22.1 PR732.1 PR835.1
+DC_IN_SS: PC9.1 PC10.1 PC11.1 PC13.1 PD700.2 PD701.3 PQ4.5 PQ4.6 PQ4.7 PQ4.8 PQ700.5 PQ700.6 PQ700.7 PQ700.8 PQ822.3 PR20.1 PR831.1 PR840.2
+DCIN: PC707.1 PR742.2 PU700.20
+DCIN_JACK: PC12.1 PJPDC1.1 PJPDC1.2 PL5.1
+DDR_CHG: Q72.1 R927.2
+DIMM1_VREF_CA: CD15.1 CD16.1 JDIMM1.126 RD5.2 RD13.2
+DIMM1_VREF_DQ: CD1.1 CD2.1 JDIMM1.1 RD1.2 RD3.2
+DIMM2_VREF_CA: CD37.1 CD38.1 JDIMM2.126 RD10.2 RD23.2
+DIMM2_VREF_DQ: CD23.1 CD24.1 JDIMM2.1 RD8.2 RD9.2
+DOCK_PWR_BAR: C702.1 C703.1 CE6.1 D33.2 D33.3 JDOCK1.146 JDOCK1.147 JDOCK1.148 JDOCK1.149 JDOCK1.150 JDOCK1.151 PD701.2 PD808.2 PD808.3 PQ810.5 PQ810.6 PQ810.7 PQ810.8 PQ826.5 PQ826.6 PQ826.7 PQ826.8 PR814.2 PR832.1
+GPU_CORE: PC927.1 PC928.1 PC929.1 PC930.1 PC931.1 PC932.1 PC933.1 PC934.1 PC944.1 PC945.1 PC946.1 PC947.1 PC948.1 PC949.1 PC950.1 PC951.1 PC952.1 PC953.1 PC954.1 PC955.1 PC956.1 PC957.1 PC958.1 PC959.1 PC960.1 PC961.1 PC962.1 PC963.1 PC964.1 PC965.1 PC966.1 PC967.1 PC968.1 PC969.1 PC970.1 PC971.1 PCV172.1 PCV174.1 PCV175.1 PCV183.1 PJP601.2 PJP603.2 PJP604.2 UV1.AA13 UV1.AA15 UV1.AA17 UV1.AA20 UV1.AA22 UV1.AA24 UV1.AA27 UV1.AB13 UV1.AB16 UV1.AB18 UV1.AB21 UV1.AB23 UV1.AB26 UV1.AB28 UV1.AC12 UV1.AC15 UV1.AC17 UV1.AC20 UV1.AC22 UV1.AC24 UV1.AC27 UV1.AD13 UV1.AD16 UV1.AD18 UV1.AD21 UV1.AD23 UV1.AD26 UV1.AF17 UV1.AF20 UV1.AF22 UV1.AG16 UV1.AG18 UV1.AH22 UV1.AH27 UV1.AH28 UV1.M15 UV1.M16 UV1.M18 UV1.M23 UV1.M26 UV1.N13 UV1.N15 UV1.N17 UV1.N20 UV1.N22 UV1.N24 UV1.R12 UV1.R13 UV1.R16 UV1.R18 UV1.R21 UV1.R23 UV1.R26 UV1.T12 UV1.T15 UV1.T17 UV1.T20 UV1.T22 UV1.T24 UV1.U16 UV1.U18 UV1.U21 UV1.U23 UV1.U26 UV1.V15 UV1.V17 UV1.V20 UV1.V22 UV1.V24 UV1.V27 UV1.Y13 UV1.Y16 UV1.Y18 UV1.Y21 UV1.Y23 UV1.Y26 UV1.Y28
+LCDVDD: C298.1 C762.1 JLVDS1.38 JLVDS1.39 U104.13 U104.14
+LOM_VCT: C701.1 JDOCK1.116 JDOCK1.118
+MBATT: PJP1.1 PL1.2 PQ804.1 PQ804.2 PQ804.3 PR842.1
+MBATT_C: MBATT1.1 PC1.1 PC2.1 PJP1.2 PL1.1
+MBATT_C2: PR842.2 PU808.3
+MIC1_VREF_OUT: D11.2 D12.2 U74.30
+MPBATT_IN_SS: PD801.2 PD801.3 PD802.2 PD809.2 PQ803.5 PQ803.6 PQ803.7 PQ803.8 PQ804.5 PQ804.6 PQ804.7 PQ804.8 PR806.1
+NBDOCK_DC_IN_SS: JDOCK1.41 PQ801.1 PQ814.3 PQ823.1 PR827.2
+PBATT: PL2.2 PL3.2 PQ811.1 PQ811.2 PQ811.3 PQ820.3 PR837.1 PR838.1 PR896.1
+PBATT_C: PBATT1.8 PBATT1.9 PC4.1 PC5.1 PL2.1 PL3.1
+PBATT_C2: PR837.2 PU808.2
+PBATT_IN_SS: PD805.2 PD806.2 PD806.3 PD807.2 PQ809.5 PQ809.6 PQ809.7 PQ809.8 PQ811.5 PQ811.6 PQ811.7 PQ811.8 PR817.1
+PCH_DCPRTC: CH54.1 UH1.P14 UH1.P16
+PCH_USB_DCPSUS1: CH39.1 RH234.2 UH1.Y12
+PCH_USB_DCPSUS2: CH58.1 RH239.2 UH1.Y35
+PCH_USB_DCPSUS3: CH41.1 CH42.1 RH236.1 UH1.AJ26 UH1.AJ28
+PCH_VCC: CH63.1 CH64.1 RH241.2 UH1.AP45
+PCH_VCCCFUSE: CH66.1 RH242.2 RH243.2 UH1.P18 UH1.P20
+PCH_VCCCLK: CH67.1 CH68.1 CH69.1 CH70.1 CH71.1 RH244.2 UH1.AA30 UH1.AA32 UH1.AD34 UH1.AD35 UH1.AD36 UH1.AE30 UH1.AE32 UH1.AG30 UH1.AG32 UH1.Y32
+PCH_VCCCLK3_3: CH72.1 CH73.1 CH74.1 CH75.1 RH245.2 UH1.L26 UH1.L29 UH1.M26 UH1.M29 UH1.U32 UH1.V32
+PCH_VCCDSW: RH232.2 UH1.U14
+PCH_VCCDSW3_3: CC19.1 CH44.1 JAPS1.3 R566.2 R835.1 RC5.1 RH80.1 RH92.1 RH112.1 RH216.2 RH217.2 RH237.2 RH238.2 UC1.5 UH1.A16
+PCH_VCCDSW_R: CH40.1 RH232.1
+PCH_VCCSST: CH46.1 UH1.AA14
+PECI_VREF: C740.1 R866.1 U51.B51
+PWR_SRC: C297.1 PC6.1 PC731.1 PC732.1 PC736.1 PC737.1 PC738.1 PJP7.2 PJP104.1 PJP200.2 PJP300.1 PJP500.1 PJP600.1 PL103.1 PL504.2 PL700.1 PQ3.3 PR17.1 PR716.4 Q21.4 R422.1
+PWR_SRC_AC: PC734.1 PC735.1 PC803.1 PC806.1 PC807.1 PD808.1 PJP700.1 PL701.2 PQ810.1 PQ810.2 PQ810.3 PR701.1 PR877.2
+PWR_SRC_S: PC7.1 PJP7.1 PQ3.1 R930.1 RC95.1 RV67.1
+RSVD_VCC3P3_1: R553.2 U31.1
+RTC_CELL: CH55.1 CH56.1 CH57.1 PC3.1 PD3.1 R810.1 R819.1 R830.1 R870.1 R1084.1 R1156.1 RH5.1 RH42.1 RH43.1 RH44.1 RH67.2 UH1.A6
+RTC_CELL_VBAT: C724.1 R830.2 U51.B64
+SA_DIMM1_VREFDQ: RD1.1 RD17.2 RD18.1 RD19.2
+SA_DIMM_VREFDQ: JCPU1.F16 QD6.1 RD26.2 RD27.1
+SA_DIMM_VREFDQ_Q: CD47.1 QD6.6 RD17.1 RD26.1
+SB_DIMM2_VREFDQ: RD8.1 RD14.2 RD15.2 RD16.1
+SB_DIMM_VREFDQ: JCPU1.F13 QD6.4 RD30.1 RD31.2
+SB_DIMM_VREFDQ_Q: CD46.1 QD6.3 RD14.1 RD31.1
+SDC_IN: PC700.1 PC720.1 PD700.1 PQ700.1 PQ700.2 PQ700.3 PR701.4 PR713.2 PR854.1 PU700.3 PU703.3
+SIM_PWR: C616.1 C636.1 C639.1 JMINI1.8 JSIM1.1
+SM_VREF: JCPU1.AM3 QD7.3 RD28.1 RD29.2
+SM_VREF_DIMM: RD13.1 RD20.2 RD21.1 RD22.2 RD23.1
+SM_VREF_Q: CD48.1 QD7.1 RD20.1 RD29.1
+SW_LX: R3883.2 U27.17
+SWR_V12: C109.1 C110.1 C111.1 C112.1 R3883.1 U27.11 U27.15 U27.43
+TRM_CT1: C479.1 T156.3
+TRM_CT2: C480.1 T156.4
+TRM_CT3: C483.1 T156.9
+TRM_CT4: C484.1 T156.10
+TSVDD: CV92.1 CV93.1 CV98.1 LV16.2 UV1.AJ32
+UIM_VPP: C628.1 JMINI1.16 JSIM1.6
+UTLGND: R104.1 U27.16
+V_DDR_REF: PC209.1 PU200.4 RD3.1 RD5.1 RD9.1 RD10.1
+VCHGR: PC717.1 PC718.1 PC719.1 PD800.1 PQ800.1 PQ800.2 PQ800.3 PR716.1 PR834.1
+VCHGR_C2: PR834.2 PU808.1
+VCOMP_OUT: JCPU1.F22 RC1.1 RC73.1
+VDISPLAY_VCC: C46.1 C47.1 JHDMI1.18 U89.3
+VGA_B+: PC601.1 PC602.1 PC603.1 PC604.1 PC619.1 PC620.1 PC621.1 PC622.1 PJP600.2 PQ600.5 PQ601.5 PQ604.5 PQ605.5 PR643.2
+VGA_COREP: PC606.1 PC628.1 PC629.1 PC677.1 PJP601.1 PJP603.1 PJP604.1 PL600.1 PL601.1 PR646.1
+VGA_PCIE: CV66.1 CV67.1 CV68.1 CV69.1 CV70.1 CV71.1 CV72.1 CV73.1 CV74.1 CV113.1 CV114.1 CV212.1 CV213.1 CV214.1 LV21.2 PJP610.1 RV296.2 RV298.2 UV1.AK33 UV1.AK34 UV1.AL33 UV1.AM33 UV1.AN31 UV1.AN33 UV1.AP31 UV1.AP32 UV1.AP33 UV1.G30 UV1.G31 UV1.H29 UV1.H30 UV1.J29 UV1.J30 UV1.L28 UV1.M28 UV1.N27 UV1.N28 UV1.R28 UV1.T27 UV1.T28 UV1.U28
+VGA_PCIE_SPLL_VDDC: CV223.1 CV224.1 CV225.1 LV21.1 UV1.AN9
+VGA_PCIEP: PC661.1 PC662.1 PC663.1 PC664.1 PC668.1 PJP610.2 PL603.2 PR683.1
+VR_CAP: C779.1 U51.B12
+VREFOUT: R1145.2 R1146.2 U74.23
-DCIN_JACK: PC16.1 PJP4.1 PJPDC1.3 PJPDC1.4
A_DE_0A: R3694.2 R3701.1 U90.16
A_DE_0B: R3725.2 R3731.1 U92.16
A_DE_0C: R3739.2 R3740.1 U94.16
A_DE_0D: R3779.1 R3780.2 U95.16
A_DE_1A: R3695.2 R3702.1 U90.18
A_DE_1B: R3726.2 R3732.1 U92.18
A_DE_1C: R3743.1 R3747.2 U94.18
A_DE_1D: R3768.2 R3776.1 U95.18
A_EQ_0A: R3692.2 R3699.1 U90.17
A_EQ_0B: R3723.2 R3729.1 U92.17
A_EQ_0C: R3736.1 R3752.2 U94.17
A_EQ_0D: R3773.1 R3774.2 U95.17
A_EQ_1A: R3693.2 R3700.1 U90.15
A_EQ_1B: R3724.2 R3730.1 U92.15
A_EQ_1C: R3733.2 R3745.1 U94.15
A_EQ_1D: R3759.1 R3762.2 U95.15
A_ON: PR308.1 R424.2 R1616.1 U51.B24
AC_DIS: PQ6.5 PR828.2 U46.B12
AC_PRESENT: R835.2 U51.A54 UH1.E6
ACAV_DOCK_SRC#: JDOCK1.42 PR846.2 PR847.1
ACAV_IN: PQ710.2 PR717.1 PR741.2 PR743.1 PR859.1 PR872.1 U51.A64
ACAV_IN#: PQ819.5 PQ825.1 PR820.2 PR864.2 PU808.8
ACAV_IN_NB: PR737.2 PR855.2 U51.B20
ACAVDK_SRC: PR847.2 PU800.4
ACAVIN: PR859.2 PU800.8
ADBIA0: UV1.J21 UV4.J4 UV5.J4
ADBIA1: UV1.G19 UV3.J4 UV6.J4
ADBIB0: UV1.T7 UV7.J4 UV8.J4
ADBIB1: UV1.W7 UV9.J4 UV10.J4
ALERT#: PR503.1 PR506.2 PU500.32
ALW_PWRGD_3V_5V: PR118.1 U51.A1
ALWON: PR110.1 U51.A60
AND_PWRGD: R840.2 U46.A4 U50.4
AUD_HP_NB_SENSE: C972.1 C1247.1 D83.3 JHP1.6 Q324.2 R1088.1 U46.A41
AUD_HP_OUT_L: R1677.2 U74.33
AUD_HP_OUT_L1: R56.1 R198.2 R209.1 R1677.1
AUD_HP_OUT_L2: C1213.1 D81.3 JHP1.1 R56.2
AUD_HP_OUT_R: R1679.2 U74.32
AUD_HP_OUT_R1: R57.1 R199.2 R210.1 R1679.1
AUD_HP_OUT_R2: C1212.1 D82.2 JHP1.2 R57.2
AUD_NB_MUTE#: C967.1 R40.1 R1099.2 U46.A39 U74.47
AUD_PC_BEEP: C1105.2 C1106.2 U74.12
AUD_SENSE_A: R1086.1 U74.13
AUD_SENSE_B: R1079.1 R1080.1 U74.14
AUDIO_BACKLITE#: Q80.2 Q82.2 Q86.2 R940.2 U46.B68
AUX_EN_WOWL: R1631.1 U46.B67
B_DE_0A: R3676.2 R3684.1 U90.3
B_DE_0B: R3706.2 R3716.1 U92.3
B_DE_0C: R3737.2 R3748.1 U94.3
B_DE_0D: R3764.1 R3767.2 U95.3
B_DE_1A: R3677.2 R3685.1 U90.6
B_DE_1B: R3707.2 R3717.1 U92.6
B_DE_1C: R3738.2 R3741.1 U94.6
B_DE_1D: R3760.1 R3777.2 U95.6
B_EQ_0A: R3674.2 R3682.1 U90.2
B_EQ_0B: R3704.2 R3714.1 U92.2
B_EQ_0C: R3734.1 R3735.2 U94.2
B_EQ_0D: R3758.2 R3765.1 U95.2
B_EQ_1A: R3675.2 R3683.1 U90.4
B_EQ_1B: R3705.2 R3715.1 U92.4
B_EQ_1C: R3750.2 R3751.1 U94.4
B_EQ_1D: R3766.1 R3772.2 U95.4
BAT1_LED#: Q83.1 R953.1 U46.B64
BAT1_LED#_Q: Q83.6 R951.1
BAT2_LED#: Q83.4 R958.1 U46.A9
BAT2_LED#_Q: Q83.3 R949.1
BATDRV#: PQ800.4 PR722.2
BATT_WHITE#: JLED2.3 R949.2
BATT_WHITE_LED#: JLVDS1.2 R958.2
BATT_YELLOW#: JLED2.2 R951.2
BATT_YELLOW_LED#: JLVDS1.3 R953.2
BAY_SMBCLK: JSATA2.30 PR4.2 R856.2 U51.A7
BAY_SMBDAT: JSATA2.29 PR3.2 R854.2 U51.B7
BBS_BIT0_R: QH2.1 RH13.1 RH37.2 UH1.AU2
BBS_BIT1: RH119.1 UH1.C10
BC_CLK_ECE1117: JKB1.9 U51.A20
BC_CLK_ECE5048: U46.A30 U51.A43
BC_DAT_ECE1117: JKB1.7 R817.2 U51.B21
BC_DAT_ECE5048: R814.2 U46.B31 U51.B45
BC_INT#_ECE1117: JKB1.6 U51.A19
BC_INT#_ECE5048: U46.A29 U51.A42
BCM5882_ALERT#: JUSH1.14 U46.B62
BEEP: R1120.2 U51.B19
BIA_PWM_CVT: D66.2 U27.19
BIA_PWM_EC: D68.2 U51.B25
BIA_PWM_LVDS: D66.1 D68.1 R1137.1 RE32.2
BIA_PWM_PCH: R109.1 UH1.N36
BIA_PWM_PCH_R: R109.2 R114.2 U27.21
BITCLK_TERM: C677.1 R753.1
BLUE_CRT: JBTB1.15 U6.22
BLUE_DOCK: JDOCK1.45 U6.21
BOARD_ID: C744.1 R875.2 U51.B10
BOOT1: PR550.2 PU500.18
BOOT1_1_VGA: PC623.1 PR649.1
BOOT1_VGA: PR649.2 PU600.19
BOOT2: PR534.2 PU500.27
BOOT2_2_VGA: PC605.1 PR614.1
BOOT2_VGA: PR614.2 PU600.30
BOOT3: PR502.2 PU501.2
BOOT_1.35V: PR200.2 PU200.18
BQ24715_REGN: PC706.1 PD702.2 PR735.1 PR741.1 PR746.1 PU700.16
BREATH_LED#: JDOCK1.98 Q84.1 R955.1 U46.B39
BREATH_LED#_Q: LED1.1 Q84.6
BREATH_WHITE_LED#: JLVDS1.4 R955.2
BREATH_WHITE_LED_SNIFF: LED1.2 R957.1
BST_3V: PR108.2 PU100.9
BST_5V: PR107.1 PU100.17
BST_+1.05VSP: PR301.1 PU300.10
BT_LED#: JMINI2.46 Q89.3 R720.1
BT_RADIO_DIS#: D36.1 R695.1 U46.A13
BT_RADIO_DIS#_R: D36.2 JMINI2.51 R695.2 R729.1
CAM_MIC_CBL_DET#: JCAM1.1 RPH6.2 UH1.L15
CARD_RESET#: CE12.1 JEXP1.18 U41.8
CARD_SMBCLK: JEXP1.6 R732.2 U51.A49
CARD_SMBDAT: JEXP1.8 R731.2 U51.B52
CASA0#: UV1.K20 UV4.L3 UV5.G3
CASA1#: UV1.K17 UV3.G3 UV6.L3
CASB0#: UV1.W10 UV7.G3 UV8.L3
CASB1#: UV1.AA10 UV9.G3 UV10.L3
CCD_OFF: Q23.2 U46.B43
CD3301_DCIN: PC813.1 PR835.2 PU800.1
CD3301_SDC_IN: PR854.2 PU800.6
CD_PBATT_OFF: PR843.1 PU800.27
CFD_PWRBTN#_XDP: JXDP1.41 RC21.2
CFG0: JCPU1.AT20 JXDP1.9
CFG1: JCPU1.AR20 JXDP1.11
CFG2: JCPU1.AP20 JXDP1.15 RC76.1
CFG3: JCPU1.AP22 JXDP1.17 RC8.2 RC100.1
CFG3_R: JXDP1.60 RC8.1
CFG4: JCPU1.AT22 JXDP1.27 RC77.1
CFG5: JCPU1.AN22 JXDP1.29 RC78.1
CFG6: JCPU1.AT25 JXDP1.33 RC79.1
CFG7: JCPU1.AN23 JXDP1.35 RC83.1
CFG8: JCPU1.AR24 JXDP1.10
CFG9: JCPU1.AT23 JXDP1.12
CFG10: JCPU1.AN20 JXDP1.16
CFG11: JCPU1.AP24 JXDP1.18
CFG12: JCPU1.AP26 JXDP1.28
CFG13: JCPU1.AN25 JXDP1.30
CFG14: JCPU1.AN26 JXDP1.34
CFG15: JCPU1.AP25 JXDP1.36
CFG16: JCPU1.AR21 JXDP1.6
CFG17: JCPU1.AP21 JXDP1.4
CFG18: JCPU1.AR23 JXDP1.24
CFG19: JCPU1.AP23 JXDP1.22
CFG_RCOMP: JCPU1.AT31 RC81.1
CHAGER_SRC: PC701.1 PC702.1 PC710.1 PC711.1 PC712.1 PC713.1 PC714.1 PC739.1 PC740.1 PJP700.2 PL701.1 PQ704.5 PQ705.5
CHARGE_EN: R3.2 U46.A45
CHARGE_MODULE_BATT: PR876.2 U46.A15
CHARGE_MODULE_BATT_C2: PR876.1 PU808.9
CHARGE_PBATT: PR873.2 U46.B16
CHARGE_PBATT_C2: PR873.1 PU808.10
CHARGER_CELL_PIN: PD818.2 PR745.1
CHARGER_SMBCLK: PU700.9 R828.2 U51.B50
CHARGER_SMBDAT: PU700.8 R827.2 U51.A47
CHG_LGATE: PQ706.4 PQ711.4 PU700.15
CHG_PHASE: PC709.2 PC715.1 PL700.2 PQ704.1 PQ704.2 PQ704.3 PQ705.1 PQ705.2 PQ705.3 PQ706.5 PQ711.5 PU700.19
CHG_UGATE: PQ704.4 PQ705.4 PU700.18
CHGVR_DCIN: PR833.2 PU800.35
CKEA0: UV1.K21 UV4.J3 UV5.J3
CKEA1: UV1.J20 UV3.J3 UV6.J3
CKEB0: UV1.U10 UV7.J3 UV8.J3
CKEB1: UV1.AA11 UV9.J3 UV10.J3
CLK_80H: RH159.2 UH1.F36
CLK_BUF_BCLK: RPH5.3 UH1.AT24
CLK_BUF_BCLK#: RPH5.4 UH1.AR24
CLK_BUF_CKSSCD: RH143.1 UH1.BC6
CLK_BUF_CKSSCD#: RH141.1 UH1.BE6
CLK_BUF_DMI: RPH5.1 UH1.AW24
CLK_BUF_DMI#: RPH5.2 UH1.AY24
CLK_BUF_DOT96: RH138.1 UH1.G33
CLK_BUF_DOT96#: RH136.1 UH1.H33
CLK_CPU_DMI: RC48.2 UH1.AF40
CLK_CPU_DMI#: RC46.2 UH1.AF39
CLK_CPU_DPLL: JCPU1.H28 UH1.AF36
CLK_CPU_DPLL#: JCPU1.G28 UH1.AF35
CLK_CPU_ITP: RH1.2 UH1.AH45
CLK_CPU_ITP#: RH2.2 UH1.AH43
CLK_CPU_SSC_DPLL: RC44.2 UH1.AJ39
CLK_CPU_SSC_DPLL#: RC42.2 UH1.AJ40
CLK_DDC2_CRT: JBTB1.9 U6.14
CLK_DDC2_DOCK: JDOCK1.48 U6.15
CLK_ENABLE#_VGA: PR620.2 PU600.40
CLK_KBD: JDOCK1.78 R845.2 U51.A38
CLK_MSE: JDOCK1.71 R851.2 U51.A39
CLK_PCH_14M: RH146.1 UH1.F45
CLK_PCI_5048: CH15.1 R795.1 RH158.2 U46.A28
CLK_PCI_DOCK: CH76.1 JDOCK1.121 R756.1 RH162.2
CLK_PCI_LOOPBACK: CH77.1 RH164.2 UH1.D17
CLK_PCI_MEC: CH16.1 R885.1 RH160.2 U51.A29
CLK_PCI_TPM: CH78.1 RE5.1 RH155.1 U39.21
CLK_PCIE_EMB: JSATA2.15 UH1.AJ42
CLK_PCIE_EMB#: JSATA2.16 UH1.AJ44
CLK_PCIE_EXP: JEXP1.11 UH1.AF45
CLK_PCIE_EXP#: JEXP1.9 UH1.AF43
CLK_PCIE_LAN: U31.44 UH1.AA42
CLK_PCIE_LAN#: U31.45 UH1.AA44
CLK_PCIE_MINI1: JMINI1.13 UH1.Y45
CLK_PCIE_MINI1#: JMINI1.11 UH1.Y43
CLK_PCIE_MINI2: JMINI2.13 UH1.AE42
CLK_PCIE_MINI2#: JMINI2.11 UH1.AE44
CLK_PCIE_MINI3: JMINI3.13 UH1.AD45
CLK_PCIE_MINI3#: JMINI3.11 UH1.AD43
CLK_PCIE_MMI: U38.3 UH1.AB45
CLK_PCIE_MMI#: U38.2 UH1.AB43
CLK_PCIE_VGA: UH1.AB36 UV1.AB35
CLK_PCIE_VGA#: UH1.AB35 UV1.AA36
CLK_SIO_14M: CH79.1 R794.1 RH157.1 U46.A32
CLK_TP_SIO: C751.1 R902.2 R1164.1 U51.A37
CLK_XDP: JXDP1.40 RH1.1
CLK_XDP#: JXDP1.42 RH2.1
CLKA0: RV187.1 UV1.H27 UV4.J12 UV5.J12
CLKA0#: RV188.1 UV1.G27 UV4.J11 UV5.J11
CLKA1: RV189.1 UV1.J14 UV3.J12 UV6.J12
CLKA1#: RV190.1 UV1.H14 UV3.J11 UV6.J11
CLKB0: RV206.1 UV1.L9 UV7.J12 UV8.J12
CLKB0#: RV208.1 UV1.L8 UV7.J11 UV8.J11
CLKB1: RV209.1 UV1.AD8 UV9.J12 UV10.J12
CLKB1#: RV210.1 UV1.AD7 UV9.J11 UV10.J11
CLKRUN#: RH90.2 U39.15 U46.B20 U51.A32 UH1.AN7
CLKTESTA: CV82.1 UV1.AK10
CLKTESTB: CV81.1 UV1.AL10
COMP: PC517.2 PC519.2 PC523.2 PC525.2 PR539.2 PR542.2 PU500.7
CONTACTLESS_DET#: JUSH1.4 RH201.2 UH1.C16
CPPE#: JMINI2.37 R737.1 UH1.B13
CPU1.5V_S3_GATE: R889.2 RC96.1 U51.A36
CPU_B+: PC503.1 PC504.1 PC505.1 PC506.1 PC507.1 PC512.1 PC513.1 PC514.1 PC515.1 PC516.1 PC530.1 PC531.1 PC532.1 PC533.1 PC534.1 PC535.1 PC536.1 PC537.1 PJP500.2 PL504.1 PQ501.5 PQ502.5 PQ505.5 PQ506.5 PQ509.5 PQ510.5 PR526.2
CPU_DETECT#: JCPU1.AP32 R763.2 U46.A3
CPU_DMI: JCPU1.E26 RC48.1
CPU_DMI#: JCPU1.D26 RC46.1
CPU_EDP_HPD: QC3.2 RC75.1 U27.1
CPU_PLTRST#: RC66.2 UH1.AU4
CPU_PLTRST#_R: JCPU1.AT26 RC23.1 RC64.2 RC66.1
CPU_PWR_DEBUG: JCPU1.H27 RC22.1 RC85.2 RC89.1
CPU_PWR_DEBUG_R: JXDP1.45 RC22.2
CPU_SSC_DPLL: JCPU1.E27 RC44.1
CPU_SSC_DPLL#: JCPU1.F27 RC42.1
CPU_VTT_ON: R789.2 U46.B17
CPUSB#: CE10.1 JEXP1.2 U41.9
CRT_IREF: RH97.2 UH1.U40
CRT_SWITCH: U6.30 U46.B52
CS_1.35V: PR201.2 PU200.13
CSA0#_0: UV1.K24 UV4.G12 UV5.L12
CSA1#_0: UV1.M13 UV3.L12 UV6.G12
CSB0#_0: UV1.P10 UV7.L12 UV8.G12
CSB1#_0: UV1.AD10 UV9.L12 UV10.G12
CSS_GC: PR702.1 PU800.10
CSSN_1: PQ701.3 PQ703.2 PR703.1 PR705.2 PR707.1 PR744.2 PU703.5
CSSP_1: PQ702.3 PQ703.5 PR703.2 PR704.2 PR706.1 PR736.1
CVT_LVDS_A0+: JLVDS1.32 U27.41
CVT_LVDS_A0-: JLVDS1.33 U27.42
CVT_LVDS_A1+: JLVDS1.30 U27.39
CVT_LVDS_A1-: JLVDS1.31 U27.40
CVT_LVDS_A2+: JLVDS1.28 U27.37
CVT_LVDS_A2-: JLVDS1.29 U27.38
CVT_LVDS_ACLK+: C49.1 JLVDS1.25 U27.35
CVT_LVDS_ACLK-: C43.1 JLVDS1.26 U27.36
CVT_LVDS_B0+: JLVDS1.22 U27.31
CVT_LVDS_B0-: JLVDS1.23 U27.32
CVT_LVDS_B1+: JLVDS1.20 U27.29
CVT_LVDS_B1-: JLVDS1.21 U27.30
CVT_LVDS_B2+: JLVDS1.18 U27.27
CVT_LVDS_B2-: JLVDS1.19 U27.28
CVT_LVDS_BCLK+: C40.1 JLVDS1.15 U27.25
CVT_LVDS_BCLK-: C41.1 JLVDS1.16 U27.26
D_CLKRUN#: JDOCK1.111 R777.2 U46.A19
D_DLDRQ1#: JDOCK1.117 R782.2 U46.B24
D_LAD0: JDOCK1.97 U46.B29
D_LAD1: JDOCK1.99 U46.B28
D_LAD2: JDOCK1.103 U46.A25
D_LAD3: JDOCK1.105 U46.A24
D_LFRAME#: JDOCK1.109 U46.B23
D_SERIRQ: JDOCK1.115 R780.2 U46.A20
DAI_12MHZ#: C987.1 JDOCK1.89 R1654.1 RE11.1
DAI_BCLK#: C986.1 JDOCK1.77 R1668.1 RE12.1
DAI_DI: JDOCK1.83 U74.24
DAI_DO#: JDOCK1.85 R1097.1
DAI_LRCK#: JDOCK1.79 U74.18
DAT_DDC2_CRT: JBTB1.11 U6.12
DAT_DDC2_DOCK: JDOCK1.46 U6.13
DAT_KBD: JDOCK1.80 R846.2 U51.B41
DAT_MSE: JDOCK1.73 R852.2 U51.B42
DAT_TP_SIO: C752.1 R903.2 R1163.1 U51.B40
DBG_CNTL0: T115.1(TP-1) UV1.AP8
DBG_DATA3: T91.1(TP-1) UV1.AP6
DBG_DATA4: T92.1(TP-1) UV1.AW5
DBG_DATA5: T93.1(TP-1) UV1.AU5
DBG_DATA6: T94.1(TP-1) UV1.AR6
DBG_DATA7: T95.1(TP-1) UV1.AW6
DBG_DATA8: T96.1(TP-1) UV1.AU6
DBG_DATA9: T97.1(TP-1) UV1.AT7
DBG_DATA10: T98.1(TP-1) UV1.AV7
DBG_DATA11: T99.1(TP-1) UV1.AN7
DBG_DATA12: T100.1(TP-1) UV1.AV9
DBG_DATA13: T101.1(TP-1) UV1.AT9
DBG_DATA14: T102.1(TP-1) UV1.AR10
DBG_DATA15: T103.1(TP-1) UV1.AW10
DBG_DATA16: T104.1(TP-1) UV1.AU10
DBG_DATA17: T105.1(TP-1) UV1.AP10
DBG_DATA18: T106.1(TP-1) UV1.AV11
DBG_DATA19: T107.1(TP-1) UV1.AT11
DBG_DATA20: T108.1(TP-1) UV1.AR12
DBG_DATA21: T112.1(TP-1) UV1.AW12
DBG_DATA22: T113.1(TP-1) UV1.AU12
DBG_DATA23: T114.1(TP-1) UV1.AP12
DBG_VREFG: CV115.1 RV66.1 RV68.2 UV1.AH13
DC_BLOCK_GC: PR700.2 PU800.7
DC_IN_SS: PR831.2 PU800.34
DDBIA0_0: UV1.A34 UV5.P13
DDBIA0_1: UV1.E30 UV4.D2
DDBIA0_2: UV1.E26 UV4.P13
DDBIA0_3: UV1.C20 UV5.D2
DDBIA1_0: UV1.C16 UV6.D2
DDBIA1_1: UV1.C12 UV3.P13
DDBIA1_2: UV1.J11 UV3.D2
DDBIA1_3: UV1.F8 UV6.P13
DDBIB0_0: UV1.G7 UV7.P13
DDBIB0_1: UV1.K1 UV8.D2
DDBIB0_2: UV1.P1 UV8.P13
DDBIB0_3: UV1.W4 UV7.D2
DDBIB1_0: UV1.AC4 UV10.D2
DDBIB1_1: UV1.AH3 UV9.P13
DDBIB1_2: UV1.AJ8 UV9.D2
DDBIB1_3: UV1.AM3 UV10.P13
DDR3_DRAMRST#_CPU: JCPU1.AN3 QD9.3 RD4.2 RD24.1
DDR3_DRAMRST#_Q: QD9.1 RD2.2 RD4.1 RD25.1
DDR3_DRAMRST#_R: JDIMM1.30 JDIMM2.30 RD25.2
DDR_A_BS0: JCPU1.V5 JDIMM1.109
DDR_A_BS1: JCPU1.U5 JDIMM1.108
DDR_A_BS2: JCPU1.AD1 JDIMM1.79
DDR_A_CAS#: JCPU1.U8 JDIMM1.115
DDR_A_D0: JCPU1.AR15 JDIMM1.5
DDR_A_D1: JCPU1.AT14 JDIMM1.7
DDR_A_D2: JCPU1.AM14 JDIMM1.15
DDR_A_D3: JCPU1.AN14 JDIMM1.17
DDR_A_D4: JCPU1.AT15 JDIMM1.4
DDR_A_D5: JCPU1.AR14 JDIMM1.6
DDR_A_D6: JCPU1.AN15 JDIMM1.16
DDR_A_D7: JCPU1.AM15 JDIMM1.18
DDR_A_D8: JCPU1.AM9 JDIMM1.21
DDR_A_D9: JCPU1.AN9 JDIMM1.23
DDR_A_D10: JCPU1.AM8 JDIMM1.33
DDR_A_D11: JCPU1.AN8 JDIMM1.35
DDR_A_D12: JCPU1.AR9 JDIMM1.22
DDR_A_D13: JCPU1.AT9 JDIMM1.24
DDR_A_D14: JCPU1.AR8 JDIMM1.34
DDR_A_D15: JCPU1.AT8 JDIMM1.36
DDR_A_D16: JCPU1.AJ9 JDIMM1.39
DDR_A_D17: JCPU1.AK9 JDIMM1.41
DDR_A_D18: JCPU1.AJ6 JDIMM1.51
DDR_A_D19: JCPU1.AK6 JDIMM1.53
DDR_A_D20: JCPU1.AJ10 JDIMM1.40
DDR_A_D21: JCPU1.AK10 JDIMM1.42
DDR_A_D22: JCPU1.AJ7 JDIMM1.50
DDR_A_D23: JCPU1.AK7 JDIMM1.52
DDR_A_D24: JCPU1.AF4 JDIMM1.57
DDR_A_D25: JCPU1.AF5 JDIMM1.59
DDR_A_D26: JCPU1.AF1 JDIMM1.67
DDR_A_D27: JCPU1.AF2 JDIMM1.69
DDR_A_D28: JCPU1.AG4 JDIMM1.56
DDR_A_D29: JCPU1.AG5 JDIMM1.58
DDR_A_D30: JCPU1.AG1 JDIMM1.68
DDR_A_D31: JCPU1.AG2 JDIMM1.70
DDR_A_D32: JCPU1.J1 JDIMM1.129
DDR_A_D33: JCPU1.J2 JDIMM1.131
DDR_A_D34: JCPU1.J5 JDIMM1.141
DDR_A_D35: JCPU1.H5 JDIMM1.143
DDR_A_D36: JCPU1.H2 JDIMM1.130
DDR_A_D37: JCPU1.H1 JDIMM1.132
DDR_A_D38: JCPU1.J4 JDIMM1.140
DDR_A_D39: JCPU1.H4 JDIMM1.142
DDR_A_D40: JCPU1.F2 JDIMM1.147
DDR_A_D41: JCPU1.F1 JDIMM1.149
DDR_A_D42: JCPU1.D2 JDIMM1.157
DDR_A_D43: JCPU1.D3 JDIMM1.159
DDR_A_D44: JCPU1.D1 JDIMM1.146
DDR_A_D45: JCPU1.F3 JDIMM1.148
DDR_A_D46: JCPU1.C3 JDIMM1.158
DDR_A_D47: JCPU1.B3 JDIMM1.160
DDR_A_D48: JCPU1.B5 JDIMM1.163
DDR_A_D49: JCPU1.E6 JDIMM1.165
DDR_A_D50: JCPU1.A5 JDIMM1.175
DDR_A_D51: JCPU1.D6 JDIMM1.177
DDR_A_D52: JCPU1.D5 JDIMM1.164
DDR_A_D53: JCPU1.E5 JDIMM1.166
DDR_A_D54: JCPU1.B6 JDIMM1.174
DDR_A_D55: JCPU1.A6 JDIMM1.176
DDR_A_D56: JCPU1.E12 JDIMM1.181
DDR_A_D57: JCPU1.D12 JDIMM1.183
DDR_A_D58: JCPU1.B11 JDIMM1.191
DDR_A_D59: JCPU1.A11 JDIMM1.193
DDR_A_D60: JCPU1.E11 JDIMM1.180
DDR_A_D61: JCPU1.D11 JDIMM1.182
DDR_A_D62: JCPU1.B12 JDIMM1.192
DDR_A_D63: JCPU1.A12 JDIMM1.194
DDR_A_DQS0: JCPU1.AP14 JDIMM1.12
DDR_A_DQS1: JCPU1.AP9 JDIMM1.29
DDR_A_DQS2: JCPU1.AK8 JDIMM1.47
DDR_A_DQS3: JCPU1.AG3 JDIMM1.64
DDR_A_DQS4: JCPU1.H3 JDIMM1.137
DDR_A_DQS5: JCPU1.E3 JDIMM1.154
DDR_A_DQS6: JCPU1.C6 JDIMM1.171
DDR_A_DQS7: JCPU1.C12 JDIMM1.188
DDR_A_DQS#0: JCPU1.AP15 JDIMM1.10
DDR_A_DQS#1: JCPU1.AP8 JDIMM1.27
DDR_A_DQS#2: JCPU1.AJ8 JDIMM1.45
DDR_A_DQS#3: JCPU1.AF3 JDIMM1.62
DDR_A_DQS#4: JCPU1.J3 JDIMM1.135
DDR_A_DQS#5: JCPU1.E2 JDIMM1.152
DDR_A_DQS#6: JCPU1.C5 JDIMM1.169
DDR_A_DQS#7: JCPU1.C11 JDIMM1.186
DDR_A_MA0: JCPU1.V8 JDIMM1.98
DDR_A_MA1: JCPU1.AC6 JDIMM1.97
DDR_A_MA2: JCPU1.V9 JDIMM1.96
DDR_A_MA3: JCPU1.U9 JDIMM1.95
DDR_A_MA4: JCPU1.AC5 JDIMM1.92
DDR_A_MA5: JCPU1.AC4 JDIMM1.91
DDR_A_MA6: JCPU1.AD6 JDIMM1.90
DDR_A_MA7: JCPU1.AC3 JDIMM1.86
DDR_A_MA8: JCPU1.AD5 JDIMM1.89
DDR_A_MA9: JCPU1.AC2 JDIMM1.85
DDR_A_MA10: JCPU1.V6 JDIMM1.107
DDR_A_MA11: JCPU1.AC1 JDIMM1.84
DDR_A_MA12: JCPU1.AD4 JDIMM1.83
DDR_A_MA13: JCPU1.V7 JDIMM1.119
DDR_A_MA14: JCPU1.AD3 JDIMM1.80
DDR_A_MA15: JCPU1.AD2 JDIMM1.78
DDR_A_RAS#: JCPU1.U6 JDIMM1.110
DDR_A_WE#: JCPU1.U7 JDIMM1.113
DDR_B_BS0: JCPU1.R7 JDIMM2.109
DDR_B_BS1: JCPU1.P8 JDIMM2.108
DDR_B_BS2: JCPU1.AA9 JDIMM2.79
DDR_B_CAS#: JCPU1.P7 JDIMM2.115
DDR_B_D0: JCPU1.AR18 JDIMM2.5
DDR_B_D1: JCPU1.AT18 JDIMM2.7
DDR_B_D2: JCPU1.AM17 JDIMM2.15
DDR_B_D3: JCPU1.AM18 JDIMM2.17
DDR_B_D4: JCPU1.AR17 JDIMM2.4
DDR_B_D5: JCPU1.AT17 JDIMM2.6
DDR_B_D6: JCPU1.AN17 JDIMM2.16
DDR_B_D7: JCPU1.AN18 JDIMM2.18
DDR_B_D8: JCPU1.AT12 JDIMM2.21
DDR_B_D9: JCPU1.AR12 JDIMM2.23
DDR_B_D10: JCPU1.AN12 JDIMM2.33
DDR_B_D11: JCPU1.AM11 JDIMM2.35
DDR_B_D12: JCPU1.AT11 JDIMM2.22
DDR_B_D13: JCPU1.AR11 JDIMM2.24
DDR_B_D14: JCPU1.AM12 JDIMM2.34
DDR_B_D15: JCPU1.AN11 JDIMM2.36
DDR_B_D16: JCPU1.AR5 JDIMM2.39
DDR_B_D17: JCPU1.AR6 JDIMM2.41
DDR_B_D18: JCPU1.AM5 JDIMM2.51
DDR_B_D19: JCPU1.AM6 JDIMM2.53
DDR_B_D20: JCPU1.AT5 JDIMM2.40
DDR_B_D21: JCPU1.AT6 JDIMM2.42
DDR_B_D22: JCPU1.AN5 JDIMM2.50
DDR_B_D23: JCPU1.AN6 JDIMM2.52
DDR_B_D24: JCPU1.AJ4 JDIMM2.57
DDR_B_D25: JCPU1.AK4 JDIMM2.59
DDR_B_D26: JCPU1.AJ1 JDIMM2.67
DDR_B_D27: JCPU1.AJ2 JDIMM2.69
DDR_B_D28: JCPU1.AM1 JDIMM2.56
DDR_B_D29: JCPU1.AN1 JDIMM2.58
DDR_B_D30: JCPU1.AK2 JDIMM2.68
DDR_B_D31: JCPU1.AK1 JDIMM2.70
DDR_B_D32: JCPU1.L2 JDIMM2.129
DDR_B_D33: JCPU1.M2 JDIMM2.131
DDR_B_D34: JCPU1.L4 JDIMM2.141
DDR_B_D35: JCPU1.M4 JDIMM2.143
DDR_B_D36: JCPU1.L1 JDIMM2.130
DDR_B_D37: JCPU1.M1 JDIMM2.132
DDR_B_D38: JCPU1.L5 JDIMM2.140
DDR_B_D39: JCPU1.M5 JDIMM2.142
DDR_B_D40: JCPU1.G7 JDIMM2.147
DDR_B_D41: JCPU1.J8 JDIMM2.149
DDR_B_D42: JCPU1.G8 JDIMM2.157
DDR_B_D43: JCPU1.G9 JDIMM2.159
DDR_B_D44: JCPU1.J7 JDIMM2.146
DDR_B_D45: JCPU1.J9 JDIMM2.148
DDR_B_D46: JCPU1.G10 JDIMM2.158
DDR_B_D47: JCPU1.J10 JDIMM2.160
DDR_B_D48: JCPU1.A8 JDIMM2.163
DDR_B_D49: JCPU1.B8 JDIMM2.165
DDR_B_D50: JCPU1.A9 JDIMM2.175
DDR_B_D51: JCPU1.B9 JDIMM2.177
DDR_B_D52: JCPU1.D8 JDIMM2.164
DDR_B_D53: JCPU1.E8 JDIMM2.166
DDR_B_D54: JCPU1.D9 JDIMM2.174
DDR_B_D55: JCPU1.E9 JDIMM2.176
DDR_B_D56: JCPU1.E15 JDIMM2.181
DDR_B_D57: JCPU1.D15 JDIMM2.183
DDR_B_D58: JCPU1.A15 JDIMM2.191
DDR_B_D59: JCPU1.B15 JDIMM2.193
DDR_B_D60: JCPU1.E14 JDIMM2.180
DDR_B_D61: JCPU1.D14 JDIMM2.182
DDR_B_D62: JCPU1.A14 JDIMM2.192
DDR_B_D63: JCPU1.B14 JDIMM2.194
DDR_B_DQS0: JCPU1.AP17 JDIMM2.12
DDR_B_DQS1: JCPU1.AP12 JDIMM2.29
