# Allegro board LA-9411P R10-0403.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
USBP9+: length 286.8
  IN2 w0.127: v2(116.75,100.08) 116.75,100.15 116.61,100.29 116.43,100.29 116.33,100.19 116.33,99.92 116.16,99.76 116.16,97.58 121.9,91.84 121.9,89.55 135.36,76.09 180.42,76.09 187.7,83.36 195.73,83.36 201.4,77.69 203.06,77.69 205.97,74.77 206.76,74.77 206.99,74.54 206.99,73.82 206.48,73.31 206.48,72.47 209.47,69.48 211.16,69.48 212.53,68.11 213.57,68.11 214.44,67.25 216.72,67.25 217.25,66.72 217.28,66.72 218.04,65.95 218.41,65.95 218.72,66.25 v2(218.72,66.62)
  BOTTOM w0.089: UH1.C30 215.98,68.53 216.3,68.21 216.61,68.21 216.82,68 216.82,67.83 217.39,67.26 217.6,67.26 217.72,67.13
  BOTTOM w0.102: R1151.1 25.8,180.56 L90.1 26.36,180.56 26.61,180.82 26.62,180.82 26.63,180.84 27.05,180.84 27.33,180.56 27.33,178.31 36.34,169.3 77.19,169.3 77.3,169.41 82.18,169.41 85.44,166.14 85.44,162.08 87,160.52 90.06,160.52 92.5,158.08 95.66,158.08 101.2,152.54 101.2,151.02 106.96,145.26 106.96,141.75 106.96,141.57 109.91,138.62 109.91,115.76 109.46,115.3 109.46,115.13 109.46,115.13 109.46,102.68 113.07,99.06 116.14,99.06 116.57,99.49 116.57,99.9 v2(116.75,100.08) ; v2(218.72,66.62) 218.66,66.57 218.29,66.57 217.72,67.13
USBP9-: length 286.7
  IN2 w0.127: v2(219.19,66.28) 219.17,66.28 218.59,65.7 217.94,65.7 217.17,66.46 217.14,66.46 216.61,66.99 214.33,66.99 213.47,67.86 212.42,67.86 211.05,69.23 209.37,69.23 206.23,72.36 206.23,73.42 206.74,73.93 206.74,74.43 206.65,74.52 205.86,74.52 202.95,77.43 201.3,77.43 195.62,83.11 187.8,83.11 180.53,75.83 135.26,75.83 121.65,89.44 121.65,89.65 121.65,89.65 121.65,91.73 115.91,97.47 115.91,97.68 v2(115.91,100.11)
  BOTTOM w0.089: UH1.A30 216.48,67.89 217.31,67.06 217.51,67.06 217.56,67 217.56,66.99 217.58,66.98
  BOTTOM w0.102: v2(115.91,100.11) 116.19,100.11 116.36,99.94 116.36,99.58 116.05,99.28 113.16,99.28 109.67,102.77 109.67,115.22 110.13,115.67 110.13,138.71 107.17,141.66 107.17,145.17 107.17,145.17 107.17,145.34 101.41,151.1 101.41,152.63 95.75,158.29 92.59,158.29 90.15,160.73 87.09,160.73 85.65,162.16 85.65,166.23 82.26,169.62 77.21,169.62 77.1,169.51 36.43,169.51 27.54,178.4 27.54,180.65 27.14,181.05 26.72,181.05 26.36,181.41 L90.4 25.8,181.41 R1150.1 ; v2(219.19,66.28) 219.19,66.11 219.02,65.94 218.88,65.94 218.79,66.03 218.79,66.17 218.74,66.22 218.55,66.22 218.42,66.34 218.22,66.34 217.58,66.98
USBP9_D+: length 14.3
  TOP w0.102: v2(18.77,180.81) 18.69,180.81 18.51,180.99 17.08,180.99 v4(16.76,181.31) 15.08,182.99 14.89,182.99 14.79,182.89 JUSB4.3
  BOTTOM w0.102: v2(18.77,180.81) 18.84,180.88 19.79,180.88 19.9,180.78 D74.2 20.33,180.45 20.33,180.75 20.4,180.82 20.66,180.82 20.82,180.67 20.82,180.28 21.19,179.9 22.52,179.9 23.52,180.9 23.63,180.9 23.97,180.56 L90.2 24.49,180.48 R1151.2
USBP9_D-: length 14.3
  TOP w0.102: JUSB4.2 14.79,183.49 15.08,183.2 15.17,183.2 16.71,181.66 16.73,181.66 17.19,181.2 18.58,181.2 v2(18.77,181.39)
  BOTTOM w0.102: v2(18.77,181.39) 19.06,181.09 19.79,181.09 19.9,181.19 D74.3 20.35,181.5 20.35,181.27 20.59,181.03 20.75,181.03 21.03,180.76 21.03,180.37 21.28,180.11 22.43,180.11 23.43,181.11 23.64,181.11 23.94,181.41 L90.3 24.49,181.5 R1150.2
USBP10+: length 123.1
  TOP w0.102: v2(277.93,27.19) 278.12,27 281.94,27 282.05,26.89 286.41,26.89 287.93,28.41 288.89,28.41 289.03,28.56 JEXP1.5
  IN1 w0.114: v2(220.58,65.04) 220.42,65.2 220.42,65.38 220.62,65.58 224.79,65.58 231.05,71.84 236.24,71.84 237.63,70.45 245.5,70.45 246.05,71.01 248.8,71.01 249.06,71.26 250.82,71.26 v2(251.11,70.97)
  BOTTOM w0.089: 216.99,66.47 216.98,66.48 216.98,66.49 216.93,66.54 216.93,66.54 216.93,66.55 216.93,66.72 216.67,66.98 216.56,67.09 216.02,67.63 215.76,67.63 215.58,67.81 215.58,68.19 215.25,68.52 UH1.D29
  BOTTOM w0.102: v2(251.11,70.97) 251.2,71.06 251.2,71.23 251.11,71.32 250.88,71.32 250.82,71.39 250.82,71.44 250.74,71.52 250.65,71.52 250.59,71.45 250.59,69.8 250.93,69.45 250.93,62.7 252.95,60.68 252.95,58.3 253.08,58.17 253.08,56.98 256.74,53.32 256.74,52.15 257.37,51.51 257.37,47.78 257.68,47.48 257.85,47.48 258.54,46.79 258.54,38.24 257.64,37.34 257.64,34.01 256.93,33.3 256.93,30.93 258.64,29.22 259.39,29.22 261.67,26.94 277.68,26.94 v2(277.93,27.19) ; v2(220.58,65.04) 220.32,64.77 219.09,64.77 218.55,65.31 218.15,65.31 216.99,66.47
USBP10-: length 123.2
  TOP w0.102: v2(277.93,26.61) 278.11,26.79 281.86,26.79 281.96,26.68 286.5,26.68 286.62,26.81 288.01,28.2 288.91,28.2 289.05,28.06 JEXP1.3
  IN1 w0.114: v2(219.97,65.65) 220.36,65.65 220.53,65.81 224.69,65.81 230.95,72.07 236.33,72.07 237.72,70.68 245.4,70.68 245.96,71.23 248.71,71.23 248.96,71.49 250.87,71.49 v2(251.11,71.73)
  BOTTOM w0.089: 215.89,67.94 215.99,68.05 216.06,68.05 216.18,67.93 216.18,67.75 216.34,67.59 216.53,67.59 216.58,67.54 216.58,67.35 216.64,67.28 216.81,67.28 216.86,67.23 216.86,67.07 216.92,67 217.08,67 217.13,66.95 217.13,66.63 217.14,66.62
  BOTTOM w0.102: v2(251.11,71.73) 250.57,71.73 250.38,71.54 250.38,69.71 250.72,69.36 250.72,62.61 252.74,60.59 252.74,58.21 252.87,58.08 252.87,56.89 256.53,53.24 256.53,52.06 257.16,51.42 257.16,47.7 257.59,47.27 257.76,47.27 258.33,46.7 258.33,38.33 257.43,37.43 257.43,34.1 256.72,33.39 256.72,30.84 258.55,29.01 259.3,29.01 261.59,26.73 277.81,26.73 v2(277.93,26.61) ; 217.14,66.62 218.24,65.52 218.64,65.52 219.17,64.99 219.5,64.99 219.58,65.06 219.58,65.21 219.63,65.27 219.81,65.27 219.87,65.2 219.87,65.06 219.95,64.99 220.11,64.99 220.18,65.06 220.18,65.21 220.29,65.33 220.29,65.38 220.02,65.65 v2(219.97,65.65)
USBP12+: length 221.4
  IN1 w0.109: v2(214.22,68.63) 214.6,68.63 215.28,67.95 216.74,67.95 217.16,68.37 218.31,68.37 218.48,68.2 218.48,68.19 218.52,68.15 218.52,68.14 218.54,68.12
  IN1 w0.114: v2(260.67,170.7) 260.79,170.7 261.35,170.14 261.35,167.83 261.03,167.51 261.03,139.25 261.72,138.56 261.72,133.49 262.15,133.06 262.15,120.78 261.27,119.9 261.27,114.15 262.21,113.21 262.21,111.43 261.96,111.18 261.96,108.1 262.21,107.85 262.21,102.55 251.77,92.11 251.16,92.11 248.52,89.48 248.52,76.72 245.22,73.42 237.97,73.42 237.28,74.12 229.45,74.12 226.7,71.36 226.33,71.36 225.53,70.56 225.39,70.56 223.86,69.04 222.16,69.04 221.15,68.03 218.64,68.03 218.63,68.04 218.62,68.04 218.54,68.12
  IN2 w0.127: v2(260.67,170.7) 258.66,170.7 258.2,170.24 256.07,170.24 254.42,171.89 236.86,171.89 235.72,170.75 233.03,170.75 232.56,171.22 232.56,171.87 231.34,173.09 222.91,173.09 222.32,173.67 214.56,173.67 214.31,173.42 206.86,173.42 206.15,172.71 205.13,172.71 204.09,171.66 200.04,171.66 198.12,169.75 196.28,169.75 195.52,168.99 194.85,168.99 194.42,168.55 192.26,168.55 191.85,168.15 191.85,167.44 v2(191.77,167.35)
  BOTTOM w0.089: UH1.F26 214.01,68.48 214.16,68.63 v2(214.22,68.63)
  BOTTOM w0.102: R427.1 190.4,167.62 L10.1 190.4,168.46 190.29,168.57 189.86,168.57 189.81,168.62 189.81,168.73 189.99,168.9 190.65,168.9 191.94,167.61 191.94,167.48 191.81,167.35 v2(191.77,167.35)
USBP12-: length 222.1
  TOP w0.089: v1(213.48,68.5) 213.76,68.78 v2(213.76,69.09)
  IN1 w0.109: 218.71,68.28 218.4,68.59 217.06,68.59 216.64,68.17 215.37,68.17 214.46,69.09 v2(213.76,69.09)
  IN1 w0.114: 218.71,68.28 218.72,68.27 218.73,68.27 218.74,68.26 221.03,68.26 222.03,69.27 223.77,69.27 225.29,70.79 225.43,70.79 226.23,71.59 226.6,71.59 229.36,74.35 237.37,74.35 238.07,73.65 245.13,73.65 248.29,76.82 248.29,89.57 248.67,89.95 251.06,92.34 251.25,92.34 251.68,92.34 261.98,102.65 261.98,107.75 261.73,108.01 261.73,111.27 261.98,111.52 261.98,113.12 261.04,114.06 261.04,119.99 261.92,120.87 261.92,132.96 261.49,133.39 261.49,138.46 260.8,139.15 260.8,167.6 261.12,167.92 261.12,170.04 260.94,170.22 260.76,170.22 260.67,170.12 v2(260.67,169.87)
  IN2 w0.127: v2(192.35,167.35) 192.11,167.59 192.11,168.05 192.36,168.3 194.53,168.3 194.96,168.73 195.63,168.73 196.39,169.49 198.23,169.49 200.15,171.41 204.2,171.41 205.24,172.45 206.26,172.45 206.97,173.16 214.41,173.16 214.67,173.42 222.22,173.42 222.8,172.83 231.24,172.83 232.3,171.77 232.3,171.12 232.92,170.5 235.82,170.5 236.96,171.64 254.31,171.64 255.96,169.99 258.3,169.99 258.76,170.45 260.1,170.45 v2(260.67,169.87)
  BOTTOM w0.089: v2(213.76,69.09) 213.58,68.92 UH1.G26
  BOTTOM w0.102: R428.1 189.6,167.6 L10.4 189.6,168.81 189.9,169.11 190.74,169.11 192.15,167.7 192.15,167.54 v2(192.35,167.35)
USBP12_D+: length 7.3
  BOTTOM w0.102: R427.2 190.4,166.47 L10.2 190.4,165.92 190.12,165.64 190.12,165.53 190.34,165.31 191.56,165.31 192.1,165.84 193.92,165.84 194.17,165.59 194.38,165.59 194.46,165.67 194.46,165.99 194.53,166.06 JCAM1.2
USBP12_D-: length 7.5
  BOTTOM w0.102: JCAM1.3 194.74,165.06 194.42,165.38 194.08,165.38 193.83,165.63 192.18,165.63 191.65,165.1 190.25,165.1 189.91,165.44 189.91,165.62 189.6,165.93 L10.3 189.6,166.49 R428.2
USBRBIAS: length 3.1
  TOP w0.089: v1(212.71,69.74) 212.25,69.28 v2(212.19,69.28) 212.19,68.42 RH187.1
  BOTTOM w0.089: UH1.K26 212.34,69.42 v2(212.19,69.28) 212.05,69.13 UH1.K24
USH_DET#: length 114
  TOP w0.102: v2(212.24,55.61) 212.29,55.57 212.29,54.6 RH202.1 ; v2(247.47,96.16) 247.47,95.26 249.58,93.15 251.25,93.15 255.34,89.07 JUSH1.1 264.55,89.07 264.84,89.36 265.95,89.36 v1(266.1,89.2)
  IN1 w0.089: v2(209.64,64.05) 209.88,63.82 209.88,59.72 210.1,59.5
  IN1 w0.102: 210.1,59.5 211.88,57.72 211.88,55.97 v2(212.24,55.61)
  IN3 w0.089: 213.21,61.11 213.29,61.19 213.3,61.19 ; v2(209.64,64.05) 209.64,64.04 210.31,63.37 210.31,61 210.94,60.38 210.97,60.38
  IN3 w0.127: 210.97,60.38 211.01,60.38 211.22,60.16 211.34,60.16 211.41,60.08 211.47,60.08 211.7,59.85 211.7,59.62 211.92,59.4 212.04,59.4 212.04,59.4 212.83,59.4 212.96,59.52 212.96,60.86 213.21,61.11 ; 213.3,61.19 213.74,61.19 214.82,60.1 215.56,60.1 217.39,58.27 218.13,58.27 219.03,57.37 221.6,57.37 223.57,55.4 230.34,55.4 231.52,54.22 234.68,54.22 237.49,57.02 237.49,59.24 241.45,63.2 241.45,73.02 242.9,74.47 242.9,83.74 245.26,86.09 245.26,94.77 246.65,96.16 v2(247.47,96.16)
  BOTTOM w0.089: v2(209.64,64.05) 209.85,64.27 UH1.F13
USH_PWR_ON: length 230.7
  TOP w0.102: U46.A18 271.44,62.76 272.12,63.45 272.45,63.45 R518.2 273.26,64.26 274.29,64.26 274.38,64.17 279.18,64.17 281.12,62.23 282.57,62.23 v2(282.6,62.2) ; v2(172.89,159.92) 172.65,160.16 172.65,160.17 171.79,161.04 171.36,161.04 170.7,160.38 R1620.1 ; v1(245.09,105.68) 244.92,105.85 v2(244.92,106.34)
  IN2 w0.127: v2(279.34,100.84) 275.97,100.84 273.1,97.97 271.34,97.97 271.04,98.26 271.04,99.21 271.38,99.56 271.38,101.35 270.73,101.99 251.63,101.99 247.96,105.66 245.59,105.66 v2(244.92,106.34)
  IN3 w0.127: v2(279.34,100.84) 279.34,98.68 279.81,98.21 279.81,96.14 277.98,94.31 277.98,66.32 281.79,62.51 282.27,62.51 282.57,62.2 v2(282.6,62.2) ; v2(172.89,159.92) 173.03,159.92 174.6,158.36 174.6,151.93 177.05,149.47 177.05,146.85 179.78,144.12 180.56,144.12 181.2,143.48 181.2,142.6 180.78,142.18 180.78,140.38 181.42,139.73 181.42,132.92 180.23,131.73 180.23,123.33 183.98,119.59 183.98,116.6 182.51,115.13 182.51,112.26 183.14,111.62 183.14,110.53 184.39,109.28 189.04,109.28 189.57,109.82 194.66,109.82 195.46,109.02 217.54,109.02 222.99,103.57 227.92,103.57 228.57,104.22 230.95,104.22 233.62,101.55 242.49,101.55 244.92,103.97 v2(244.92,106.34)
USH_PWR_STATE#: length 42.3
  TOP w0.102: R1640.1 264.98,87.63 264.41,87.07 JUSH1.5 261.94,87.07 v2(261.59,87.41) ; U46.A34 262.45,55.89 262.03,56.3 261.83,56.3 v1(261.62,56.52) v2(261.18,56.95)
  BOTTOM w0.102: v2(261.18,56.95) 260.78,57.35 260.78,58.05 261.01,58.29 261.01,61.93 265.64,66.56 265.64,79.08 263.61,81.11 262.19,81.11 261.88,81.42 261.88,82.07 261.49,82.46 261.49,87.31 v2(261.59,87.41)
USH_SMBCLK: length 44.5
  TOP w0.102: v2(262.36,81.54) 262.54,81.71 263.01,81.71 263.16,81.57 JUSH1.16 264.75,81.57 264.88,81.7 265.82,81.7 R589.2 ; U51.A50 284.22,108.26 283.99,108.04 v2(283.99,107.78)
  IN1 w0.102: v2(262.36,81.54) 262.54,81.71 263.22,81.71 263.62,82.11 263.62,89.76 267.01,93.15 267.01,94.18 271.22,98.39 v2(271.51,98.39) ; v2(283.99,107.78) 283.78,107.57 283.78,106.59 282.84,105.65 282.18,105.65 281.11,104.58 281.11,102.81 280.68,102.38 280.07,102.38 279.88,102.18 v2(279.81,102.18)
  IN2 w0.127: v2(279.81,102.18) 279.77,102.18 279.64,102.31 279.26,102.31 278.29,101.35 275.79,101.35 273.01,98.56 271.69,98.56 v2(271.51,98.39)
USH_SMBDAT: length 46.4
  TOP w0.102: v2(262.36,82.12) 262.54,81.94 263.03,81.94 263.16,82.07 JUSH1.15 264.75,82.07 264.88,81.93 266.19,81.93 R585.2 ; v2(283.57,110.03) 283.97,109.63 U51.B53
  IN1 w0.102: v2(279.81,102.77) 279.98,102.61 280.59,102.61 280.88,102.9 280.88,104.68 282.08,105.88 282.74,105.88 283.55,106.69 283.55,110.01 v2(283.57,110.03) ; v2(271.52,98.98) 271.38,98.98 271,98.6 271,98.49 266.79,94.28 266.79,93.24 263.39,89.85 263.39,82.21 263.13,81.94 262.54,81.94 v2(262.36,82.12)
  IN2 w0.127: v2(279.81,102.77) 279.61,102.56 279.1,102.56 278.14,101.6 275.68,101.6 272.9,98.82 271.69,98.82 v2(271.52,98.98)
V_SYS: length 323.3
  TOP w0.102: v2(281.48,101.36) 282.02,100.81 R392.2
  TOP w0.254: PU700.7 74.79,185.17 v4(74.53,185.43)
  IN3 w0.127: v2(73.62,180.38) 73.62,180.01 77.91,175.72 81.34,175.72 84.96,172.1 84.96,171.45 88.11,168.3 88.43,168.3 89.99,166.74 102.07,166.74 102.43,166.37 108.95,166.37 110.29,165.03 110.29,161.63 111.65,160.27 115.13,160.27 115.59,160.73 117.34,160.73 117.99,161.38 121.02,161.38 121.28,161.65 122.26,161.65 122.97,160.93 123.73,160.93 124.19,160.48 126.89,160.48 128.15,161.73 138,161.73 138.33,162.06 140.09,162.06 140.66,161.49 147.09,161.49 148.07,162.47 148.49,162.47 154.56,162.47 155.74,163.65 156.42,163.65 157.98,165.21 157.98,169.98 159.37,171.37 160.04,171.37 160.14,171.27 164.04,171.27 165.1,172.33 165.32,172.33 167.07,174.08 167.56,174.08 168.47,174.98 170.8,174.98 172.42,176.61 178.7,176.61 179.23,176.07 181.01,176.07 181.15,176.21 181.87,176.21 182.46,175.63 183.79,175.63 184.16,175.26 186,175.26 187.54,176.8 190.54,176.8 192.02,178.27 194.18,178.27 194.48,178.57 195.94,178.57 196.25,178.27 197.35,178.27 197.62,178.54 202.58,178.54 202.61,178.5 204.95,178.5 205.68,177.77 211.2,177.77 213.46,180.03 217.38,180.03 219.44,182.09 227.55,182.09 228.28,181.37 231.49,181.37 235.33,185.2 245.32,185.2 245.8,185.69 247.79,185.69 248.01,185.46 252.12,185.46 253.35,184.23 263.28,184.23 269.15,178.36 269.93,178.36 270.56,177.74 270.56,173.65 269.92,173.01 269.92,172.06 270.07,171.91 270.07,169.7 269.79,169.42 269.79,167.94 270.06,167.68 270.06,149.88 269.44,149.25 269.44,147.36 272.14,144.66 272.25,144.66 274.07,142.84 274.07,135.54 274.19,135.43 274.19,123.55 273.52,122.87 273.52,110.99 274.39,110.11 274.39,108.66 274.11,108.38 274.11,106.21 277.78,102.54 278.87,102.54 279.64,101.76 279.89,101.76 280.28,101.37 280.28,100.69 280.53,100.44 280.88,100.44 281.29,100.85 281.29,101.17 v2(281.48,101.36)
  BOTTOM w0.254: v2(73.62,180.38) v1(74.19,180.95) 74.49,181.25 74.49,182.6 75.32,183.43 PC716.2 75.26,184.45 74.53,185.18 v4(74.53,185.43)
V_SYS_R: length 14.6
  TOP w0.102: v2(287.89,110.02) 287.92,109.99 287.92,109.36 U51.B61 ; R392.1 281.99,101.73 281.59,102.12 v2(281.59,102.58) 281.59,102.76 v1(281.95,103.11)
  IN1 w0.102: v2(287.89,110.02) 287.88,110.01 287.88,107.15 286.71,105.98 283.89,105.98 283.09,105.18 283.09,104.38 281.59,102.88 v2(281.59,102.58)
VCI_IN3#: length 3.2
  TOP w0.102: R1156.2 293.39,106.95 v2(292.66,107.68) 291.47,108.87 U51.B68
VCORE_VDDP: length 7.2
  TOP w0.508: PC509.2 123.41,153.26 v4(124.02,152.65) 124.61,152.65 PR520.1
  BOTTOM w0.102: PR523.1 125.14,152.67 v1(126.4,151.41)
  BOTTOM w0.203: 123.43,153.12 123.43,153.21 122.81,153.83 PU500.23
  BOTTOM w0.508: PR523.1 125.12,152.65 v4(124.02,152.65) 123.9,152.65 123.43,153.12
VCP: length 337.3
  TOP w0.102: U51.A12 293.52,115.66 v2(293.64,115.78) ; v2(193.67,171.6) 193.67,172.08 v1(193.4,172.35)
  TOP w0.254: v2(105.09,161.33) 104.81,161.05 PR710.1 ; PU702.1 102.34,157.24 101.84,156.73 v2(101.84,156.22) 102.09,155.97 PU702.2 ; PR728.1 89.91,163.59 89.71,163.79 v2(89.71,164.22)
  IN1 w0.229: 282.72,116.4 283.79,116.4 284.13,116.05 284.48,116.05 284.65,115.88
  IN1 w0.254: 282.72,116.4 282.71,116.38 280.45,116.38 280.14,116.69 280.14,125.11 280.81,125.77 280.81,131.11 279.61,132.3 279.61,136.47 278.81,137.27 278.81,137.7 278.49,138.02 278.49,144.57 276.33,146.73 276.33,154.44 275.87,154.91 275.87,166.84 277.26,168.24 277.26,169.53 277,169.8 277,170.92 277.21,171.13 280.31,171.13 280.56,171.39 283.5,171.39 283.73,171.61 283.73,172.68 v2(283.4,173.01) ; v2(293.64,115.78) 293.49,115.63 292.62,115.63 292.27,115.29 289.47,115.29 288.96,114.78 286.24,114.78 285.9,115.13 285.4,115.13 284.65,115.88 ; v2(188.34,182.09) 188.37,182.05 188.37,181.64 189.54,180.47 190.1,180.47 192.45,178.12 192.45,176.53 192.6,176.37 192.6,172.67 v2(193.67,171.6)
  IN2 w0.254: v2(188.34,182.09) 188.35,182.09 188.76,181.68 190.18,181.68 190.77,182.27 193.04,182.27 194.03,181.28 198.2,181.28 198.74,180.75 203.36,180.75 204.14,179.97 204.14,179.23 204.39,178.98 210.89,178.98 212.43,180.52 226.62,180.52 227.49,179.64 233.65,179.64 236.3,182.3 247.91,182.3 248.88,181.33 251.14,181.33 251.37,181.56 251.38,181.56 252.58,182.76 252.65,182.76 258.87,182.76 260.35,184.24 263.57,184.24 267.39,180.42 279.12,180.42 281.29,178.24 281.29,178.24 282.3,177.22 282.3,175.44 282.9,174.85 282.9,173.53 283.4,173.04 v2(283.4,173.01) ; v2(161.4,162.98) 162.64,164.22 163.97,164.22 164.36,164.61 164.54,164.61 168.11,168.19 169.99,168.19 172.66,170.87 177.09,170.87 177.33,170.62 180.6,170.62 181.97,172 183.45,172 184.01,172.55 184.77,172.55 185.35,173.14 186.32,173.14 186.75,173.57 191.97,173.57 193.64,171.9 193.64,171.57 v2(193.67,171.6)
  IN3 w0.254: v2(105.09,161.33) 105.09,158.43 106.33,157.19 113.2,157.19 113.98,157.96 117.24,157.96 118.42,156.78 122.73,156.78 123.2,157.25 123.37,157.42 126.96,157.42 127.43,156.95 128.73,156.95 130.27,155.41 132.15,155.41 132.32,155.57 132.32,158.78 132.55,159 135.25,159 135.9,158.36 151.16,158.36 151.52,158.71 154.5,158.71 155.44,159.65 157.51,159.65 160.27,162.41 160.76,162.41 161.18,162.83 161.25,162.83 v2(161.4,162.98)
  BOTTOM w0.254: v2(89.71,164.22) 90.59,164.22 92.44,162.37 100.07,162.37 100.72,163.02 103.67,163.02 105.09,161.59 v2(105.09,161.33) 104.52,160.76 103.78,160.76 103.08,160.06 103.08,157.35 101.95,156.22 v2(101.84,156.22)
VCP_1: length 14.3
  TOP w0.102: PU702.3 101.01,154.7 v1(100.95,154.63)
  TOP w0.254: PU702.3 104.05,154.7 104.67,155.32 104.67,157.39 103.23,158.83 103.23,160.81 104.55,162.13 105.76,162.13 PR727.1 PR729.2
VCT_LAN_R1: length 3.4
  BOTTOM w0.102: U31.6 v1(315.52,194.69) 315.52,193.69 R152.2 R556.2
VGA_ID: length 10.3
  TOP w0.102: R803.1 270.19,44.12 v1(270.19,42.53) ; R803.1 269.67,44.57 R800.2 ; R803.1 269.71,44.84 v2(269.32,45.24) ; v2(268.04,49.4) 267.61,48.96 267.61,48.51 267.69,48.44 U46.B59
  IN1 w0.102: v2(269.32,45.24) 268.74,45.81 268.74,46.58 268.49,46.84 268.49,48.95 v2(268.04,49.4)
VGA_THERMDN: length 80
  TOP w0.254: U51.A15 293.23,117.16 293.62,117.55 293.62,118.64 v2(293.76,118.78) ; v2(294.39,121.97) 294.95,122.53 C287.1
  IN2 w0.102: 234.75,124.9 234.74,124.9 234.66,124.98 234.58,124.98 234.32,125.23 233.9,125.65 233.84,125.65 233.76,125.58 230.83,125.58 229.32,124.07 228.88,124.07 v2(228.82,124)
  IN2 w0.254: v2(294.39,121.97) 293.94,121.53 292.1,121.53 289.44,124.18 289.44,124.91 288.52,125.83 282.74,125.83 282.43,126.14 280.97,126.14 280.55,125.72 279.48,125.72 278.72,126.48 277.17,126.48 275.39,124.7 271.39,124.7 270.72,124.03 266.35,124.03 266.17,123.85 259.52,123.85 259.23,123.56 253.5,123.56 251.76,121.82 245.23,121.82 242.14,124.9 234.75,124.9
  IN4 w0.254: v2(293.76,118.78) 293.99,119.01 293.99,120.65 294.39,121.05 v2(294.39,121.97)
  BOTTOM w0.102: v2(228.82,124) 228.45,124.37 UV1.AG29
VGA_THERMDP: length 81.4
  TOP w0.254: U51.B16 291.74,117.41 291.38,117.77 v2(291.38,117.86) ; C287.2 294.04,122.34 v2(293.73,122.03)
  IN1 w0.254: v2(293.73,122.03) 293.73,119.66 292.11,118.03 291.56,118.03 v2(291.38,117.86)
  IN2 w0.102: 234.75,125.41 234.72,125.41 234.69,125.38 234.68,125.38 234.05,126.01 233.69,126.01 233.62,125.93 230.68,125.93 229.17,124.42 228.63,124.42 227.9,123.69 v2(227.89,123.69)
  IN2 w0.254: 234.75,125.41 242.35,125.41 245.44,122.33 251.53,122.33 253.27,124.07 259.02,124.07 259.31,124.36 265.96,124.36 266.14,124.54 270.51,124.54 271.18,125.21 275.18,125.21 276.96,126.99 278.93,126.99 279.7,126.23 280.34,126.23 280.76,126.64 282.64,126.64 282.95,126.34 288.73,126.34 289.95,125.12 289.95,124.39 292.31,122.03 v2(293.73,122.03)
  BOTTOM w0.102: v2(227.89,123.69) 227.88,123.69 227.25,124.32 UV1.AF29
VID0: length 5.2
  TOP w0.254: PR613.1 v4(305.8,167.14)
  BOTTOM w0.203: v4(305.8,167.14) 306.31,166.64 v1(307.58,166.64) 307.96,166.64 308.44,166.15 PU600.31
  BOTTOM w0.254: PR613.1 v4(305.8,167.14)
VID6: length 2.9
  BOTTOM w0.203: PU600.37 310.84,166.27 v1(311.48,166.9) 312.02,167.45 PR615.2
VIDALERT_N: length 81.4
  TOP w0.102: v2(133.68,98.78) 133.68,98.31 v1(132.93,97.57) 132.37,97.57 131.89,97.08 RC88.2 131.89,96.55 131.99,96.44 133.02,96.44 133.14,96.32 133.14,94.94 133.02,94.82 132.01,94.82 131.89,94.94 RC87.2
  IN1 w0.102: v2(117.58,147.5) 116.86,147.5 115.5,146.14 115.5,131.69 115.5,131.23 124.52,122.21 124.52,121.02 124.52,121.02 124.52,120.56 128.4,116.67 130.08,116.67 130.08,116.67 130.54,116.67 131.25,116.67 133.51,114.42 133.51,110.48 135.46,108.53 140.76,108.53 141.21,108.09 141.21,106.82 140.83,106.44 139.56,106.44 139.3,106.18 139.3,102.76 138.92,102.37 135.62,102.37 134.73,101.49 134.73,99.83 v2(133.68,98.78)
  BOTTOM w0.102: v2(117.58,147.5) 118.21,148.12 PR506.1
VIDSCLK: length 59.4
  TOP w0.102: v2(116.76,148.32) v1(116.76,147.78)
  IN1 w0.102: v2(116.76,148.32) 114.91,146.47 114.91,131.1 114.94,131.06 114.94,130.99 123.96,121.98 123.96,121.25 123.96,120.79 123.96,120.33 128.17,116.12 131.02,116.12 132.95,114.19 132.95,110.25 135.76,107.44 140.21,107.44 v2(140.73,106.92)
  BOTTOM w0.089: v2(140.73,106.92) 141.2,107.39 JCPU1.AM29
  BOTTOM w0.102: v2(116.76,148.32) 116.18,148.91 PR508.1
VIDSOUT: length 75.2
  TOP w0.089: 136,103.2 136.14,103.2 136.5,103.56 137.57,103.56 137.58,103.55 137.89,103.55 137.99,103.64 138.48,103.64 138.58,103.55 138.89,103.55 139.33,103.99 139.33,104.05 139.75,104.47 139.81,104.47 140.15,104.81 140.15,105.87 140.76,106.48 141,106.48 141.45,106.92 v2(141.73,106.92)
  TOP w0.102: 136,103.2 v1(135.75,103.2) 135.49,103.2 134.51,102.22 v2(134.49,102.22) 132.52,100.25 132.18,100.25 RC90.2
  IN1 w0.102: v2(141.73,106.92) 142.11,107.3 142.11,109.09 141.78,109.42 135.36,109.42 134.09,110.69 134.09,114.43 134.07,114.45 134.07,114.65 131.48,117.23 130.77,117.23 128.64,117.23 125.08,120.79 125.08,122.44 116.06,131.46 116.06,145.91 117.05,146.9 117.84,146.9 118.33,147.4 118.79,147.4 v2(119.74,148.35)
  BOTTOM w0.102: v2(141.73,106.92) JCPU1.AL28 ; v2(119.74,148.35) 119.74,148.37 120.24,148.87 PR505.1
VLDOIN_1.35V: length 0.9
  BOTTOM w0.102: v4(208.14,9.85) v1(209.04,9.85)
  vias: v4(207.72,12.73) v4(207.88,13.35) v4(208.15,9.17)
VOL_DOWN#: length 353.1
  TOP w0.102: v2(61.83,197.24) v1(60.69,197.24) 58.68,197.24 58.02,197.9 57.23,197.9 56.5,198.64 JBTB1.10 ; v2(287.32,100.23) 287.32,100.15 287.4,100.08 287.4,99.81 287.18,99.59 R1197.2 R887.2
  IN3 w0.127: v2(61.83,197.24) 63.48,195.59 65.65,195.59 70.91,190.33 70.91,185.53 72.69,183.76 72.69,180.81 72.98,180.51 72.98,180.28 77.9,175.36 81.33,175.36 84.14,172.56 84.14,171.07 85.37,169.84 86.09,169.84 87.98,167.95 88.42,167.95 89.89,166.48 101.84,166.48 102.33,166 108.97,166 110.04,164.92 110.04,161.53 111.54,160.02 115.23,160.02 115.69,160.48 117.45,160.48 117.65,160.68 123.62,160.68 124.08,160.22 127,160.22 128.23,161.45 138.08,161.45 138.44,161.81 139.98,161.81 140.6,161.19 140.6,161.19 140.65,161.24 147.2,161.24 148.18,162.22 148.39,162.22 154.66,162.22 155.84,163.4 156.53,163.4 158.26,165.13 158.26,169.9 159.48,171.12 159.86,171.12 160.1,170.88 164.01,170.88 165.11,171.98 165.34,171.98 167.18,173.82 167.67,173.82 168.57,174.73 170.9,174.73 172.46,176.29 174.48,176.29 174.57,176.2 178.74,176.2 179.13,175.82 180.72,175.82 181.17,175.37 183.62,175.37 183.99,175.01 187.21,175.01 188.75,176.54 190.65,176.54 192.12,178.02 194.28,178.02 194.59,178.32 195.84,178.32 196.14,178.02 197.46,178.02 197.73,178.28 202.47,178.28 202.51,178.24 204.75,178.24 205.51,177.49 211.69,177.49 213.47,179.27 214.52,179.27 215.54,178.26 216.82,178.26 219.95,181.38 226.89,181.38 227.41,180.86 231.8,180.86 235.48,184.54 248.52,184.54 248.86,184.88 251.61,184.88 252.78,183.72 262.95,183.72 270.05,176.62 270.05,173.93 269.41,173.29 269.41,171.75 269.52,171.65 269.52,169.86 269.29,169.63 269.29,166.29 269.55,166.03 269.55,150.09 268.93,149.46 268.93,147.15 272.04,144.04 272.16,144.04 273.22,142.97 273.22,137.3 272.72,136.79 272.72,134.95 273.16,134.51 273.16,133.74 273.93,132.97 273.93,131.7 272.88,130.64 272.88,129.71 273.06,129.53 273.06,125.89 273.26,125.68 273.26,110.88 274.13,110.01 274.13,108.77 273.86,108.49 273.86,106.1 277.67,102.29 278.76,102.29 279.54,101.51 279.79,101.51 280.03,101.27 280.03,100.58 280.42,100.19 280.98,100.19 282,101.21 286.37,101.21 287.32,100.25 v2(287.32,100.23)
VOL_DOWN_LED: length 2.6
  TOP w0.102: JBTB1.20 54,199.13 53.81,198.93 v1(53.81,198.36) 53.81,197.75 53.96,197.6 R954.2
VOL_DOWN_R#: length 13
  TOP w0.102: v2(287.22,107.71) 287.22,107.38 286.66,106.82 286.66,105.02 287.13,104.55 287.13,101.82 R887.1 ; U51.B57 285.97,109.61 286.06,109.7 286.06,110.22 286.29,110.45 286.74,110.45 287.21,110.92 v2(287.36,110.92)
  BOTTOM w0.102: v2(287.36,110.92) v1(287,110.56) 286.9,110.46 286.9,109.61 287.22,109.3 v2(287.22,107.71)
VOL_MUTE: length 361.3
  TOP w0.102: v2(63.36,196.48) 63.1,196.74 v1(62.59,196.74) 58.81,196.74 57.92,197.62 56.88,197.62 56,198.5 JBTB1.12 ; R884.2 R1169.2 299.39,107.11 v2(299.26,106.98)
  IN3 w0.127: v2(63.36,196.48) 63.88,195.96 65.76,195.96 71.17,190.55 71.17,185.69 73.06,183.8 73.06,181.97 73.34,181.69 73.8,181.69 75.04,180.45 75.04,179.34 77.97,176.42 81.61,176.42 85.65,172.37 85.65,171.79 90.05,167.4 97.96,167.4 98.64,168.07 101.53,168.07 102.5,167.11 108.95,167.11 110.8,165.25 110.8,161.84 111.86,160.78 114.92,160.78 116.02,161.89 120.74,161.89 121.26,162.41 126.47,162.41 126.53,162.36 137.74,162.36 137.95,162.57 140.3,162.57 140.87,162 146.88,162 148.44,163.56 149.75,163.56 149.87,163.68 150.58,163.68 151.28,162.98 154.35,162.98 155.53,164.16 156.21,164.16 157.43,165.38 157.43,170.15 159.19,171.91 160.1,171.91 160.22,172.02 163.93,172.02 166.49,174.59 167.35,174.59 168.26,175.49 170.48,175.49 172.11,177.11 179.02,177.11 179.55,176.58 180.58,176.58 180.78,176.77 182.17,176.77 182.72,176.22 184.18,176.22 184.31,176.35 186.13,176.35 187.19,177.42 190.45,177.42 191.81,178.78 192.84,178.78 193.56,179.5 196,179.5 196.31,179.81 201.26,179.81 202.14,178.93 202.69,178.93 202.87,178.75 205.06,178.75 205.78,178.03 211.1,178.03 213.38,180.31 217.08,180.31 219.11,182.35 227.66,182.35 228.31,181.7 231.4,181.7 235.16,185.46 245.22,185.46 245.7,185.94 247.89,185.94 248.12,185.71 252.27,185.71 253.35,184.63 263.48,184.63 269.5,178.61 270.04,178.61 271.07,177.58 271.07,176.07 271.39,175.75 271.39,174.71 270.81,174.13 270.81,172.11 270.66,171.96 270.66,168.2 270.33,167.87 270.33,149.78 269.69,149.15 269.69,147.46 272.24,144.92 272.36,144.92 274.33,142.95 274.33,135.65 274.44,135.53 274.44,123.24 273.77,122.57 273.77,111.12 274.64,110.25 274.64,109.3 274.84,109.11 277.91,109.11 281.34,105.68 287.51,105.68 288.4,106.57 289.18,106.57 289.44,106.82 289.44,106.84 289.54,106.95 293.89,106.95 294.38,107.44 295.46,107.44 295.78,107.12 295.78,106.83 296.04,106.57 298.85,106.57 v2(299.26,106.98)
VOL_MUTE_WHITE_LED: length 2.8
  TOP w0.102: JBTB1.16 55,198.87 v1(55.67,198.2) 55.99,197.88 R989.2
VOL_MUTE_YELLOW_LED#: length 8.7
  TOP w0.102: v1(59.15,198.25) 59.09,198.18 58.58,198.18 58.35,198.41 57.87,198.41 57.5,198.78 JBTB1.6 57.5,200.43 v2(57.26,200.67) ; R988.2 57.18,196.86 v2(56.88,196.86)
  BOTTOM w0.102: v2(57.26,200.67) 57.26,197.24 v2(56.88,196.86)
VOL_UP#: length 344.3
  TOP w0.102: v1(65.01,196.61) v2(64.12,196.61) 63.06,197.66 58.64,197.66 58.17,198.13 57.39,198.13 57,198.52 JBTB1.8 ; v2(298.74,113.32) 298.76,113.32 299.41,113.97 299.72,113.97 300.25,113.44 R888.2 R1118.2
  IN1 w0.102: v2(298.74,113.32) 298.46,113.32 297.3,114.48 297.3,115.13 296.92,115.51 295.44,115.51 295.25,115.32 292.91,115.32 292.57,114.97 289.87,114.97 289.38,114.48 285.59,114.48 284.58,115.49 282.72,115.49 282.14,116.08 280.32,116.08 279.83,116.57 279.83,130.21 279.31,130.73 279.31,136.34 278.51,137.14 278.51,137.57 278.19,137.89 278.19,144.44 276,146.62 276,154.34 275.56,154.79 275.56,166.97 276.93,168.34 276.93,169.35 276.69,169.6 276.69,171.26 276.87,171.44 280.19,171.44 280.44,171.69 282.39,171.69 v2(283.13,172.43)
  IN2 w0.127: v2(184.32,183.74) 185.42,183.74 187.84,181.33 190.48,181.33 191.04,181.89 192.69,181.89 193.73,180.85 197.81,180.85 198.29,180.36 201.52,180.36 201.87,180.01 201.87,179.1 202.31,178.66 211.04,178.66 212.57,180.19 225.57,180.19 226.56,179.2 233.91,179.2 236.69,181.98 247.66,181.98 248.62,181.01 251.35,181.01 252.78,182.44 259,182.44 260.48,183.92 263.36,183.92 267.18,180.1 278.87,180.1 281.99,176.99 281.99,174.85 282.57,174.26 282.57,173.18 283.07,172.68 283.07,172.49 v2(283.13,172.43) ; v2(180.42,187.62) 179.89,187.08 175.69,187.08 174.54,185.94 169.99,185.94 165.95,189.98 161.16,189.98 160.74,189.56 159.6,189.56 159.18,189.98 139.49,189.98 138.79,189.28 133.51,189.28 130.28,186.05 122.33,186.05 121.73,186.66 118.58,186.66 117.33,187.91 113.97,187.91 112.79,186.73 107.36,186.73 105.2,188.88 v4(105.2,190.17)
  IN3 w0.127: v2(64.12,196.61) 65.9,196.61 71.36,191.15 98.53,191.15 99.3,190.39 104.99,190.39 v4(105.2,190.17)
  BOTTOM w0.102: v2(184.32,183.74) 183.55,183.74 183,184.29 183,184.72 182.39,185.33 182.39,185.42 180.42,187.39 v2(180.42,187.62)
VOL_UP_LED: length 2.8
  TOP w0.102: R3672.2 52.94,197.68 52.54,198.08 v1(52.54,198.28) 52.54,198.53 53,198.99 JBTB1.24
VR_HOT#: length 2.7
  BOTTOM w0.102: PR524.2 116.18,154.95 116.28,155.05 117.01,155.05 v1(117.1,155.14) 117.44,155.14 117.56,155.03 PU500.5
VR_ON: length 4.1
  TOP w0.102: v1(117.13,152.72) v2(116.44,152.72) PR511.2
  BOTTOM w0.102: v2(116.44,152.72) 116.44,152.83 117.44,153.83 PU500.2
VREFC1: length 8.9
  BOTTOM w0.102: RV139.2 189.35,111.1 v1(189.35,109.65)
  BOTTOM w0.254: 193.19,113.99 193.19,114.36 193.2,114.37 193.2,114.84 UV4.J14
  BOTTOM w0.508: 193.19,113.99 193.19,113.23 192.9,112.94 RV110.1 CV326.1 CV208.2 RV139.2
VREFC2: length 11.5
  TOP w0.254: UV5.J14 193.45,114.91 193.72,114.64 v2(193.72,114.53)
  BOTTOM w0.102: RV184.1 198.99,111.51 198.48,111 v1(198.48,109.42)
  BOTTOM w0.508: v2(193.72,114.53) 194.06,114.19 195.97,114.19 196.32,113.83 196.32,112.51 196.96,111.87 CV328.2 ; CV328.2 RV183.2 RV184.1 ; CV328.2 CV329.1
VREFC3: length 16.1
  TOP w0.254: 191.82,145.74 191.88,145.68 192.77,145.68 193.45,145 UV3.J14
  TOP w0.508: v2(184.69,145.24) 185.66,145.24 186.23,145.81 188.82,145.81 188.89,145.74 191.82,145.74
  BOTTOM w0.102: RV193.2 184.77,148.98 185.28,148.48 v1(185.4,148.48)
  BOTTOM w0.508: RV193.2 RV194.1 CV349.1 CV350.2 183.7,145.92 184.39,145.24 v2(184.69,145.24)
VREFC4: length 15
  TOP w0.508: v2(189.15,146.38) 188.96,146.57 v1(185.66,146.57) 185.02,145.94 RV197.2 RV198.1 CV353.1 CV354.2
  IN1 w0.508: v2(193.09,144.09) 193.09,145.34 192.05,146.38 v2(189.15,146.38)
  BOTTOM w0.254: v2(193.09,144.09) 193.45,144.46 UV6.J14
VREFC5: length 11.1
  TOP w0.102: v1(213.52,150.42) 212.91,151.03 212.91,152.29 RV5.1
  TOP w0.508: v2(207.03,155.55) 208.05,155.55 209.41,154.19 CV22.1 CV21.2 RV6.2 RV5.1
  BOTTOM w0.254: UV8.J14 206.49,156.09 v2(207.03,155.55)
VREFC6: length 6.9
  TOP w0.254: 206.21,155.17 206.32,155.29 206.32,155.85 206.31,155.86 UV7.J14
  TOP w0.508: 206.21,155.17 206.21,154.29 v1(206.66,153.84) 207.37,153.12 RV11.1 CV27.1 CV28.2 RV12.2
VREFC7: length 9.3
  TOP w0.102: v1(228.3,152.35) 228.7,152.74 RV19.2
  TOP w0.254: v2(227.91,155.61) 227.91,155.66 227.48,156.09 UV9.J14
  TOP w0.508: CV34.2 CV33.1 RV17.1 ; CV34.2 v2(230.23,153.54) ; CV34.2 RV19.2
  IN2 w0.508: v2(230.23,153.54) 229.42,154.36 229.42,154.98 228.79,155.61 v2(227.91,155.61)
VREFC8: length 35.7
  TOP w0.102: v1(237.5,156.9) 237.5,156.81 v2(236.8,156.11)
  TOP w0.508: RV27.2 CV40.2 CV39.1 RV24.1 228.71,169.21 229.51,168.41 232.93,168.41 v2(233.24,168.73) ; v2(227.11,155.54) 227.15,155.54 227.67,155.02 227.97,155.02 228.19,154.8 229.62,154.8 229.92,155.09 236.13,155.09 236.8,155.77 v2(236.8,156.11)
  IN1 w0.508: v2(236.8,156.11) 237.05,156.36 237.05,161.82 235.73,163.14 235.73,166.24 v2(233.24,168.73)
  BOTTOM w0.254: v2(227.11,155.54) 227.09,155.54 227.12,155.57 227.12,155.91 UV10.J14
VREFD1_1: length 9.7
  BOTTOM w0.254: 186.63,119.49 186.63,118.71 UV4.A10
  BOTTOM w0.508: 186.63,119.49 v1(184.1,122.03) 183.7,122.43 CV322.2 CV207.1 RV128.1 RV109.2
VREFD1_2: length 7.2
  BOTTOM w0.254: 200.48,118.16 199.99,118.16 UV4.U10
  BOTTOM w0.508: 200.48,118.16 v1(202.87,118.16) RV131.1 CV324.1 CV323.2 RV129.2
VREFD2_1: length 14.7
  TOP w0.102: v2(204.07,125.39) v1(204.07,126.54)
  TOP w0.254: UV5.A10 v2(200.39,118.83)
  TOP w0.508: RV181.1 CV325.2 CV327.1 RV140.2 203.11,124.75 203.74,125.39 v2(204.07,125.39)
  IN3 w0.508: v2(204.07,125.39) 202.27,123.58 202.27,121.5 200.39,119.62 v2(200.39,118.83)
VREFD2_2: length 10.8
  TOP w0.254: UV5.U10 187.02,118.3 186.61,118.71 186.61,119.32
  TOP w0.508: 186.61,119.32 186.61,119.35 183.7,122.26 v1(183.7,123.04) CV330.2 CV331.1 RV185.2 RV186.1
VREFD3_1: length 9.2
  TOP w0.102: v1(181.69,136.93) 183.26,136.93 183.7,137.38 RV120.1
  TOP w0.254: UV3.A10 186.8,141.3 186.36,140.86
  TOP w0.508: RV120.1 RV119.2 CV209.2 CV210.1 186.36,140.86
VREFD3_2: length 6.2
  TOP w0.254: UV3.U10 200.74,141.3
  TOP w0.508: 200.74,141.3 200.77,141.33 v1(201.99,141.33) CV332.1 RV192.1 RV191.2 CV333.2
VREFD4_1: length 8.8
  IN3 w0.508: v2(200.35,141.86) 200.97,141.24 200.97,141.02 v2(202.32,139.67)
  BOTTOM w0.102: v1(203.18,135.58) 203.02,135.75 RV196.1
  BOTTOM w0.254: UV6.A10 199.85,141.36 v2(200.35,141.86)
  BOTTOM w0.508: v2(202.32,139.67) 202.88,139.67 CV351.1 CV352.2 RV195.2 RV196.1
VREFD4_2: length 8.2
  BOTTOM w0.102: CV356.2 183.7,137.58 v1(183.5,137.38)
  BOTTOM w0.254: 185.53,141.47 185.7,141.3 UV6.U10
  BOTTOM w0.508: 185.53,141.47 185.12,141.87 CV355.1 RV205.1 RV203.2 CV356.2
VREFD5_1: length 11.4
  TOP w0.102: v1(196.81,162.99) 196.75,162.94 RV1.2
  TOP w0.508: v2(196.15,159.1) 196.03,159.22 196.03,159.32 195.5,159.85 RV65.1 CV18.2 CV13.1 RV1.2
  IN2 w0.508: v2(196.15,159.1) 196.28,159.1 196.34,159.16 196.59,159.16 197.73,160.3 v2(200.31,160.3)
  BOTTOM w0.254: v2(200.31,160.3) 200.13,160.3 199.84,160.01 199.84,159.36 UV8.A10
VREFD5_2: length 13.7
  TOP w0.102: RV4.1 216.06,160.24 216.47,160.64 217.84,160.64 v1(218.16,160.32)
  TOP w0.508: CV20.1 CV19.2 RV3.2 ; CV20.1 214.13,159.14 213.93,159.35 213.93,159.9 212.75,161.07 v2(211.5,161.07) ; CV20.1 RV4.1
  BOTTOM w0.254: UV8.U10 212.75,159.33 212.75,160.17 211.84,161.07 v2(211.5,161.07)
VREFD6_1: length 11.5
  TOP w0.102: v1(218.16,164.69) 216.44,164.69 216.06,164.31 RV7.1
  TOP w0.254: UV7.A10 212.71,159.38 212.35,159.74 v2(212.28,159.74)
  TOP w0.508: v2(214.63,161.75) 214.63,161.73 215.18,161.18 RV8.2 CV24.2 CV23.1 RV7.1
  IN1 w0.508: v2(214.63,161.75) 213.22,161.75 212.28,160.81 v2(212.28,159.74)
VREFD6_2: length 17.5
  TOP w0.102: v1(196.92,168.12) 196.36,168.68 v2(196.36,168.69)
  TOP w0.254: v2(200.3,159.69) 199.91,159.3 UV7.U10
  TOP w0.508: v2(196.36,168.69) 196.36,170.03 CV25.1 ; CV25.1 CV26.2 RV10.2 ; CV25.1 RV9.1
  IN4 w0.508: v2(196.36,168.69) 196.5,168.69 197.3,167.89 197.3,161.15 198.76,159.69 v2(200.3,159.69)
VREFD7_1: length 21.7
  TOP w0.254: v2(234.18,159.79) 233.71,159.32 UV9.A10
  BOTTOM w0.102: v2(234.18,159.79) v1(236.6,159.79)
  BOTTOM w0.508: v2(234.18,159.79) 234.18,159.85 235.12,160.79 235.12,166.53 233.85,167.8 229.9,167.8 228.96,168.74 CV30.2 CV29.1 RV13.1 RV14.2
VREFD7_2: length 16.8
  TOP w0.102: v2(218.88,170.12) v1(218.09,170.12)
  TOP w0.254: UV9.U10 221.01,159.4 221.01,160.59 220.68,160.92 v2(220.58,160.92)
  IN1 w0.508: v2(220.58,160.92) 220.58,161.3 218.89,162.99 218.89,164.96 218.45,165.4 218.45,168.87 218.88,169.3 v2(218.88,170.12)
  BOTTOM w0.508: v2(218.88,170.12) RV16.2 CV32.2 RV15.1 CV31.1
VREFD8_1: length 11.6
  TOP w0.102: v1(216.24,151.71) 216.24,152.31 RV20.1
  TOP w0.508: v2(217.66,155.84) 217.47,156.03 217.04,156.03 RV21.2 CV36.2 CV35.1 RV20.1
  IN1 w0.508: v2(217.66,155.84) 217.67,155.84 218.97,157.14 218.97,157.98 220.07,159.07 221.13,159.07 v2(221.31,158.9)
  BOTTOM w0.254: UV10.A10 v2(221.31,158.9)
VREFD8_2: length 14.1
  BOTTOM w0.254: UV10.U10 234.13,158.88 235.07,158.88 235.14,158.81
  BOTTOM w0.508: RV23.2 RV22.1 CV37.1 CV38.2 v1(237.09,154.05) 235.91,155.23 235.91,158.1 235.2,158.81 235.14,158.81
VSB_N_001: length 162.5
  TOP w0.254: v2(125.79,8.9) 125.79,8.41 PR17.2 126.17,8.03 PC6.2 PQ3.2
  IN4 w0.254: v2(125.79,8.9) 125.78,8.89 124.54,8.89 123.63,9.8 123.63,14.01 118.59,19.06 118.59,32.47 116.95,34.11 116.95,45.41 117.53,45.99 117.53,56.22 117.12,56.64 117.12,69.57 117.53,69.99 117.53,84.37 115.64,86.27 115.64,91.12 109.84,96.92 109.84,119.84 110.94,120.94 110.94,139.09 107.4,142.64 107.4,150.77 105.53,152.64 105.53,153.9 105.92,154.28 v2(106.03,154.28)
  BOTTOM w0.102: v2(106.03,154.28) v1(106.83,154.28)
  BOTTOM w0.254: v2(106.03,154.28) 105.13,154.28 PR19.2
VSB_N_002: length 5.8
  TOP w0.102: PQ5.2 127.73,8.57 v1(127.44,8.86)
  TOP w0.254: PQ5.2 127.73,5.54 PR24.2 PR21.2 PC15.1
VSB_N_003: length 161.8
  TOP w0.102: v2(128.51,9.36) v1(128.51,10.05)
  TOP w0.254: PQ5.1 128.38,9.23 v2(128.51,9.36)
  IN4 w0.254: v2(106.02,153.7) 106.02,152.76 107.84,150.93 107.84,142.73 111.39,139.19 111.39,120.79 110.22,119.62 110.22,97.17 116.09,91.3 116.09,86.36 117.98,84.47 117.98,69.89 117.5,69.41 117.5,57.02 117.98,56.54 117.98,45.81 117.39,45.22 117.39,34.29 119.03,32.65 119.03,19.15 124.06,14.12 124.06,9.91 124.56,9.41 128.46,9.41 v2(128.51,9.36)
  BOTTOM w0.254: PR19.1 104.8,153.7 v2(106.02,153.7)
VSET_5075: length 9.2
  TOP w0.102: U51.A17 291.22,119.69 291.5,119.98 v2(291.5,120.09) ; v1(293.48,124.37) 293.01,124.84 v2(292.08,124.84) C284.1 R407.1
  IN4 w0.102: v2(292.08,124.84) 291.33,124.09 291.33,120.26 v2(291.5,120.09)
VSUM+_VGA: length 22.3
  TOP w0.254: v4(303.13,153.43) 304.06,153.43 v1(304.29,153.66) 304.82,154.19 v4(305.29,154.19) 307.59,154.19 308.1,154.7 309.23,154.7 309.35,154.83 v2(309.35,155.6) 310.43,154.52 PR648.1 PC627.1 311.64,155.21 v4(311.51,155.33)
  BOTTOM w0.203: 310.02,157.21 310.02,158.12 310.47,158.57 310.47,159.23 310.54,159.3 310.54,159.65 310.44,159.74 PU600.15
  BOTTOM w0.254: v4(305.29,154.19) 305.67,154.19 306.18,153.68 PR619.2 ; 310.02,157.21 309.93,157.11 309.93,156.17 v2(309.35,155.6) 309.35,154.89 PC626.1 309.72,154.52 PR648.1 ; v4(311.51,155.33) 311.7,155.14 PR647.1 ; v4(303.13,153.43) PR651.2
VSUM-_VGA: length 58.9
  TOP w0.254: v4(305.29,153.56) 305.34,153.5 v1(307.32,153.5) v2(308.55,153.5) ; PC627.2 311.84,153.61 v4(312.53,152.92)
  IN2 w0.254: v4(310.62,156.1) 311.29,156.76 314.03,156.76 v4(314.18,156.6) 314.18,156.01 311.68,153.5 v2(308.55,153.5)
  BOTTOM w0.254: PH601.2 288.37,146.72 288.37,145.81 289.47,144.72 302.54,144.72 305.75,147.93 309.15,147.93 311.03,149.81 311.03,152.51 311.44,152.92 v4(312.53,152.92) ; v4(312.53,152.92) 312.45,152.84 PC632.1 ; v4(312.53,152.92) 312.92,152.92 313.58,153.58 313.58,155.37 314.18,155.97 v4(314.18,156.6) 313.88,156.91 PC616.2 ; v4(312.53,152.92) 312.59,152.98 PC615.2 ; v2(308.55,153.5) 308.21,153.16 PR624.2 308.86,152.74 PC626.2 310.38,153.36 PR655.2 ; PR654.2 305.16,153.43 v4(305.29,153.56) ; PR659.2 v4(310.62,156.1)
VSYNC: length 3.5
  TOP w0.089: v1(217.09,75.64) 217.58,75.15 RH95.2 218.14,75.27 218.14,76.19 v2(218.12,76.21)
  BOTTOM w0.089: UH1.N44 217.16,75.87 217.5,76.21 v2(218.12,76.21)
VSYNC_BUF: length 170.8
  TOP w0.102: v2(58.02,201.31) 58,201.33 JBTB1.3 ; v2(186.22,178.37) 186.22,177.99 186.7,177.51 186.7,175.95 185.86,175.11 U6.18
  IN2 w0.127: v2(58.02,201.31) 60.31,199.02 60.31,185.63 63.31,182.63 65.76,182.63 72.87,175.51 81.65,175.51 86.15,171.02 86.61,171.02 92.04,165.58 101.18,165.58 102.15,166.55 107.06,166.55 107.77,167.26 119.1,167.26 119.9,166.46 137.22,166.46 138.92,168.16 143.98,168.16 144.18,168.36 148.43,168.36 149.93,169.86 155.43,169.86 156.21,170.64 157.76,170.64 158.6,171.48 164.21,171.48 170.3,177.56 170.3,178.23 169.82,178.71 169.82,179.12 170.48,179.78 170.99,179.78 172.07,180.86 177.91,180.86 179.3,182.25 180.96,182.25 181.67,181.55 184.64,181.55 186.18,180.01 186.18,179.26 186.29,179.15 186.29,178.45 v2(186.22,178.37)
  BOTTOM w0.102: v2(58.02,201.31) v1(58.02,202.07)
VSYNC_DOCK: length 8.5
  TOP w0.102: v2(186.89,175.44) 186.72,175.44 186.26,174.97 U6.17
  BOTTOM w0.102: v2(186.89,175.44) 186.7,175.44 186.51,175.63 185.67,175.63 v1(184.58,176.72) 184.11,177.19 184.11,179.22 184.75,179.86 JDOCK1.67
WCKA0_0: length 24.4
  TOP w0.102: v2(189.85,122.7) 189.91,122.76 189.91,123.14 189.81,123.24 189.59,123.24 UV5.P4
  BOTTOM w0.102: UV5.P4 v2(189.85,122.7) ; 207.12,120.47 207.86,121.21 207.86,121.53 208.23,121.89 208.62,121.89 208.73,122.01 208.73,122.11 UV1.A32
  BOTTOM w0.127: 207.12,120.47 206.27,119.62 v4(205.02,119.62) 191.25,119.62 189.68,121.18 189.68,122.05 189.74,122.1 189.85,122.1 189.91,122.16 189.91,122.63 v2(189.85,122.7)
WCKA0_1: length 20.7
  TOP w0.102: v2(197.05,122.7) UV5.D4
  IN4 w0.114: v2(210.69,128.83) 210.49,129.03 210.23,129.03 210.03,128.83 210.03,128.17 208.89,127.03 208.89,125.58 208.61,125.3 207.41,125.3 205.88,123.77 202.65,123.77 200.63,121.75 197.79,121.75 197.21,122.33 197.21,122.53 v2(197.05,122.7)
  BOTTOM w0.102: v2(210.69,128.83) 210.6,128.83 210.03,129.4 UV1.D23 ; v2(197.05,122.7) UV5.D4
WCKA0B_0: length 24.5
  TOP w0.102: v2(189.04,122.64) 189.38,122.3 UV5.P5
  BOTTOM w0.102: UV5.P5 189.11,122.64 v2(189.04,122.64) ; UV1.C32 209.26,122.2 208.76,121.69 208.36,121.69 208.1,121.43 208.1,121.11 207.12,120.13
  BOTTOM w0.127: 207.12,120.13 206.34,119.35 v4(201.98,119.35) 191.13,119.35 189.42,121.07 189.42,122.17 189.45,122.21 189.45,122.29 UV5.P5
WCKA0B_1: length 20.5
  TOP w0.102: v2(197.85,122.7) UV5.D5
  IN4 w0.114: v2(197.85,122.7) 197.54,122.7 197.42,122.57 197.42,122.42 197.88,121.96 200.55,121.96 202.56,123.98 205.8,123.98 207.32,125.5 208.52,125.5 208.68,125.66 208.68,127.11 209.83,128.26 209.83,128.91 210.15,129.23 210.52,129.23 210.64,129.35 v2(210.64,129.6)
  BOTTOM w0.102: v2(197.85,122.7) UV5.D5 ; v2(210.64,129.6) 210.25,129.99 UV1.E22
WCKA1_0: length 15.4
  TOP w0.102: v2(197.05,136.9) UV3.P4
  IN4 w0.114: v2(205.95,136.69) 205.7,136.94 200.82,136.94 199.6,138.16 198.21,138.16 198,137.95 198,137.65 197.43,137.08 197.23,137.08 v2(197.05,136.9)
  BOTTOM w0.102: UV1.C14 209.27,136.6 209.01,136.33 208.94,136.33 208.87,136.27 208.5,136.27 208.31,136.46 207.59,136.46 207.35,136.22 207.12,136.22 ; v2(197.05,136.9) UV3.P4
  BOTTOM w0.127: 207.12,136.22 206.4,136.22 205.95,136.66 v2(205.95,136.69)
WCKA1_1: length 24.8
  TOP w0.102: UV3.D4 189.45,136.87 189.57,136.99 189.75,136.99 v2(189.85,136.9)
  BOTTOM w0.102: UV3.D4 189.84,136.88 ; 189.85,136.89 v2(189.85,136.9) ; UV1.E10 210.01,139.8 209.7,140.11 209.33,140.11 209.28,140.05 208.83,140.05 208.77,140.11 208.52,140.11 208.44,140.03 207.83,140.03 207.53,140.33 207.12,140.33
  BOTTOM w0.127: 189.84,136.88 189.85,136.89 189.85,138.5 190.42,139.06 200.48,139.06 v4(201.52,140.1) 202.07,140.65 203.36,140.65 203.59,140.42 205.71,140.42 205.8,140.33 207.12,140.33
WCKA1B_0: length 14.8
  TOP w0.102: v2(197.05,137.7) UV3.P5
  IN4 w0.114: v2(197.05,137.7) 196.88,137.53 196.88,137.36 196.96,137.28 197.35,137.28 197.8,137.73 197.8,138.04 198.13,138.37 199.69,138.37 200.91,137.15 206.18,137.15 206.54,136.79 v2(206.54,136.68)
  BOTTOM w0.102: 207.12,136.6 207.38,136.6 207.49,136.7 208.54,136.7 UV1.A14 ; v2(197.05,137.7) UV3.P5
  BOTTOM w0.127: v2(206.54,136.68) 206.62,136.6 207.12,136.6
WCKA1B_1: length 24.3
  TOP w0.102: v2(189.05,136.9) UV3.D5
  BOTTOM w0.102: UV3.D5 v2(189.05,136.9) ; UV1.D9 209.85,140.42 209.77,140.35 209.23,140.35 209.18,140.29 208.93,140.29 208.9,140.32 208.39,140.32 208.32,140.25 207.96,140.25 207.63,140.58 207.24,140.58 207.23,140.59 207.15,140.59 207.13,140.6 207.12,140.6
  BOTTOM w0.127: UV3.D5 189.58,137.43 189.58,138.61 190.31,139.33 200.37,139.33 201.96,140.92 v4(203.11,140.92) 203.47,140.92 203.7,140.69 205.82,140.69 205.91,140.6 207.12,140.6
WCKB0_0: length 28.2
  TOP w0.102: UV7.P4 202.31,164.05 v2(201.9,163.64)
  IN4 w0.102: 203.64,154.57 203.54,154.67 203.54,158.62 202.83,159.33 202.7,159.33 202.08,159.96 202.08,163.46 v2(201.9,163.64)
  IN4 w0.114: 203.64,154.57 203.73,154.48 203.73,150.84 206.86,147.71 209.26,147.71 210.46,146.51 210.46,145.98 211.06,145.38 212.54,145.38 212.75,145.59 213.34,145.59 v2(213.36,145.58)
  BOTTOM w0.102: UV1.H3 212.85,145.16 213.27,145.58 v2(213.36,145.58) ; UV7.P4 202.31,164.05 v2(201.9,163.64)
WCKB0_1: length 27.5
  TOP w0.102: UV7.D4 v2(210.71,163.7)
  TOP w0.127: v2(219.57,144.4) 219.43,144.26 219.42,144.26 219.18,144.02 219.03,144.02 218.56,144.49 217.32,144.49 215.87,145.94 215.87,150.14 215.14,150.87 215,151 213.8,152.2 213.8,153.3 213.47,153.63 213.47,155.33 213.8,155.67 213.8,158.06 213.47,158.39 213.47,159.76 212.77,160.46 211.36,160.46 210.73,161.1 210.73,163.25 210.71,163.27 v2(210.71,163.7)
  BOTTOM w0.102: v2(210.71,163.7) 210.71,164.01 210.63,164.1 UV7.D4 ; UV1.T3 219.25,144.71 219.57,144.4 v2(219.57,144.4)
WCKB0B_0: length 27.5
  TOP w0.102: UV7.P5 v2(202.71,163.7)
  IN4 w0.102: v2(202.71,163.7) 202.44,163.7 202.27,163.52 202.27,160.04 202.78,159.52 202.91,159.52 203.73,158.7 203.73,154.78 203.94,154.57
  IN4 w0.114: v2(213.06,146.1) 212.76,145.8 212.67,145.8 212.45,145.58 211.15,145.58 210.66,146.06 210.66,146.59 209.34,147.91 206.95,147.91 203.94,150.92 203.94,154.57
  BOTTOM w0.102: v2(213.06,146.1) 212.85,145.88 212.85,145.6 UV1.H1 ; UV7.P5 v2(202.71,163.7)
WCKB0B_1: length 27.7
  TOP w0.102: v2(209.91,163.7) UV7.D5
  TOP w0.127: UV7.D5 210.46,163.14 210.46,160.97 211.23,160.2 212.66,160.2 213.2,159.65 213.2,158.28 213.54,157.95 213.54,155.78 213.2,155.44 213.2,153.52 213.54,153.19 213.54,152.09 215.6,150.02 v4(215.6,149.42) 215.6,145.82 217.21,144.22 218.45,144.22 218.92,143.75 219.29,143.75 219.51,143.98 219.7,143.98 v2(219.82,143.87)
  BOTTOM w0.102: UV7.D5 v2(209.91,163.7) ; UV1.T5 219.7,144 219.82,143.88 219.82,143.87 v2(219.82,143.87)
WCKB1_0: length 36.6
  TOP w0.102: v2(223.3,162.73) 222.99,163.04 222.99,163.77 223.31,164.09 UV9.P4
  TOP w0.127: v2(223.3,162.73) 223.54,162.73 223.68,162.59 223.68,162.47 223.23,162.01 220.55,162.01 218.84,160.3 218.84,159.03 218.55,158.73 218.55,155.51 217.8,154.76 217.8,152.55 216.9,151.64 216.9,146.17 217.2,145.86 217.2,145.57 217.78,145 220.32,145 220.96,144.35 221.49,144.35 221.83,144.02 224.03,144.02 224.37,144.35 226.04,144.35 226.31,144.08 226.31,143.64 v2(226.3,143.62)
  BOTTOM w0.102: UV1.AE4 226.45,143.78 v2(226.3,143.62) ; v2(223.3,162.73) 222.91,163.12 222.91,163.7 223.3,164.1 UV9.P4
WCKB1_1: length 25.6
  TOP w0.102: v2(230.91,163.7) UV9.D4
  IN4 w0.114: v2(229.46,148.48) 229.64,148.65 229.85,148.65 230.08,148.88 230.08,149.56 229.77,149.87 229.77,151.2 230.11,151.54 230.11,153.08 229.77,153.42 229.77,155.36 228.91,156.21 228.91,159.85 231.63,162.56 231.63,163.24 231.36,163.51 231.1,163.51 230.91,163.7 v2(230.91,163.7)
  BOTTOM w0.102: UV1.AK6 230.62,143.2 230.15,143.67 230.15,144.07 230.02,144.2 230.02,144.45 229.9,144.57 229.9,145.02 230.02,145.14 230.02,145.25 229.9,145.37 229.9,145.82 230.21,146.13 230.21,146.86 ; v2(230.91,163.7) UV9.D4
  BOTTOM w0.127: v2(229.46,148.48) 229.59,148.6 229.81,148.6 230.21,148.21 230.21,146.86
WCKB1B_0: length 35.2
  TOP w0.102: v2(223.71,163.7) 223.41,163.7 223.31,163.6 UV9.P5
  TOP w0.127: v2(226.93,143.6) 226.58,143.95 226.58,144.19 226.15,144.62 224.26,144.62 223.92,144.28 221.94,144.28 221.6,144.62 221.07,144.62 220.43,145.26 217.89,145.26 217.47,145.68 217.47,145.97 217.16,146.28 v4(217.16,148.42) 217.16,151.53 218.07,152.44 218.07,154.65 218.82,155.4 218.82,158.62 219.11,158.91 219.11,160.19 220.67,161.75 223.34,161.75 223.95,162.36 223.95,162.7 223.71,162.94 v2(223.71,163.7)
  BOTTOM w0.102: v2(223.71,163.7) 223.31,163.31 UV9.P5 ; v2(226.93,143.6) 227.25,143.92 UV1.AF5
WCKB1B_1: length 25
  TOP w0.102: UV9.D5 231.31,163.29 v2(230.88,162.86)
  IN4 w0.114: v2(229.46,149.06) 229.66,148.86 229.77,148.86 229.88,148.97 229.88,149.47 229.56,149.79 229.56,151.28 229.91,151.63 229.91,152.99 229.56,153.34 229.56,155.27 228.71,156.13 228.71,159.93 231.43,162.65 231.43,163.16 231.28,163.31 230.86,163.31 230.77,163.22 230.77,162.98 v2(230.88,162.86)
  BOTTOM w0.102: 230.48,146.86 230.48,146.85 230.46,146.83 230.46,146.75 230.45,146.74 230.45,146.03 230.15,145.72 230.15,145.47 230.26,145.36 230.26,145.04 230.15,144.92 230.15,144.67 230.26,144.55 230.26,144.3 230.45,144.11 UV1.AK5 ; v2(230.88,162.86) 231.31,163.29 UV9.D5
  BOTTOM w0.127: 230.48,146.86 230.48,148.32 229.93,148.87 229.65,148.87 v2(229.46,149.06)
WEA0#: length 31.4
  TOP w0.102: v2(214.08,127.55) 214.08,127.84 v1(214.4,128.16) ; v2(194.65,117.1) UV5.G12
  IN4 w0.127: v2(194.65,117.1) 194.65,118.45 195.37,119.18 198.9,119.18 199.68,118.4 202.69,118.4 202.82,118.53 202.82,118.68 202.94,118.81 203.22,118.81 203.35,118.68 203.35,118.53 203.48,118.4 203.72,118.4 203.84,118.53 203.84,118.8 203.97,118.92 204.23,118.92 204.36,118.8 204.36,118.53 204.48,118.4 206.54,118.4 207.16,119.02 207.96,119.02 209.93,120.99 209.93,123.89 210.86,124.82 210.86,125.1 211.58,125.83 213.3,125.83 214.08,126.61 v2(214.08,127.55)
  BOTTOM w0.102: UV1.K26 214.25,127.38 v2(214.08,127.55) ; v2(194.65,117.1) UV5.G12
WEA1#: length 30.1
  TOP w0.102: v2(192.25,142.5) UV3.G12
  IN4 w0.102: v2(213.84,136.15) 213.63,135.94 213.63,135.82 213.35,135.53 209.04,135.53 208.9,135.67 208.9,135.97 208.39,136.47 207.62,136.47 207.19,136.05
  IN4 w0.127: 207.19,136.05 205.16,136.05 204.9,136.32 200.98,136.32 200.36,135.7 197.69,135.7 197.44,135.94 197.44,136.26 197.21,136.49 196.9,136.49 196.66,136.73 196.66,136.75 196.64,136.76 196.64,137.86 195.16,139.35 194.53,139.35 193.26,140.62 193.26,140.94 193.44,141.13 193.44,141.86 193.21,142.09 192.66,142.09 v2(192.25,142.5)
  BOTTOM w0.102: v2(213.84,136.15) 213.86,136.15 213.86,136.13 213.96,136.22 215.02,136.22 UV1.L15 ; v2(192.25,142.5) UV3.G12
