# Allegro board LA-9411P R10-0403.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
DDR_A_BS2: length 67.2
  IN4 w0.089: 149.17,77.36 149.17,79.11 149.73,79.67 v2(149.73,79.92)
  IN4 w0.165: v2(145.76,42.08) 146.13,42.08 146.25,41.95 146.25,41.05 146.13,40.92 145.95,40.92 145.82,40.79 145.82,40.35 145.95,40.22 146.13,40.22 146.25,40.09 146.25,39.7 146.13,39.57 145.94,39.57 145.82,39.45 145.82,38.95 145.94,38.82 146.11,38.82 146.24,38.7 146.24,38.37 146.05,38.18 145.37,38.18 145.15,38.4 145.15,44.1 144.59,44.66 144.59,57.08 146.05,58.53 146.05,59 146.22,59.18 147.72,59.18 147.82,59.29 147.82,59.75 147.72,59.85 146.15,59.85 146.05,59.96 146.05,60.41 146.15,60.52 147.72,60.52 147.82,60.62 147.82,61.1 147.72,61.2 146.15,61.2 146.05,61.3 146.05,61.86 146.15,61.96 148.12,61.96 148.22,62.06 148.22,66.06 147.82,66.46 147.82,68.87 148.4,69.45 148.4,71.05 147.82,71.63 147.82,75.81 149.17,77.16 149.17,77.36
  BOTTOM w0.089: JCPU1.AD1 149.26,79.45 v2(149.73,79.92)
  BOTTOM w0.165: v2(145.76,42.08) 145.76,42.31 145.86,42.41 147.01,42.41 147.11,42.31 147.11,41.63 147.01,41.53 146.54,41.53 146.44,41.43 146.44,40.78 146.54,40.68 148.6,40.68 148.7,40.58 JDIMM1.79
DDR_A_CAS#: length 63.9
  IN4 w0.089: 160.13,78.62 160.13,85.21 159.86,85.49 157.6,85.49 157.17,85.92 v2(156.73,85.92)
  IN4 w0.152: 160.13,78.62 160.13,77.36
  IN4 w0.165: 160.13,77.36 160.13,63.25 160.94,62.44 160.94,57.59 161.63,56.9 161.63,56.21 162.13,55.71 162.13,53.23 162.03,53.13 161.08,53.13 160.96,53 160.96,42.34 160.98,42.32 160.98,41.08 160.85,40.95 160.68,40.95 160.55,40.82 160.55,40.39 160.65,40.28 160.98,40.28 161.13,40.13 161.13,38.15 161.01,38.02 160.52,38.02 160.4,38.15 160.4,39.5 160.29,39.6 160.04,39.6 159.94,39.7 159.94,41.96 159.75,42.15 159.75,42.4 159.87,42.52 160.09,42.52 160.4,42.21 v2(160.4,42.08)
  BOTTOM w0.089: v2(156.73,85.92) JCPU1.U8
  BOTTOM w0.165: v2(160.4,42.08) 159.75,41.43 159.75,40.25 159.5,40.01 JDIMM1.115
DDR_A_D0: length 74.7
  IN4 w0.097: 136,92.38 137.52,92.38 137.73,92.59 v2(137.73,92.92)
  IN4 w0.102: v2(123.64,41.31) 123.6,41.28 123.6,37.91 123.34,37.65 123.34,37.19 123.21,37.06 123.02,37.06 122.89,37.19 122.89,45.07 126.31,48.49 126.31,71.52 123.53,74.3 123.53,79.52 124.01,80.01 124.01,80.15 123.88,80.28 123.88,80.42 124.2,80.73 124.34,80.73 124.53,80.54 124.68,80.54 124.89,80.76 124.89,80.9 124.7,81.09 124.7,81.24 125.06,81.6 125.2,81.6 125.4,81.4 125.54,81.4 125.76,81.62 125.76,81.76 125.56,81.96 125.56,82.1 135.84,92.38 136,92.38
  BOTTOM w0.089: JCPU1.AR15 138.2,93.39 v2(137.73,92.92)
  BOTTOM w0.102: JDIMM1.5 124.1,40.86 v2(123.64,41.31)
DDR_A_D1: length 74.2
  IN4 w0.089: 136,91.92 v2(136.73,91.92)
  IN4 w0.102: 136,91.92 135.81,91.92 128.47,84.58 128.47,84.43 128.66,84.24 128.66,84.09 128.45,83.88 128.3,83.88 128.11,84.07 127.96,84.07 127.75,83.86 127.75,83.71 127.94,83.52 127.94,83.37 127.73,83.16 127.59,83.16 127.39,83.35 127.25,83.35 126.89,82.99 126.89,82.85 127.08,82.66 127.08,82.51 126.87,82.3 126.72,82.3 126.53,82.49 126.38,82.49 126.17,82.28 126.17,82.13 126.36,81.94 126.36,81.79 123.83,79.26 123.83,74.43 126.61,71.65 126.61,69.71 126.74,69.58 128.42,69.58 128.54,69.46 128.54,69.19 128.42,69.06 128.23,69.06 128.1,68.94 128.1,68.68 127.97,68.55 127.76,68.55 127.63,68.68 127.63,68.94 127.5,69.06 126.74,69.06 126.61,68.94 126.61,68.59 126.72,68.48 127.1,68.48 127.2,68.38 127.2,68.08 127.1,67.98 126.72,67.98 126.61,67.87 126.61,48.28 126.4,48.06 126.4,47.93 126.61,47.71 126.61,47.59 126.25,47.23 126.11,47.23 125.87,47.47 125.73,47.47 125.51,47.26 125.51,47.11 125.75,46.87 125.75,46.73 125.54,46.51 125.39,46.51 125.15,46.75 125.01,46.75 124.79,46.54 124.79,46.39 125.03,46.15 125.03,46.01 124.82,45.79 124.67,45.79 124.43,46.03 124.29,46.03 124.07,45.82 124.07,45.68 124.31,45.43 124.31,45.29 124.1,45.07 123.96,45.07 123.71,45.32 123.57,45.32 123.35,45.1 123.35,44.96 123.6,44.71 123.6,44.57 123.21,44.19 123.21,42.77 123.34,42.65 123.45,42.65 v2(123.64,42.84)
  BOTTOM w0.089: JCPU1.AT14 137.2,92.39 v2(136.73,91.92)
  BOTTOM w0.102: v2(123.64,42.84) 124.7,41.78 JDIMM1.7
DDR_A_D2: length 79.3
  IN4 w0.089: v2(140.73,91.92) 140.22,91.4 139.6,91.4 139.32,91.13 139.32,90.67 138.98,90.33 138.52,90.33 138.32,90.13 138.32,89.67 137.97,89.32 136.3,89.32 136,89.02
  IN4 w0.102: v2(125.68,41.31) 125.68,38.25 125.8,38.13 127.4,38.13 127.52,38.25 127.52,39.15 127.4,39.28 126.37,39.28 126.25,39.41 126.25,40.7 126.37,40.83 126.51,40.83 126.64,40.96 126.64,41.38 126.51,41.5 126.21,41.5 126.08,41.63 126.08,42.09 126.21,42.21 126.51,42.21 126.64,42.34 126.64,44.55 128.82,46.73 128.82,66.36 131.54,69.08 131.54,73.42 131.44,73.52 127.78,73.52 125.98,75.32 125.98,78.27 129.47,81.76 130.13,81.76 131.54,83.17 131.54,83.58 135.75,87.79 135.75,88.78 136,89.02
  BOTTOM w0.089: JCPU1.AM14 141.2,92.39 v2(140.73,91.92)
  BOTTOM w0.102: JDIMM1.15 127.1,40.47 126.26,41.31 v2(125.68,41.31)
DDR_A_D3: length 78.4
  IN4 w0.089: v2(139.73,91.92) 139.73,91.65 139.68,91.6 139.53,91.6 139.13,91.21 139.13,90.75 138.9,90.52 138.44,90.52 138.13,90.21 138.13,89.75 137.89,89.51 136.06,89.51 136,89.45
  IN4 w0.102: 136,89.45 134.81,88.27 134.81,88.13 135.16,87.78 135.16,87.63 134.95,87.42 134.8,87.42 134.45,87.77 134.31,87.77 134.1,87.55 134.1,87.41 134.44,87.06 134.44,86.91 134.23,86.7 134.09,86.7 133.74,87.05 133.59,87.05 133.38,86.83 133.38,86.69 133.73,86.34 133.73,86.2 133.51,85.98 133.37,85.98 133.13,86.21 132.96,86.21 132.78,86.03 132.78,85.85 133.01,85.62 133.01,85.48 131.3,83.77 130.95,83.77 125.67,78.5 125.67,75.2 127.65,73.22 128,73.22 128.13,73.09 128.13,72.86 128.25,72.73 128.56,72.73 128.68,72.86 128.68,73.09 128.81,73.22 129.12,73.22 129.22,73.12 129.22,71.6 129.32,71.5 129.62,71.5 129.73,71.6 129.73,73.12 129.83,73.22 131.11,73.22 131.24,73.09 131.24,72.75 131.11,72.62 130.36,72.62 130.23,72.49 130.23,72.16 130.36,72.03 131.11,72.03 131.24,71.91 131.24,69.21 128.52,66.49 128.52,46.85 126.16,44.5 126.16,42.59 126.03,42.46 125.8,42.46 125.68,42.59 v2(125.68,42.84)
  BOTTOM w0.089: v2(139.73,91.92) 140.2,92.39 JCPU1.AN14
  BOTTOM w0.102: JDIMM1.17 127.7,40.33 127.36,40.67 127.36,41.22 125.75,42.84 v2(125.68,42.84)
DDR_A_D4: length 74
  IN4 w0.089: v2(136.73,92.92) 136,92.92
  IN4 w0.102: 136,92.92 135.95,92.92 124.97,81.94 123.22,80.19 123.22,74.18 126.01,71.39 126.01,48.61 122.56,45.17 122.56,36.92 122.69,36.79 122.86,36.79 122.98,36.66 122.98,36.35 122.86,36.22 122.69,36.22 122.56,36.09 122.56,35.78 122.69,35.65 122.84,35.65 122.97,35.52 122.97,35.23 122.84,35.1 122.69,35.1 122.56,34.98 122.56,34.7 122.69,34.57 123.45,34.57 v2(123.52,34.64)
  BOTTOM w0.089: JCPU1.AT15 137.2,93.39 v2(136.73,92.92)
  BOTTOM w0.102: v2(123.52,34.64) 123.01,34.13 123.01,32.69 123.8,31.9 JDIMM1.4
DDR_A_D5: length 75.7
  IN4 w0.097: 136,93.36 137.86,93.36 138.14,93.08 138.14,92.72 137.73,92.31 v2(137.73,91.92)
  IN4 w0.102: 136,93.36 135.96,93.36 124.75,82.15 122.92,80.32 122.92,74.05 125.7,71.27 125.7,48.78 122.25,45.33 122.25,34.38 v2(123.52,33.11)
  BOTTOM w0.089: v2(137.73,91.92) 138.2,92.39 JCPU1.AR14
  BOTTOM w0.102: JDIMM1.6 124.4,32.23 v2(123.52,33.11)
DDR_A_D6: length 78.2
  IN4 w0.089: 136,90.36 136.15,90.51 137.89,90.51 138.13,90.75 138.13,91.21 138.44,91.52 138.9,91.52 139.13,91.75 139.13,92.32 v2(139.73,92.92)
  IN4 w0.102: v2(126.31,33.11) 125.63,33.11 125.5,33.24 125.5,33.52 125.63,33.64 125.75,33.64 125.88,33.77 125.88,34.2 125.75,34.33 125.59,34.33 125.5,34.41 125.5,37.57 124.91,38.15 124.91,44.15 127.85,47.08 127.85,66.68 130.63,69.46 130.63,70.69 130.5,70.81 127.97,70.81 127.85,70.94 127.85,72.16 125.06,74.94 125.06,78.75 130.63,84.31 130.63,84.99 136,90.36
  BOTTOM w0.089: JCPU1.AN15 140.2,93.39 v2(139.73,92.92)
  BOTTOM w0.102: v2(126.31,33.11) 127.4,32.02 JDIMM1.16
DDR_A_D7: length 79.1
  IN4 w0.089: 136,89.89 136.43,90.32 137.97,90.32 138.32,90.67 138.32,91.14 138.52,91.33 138.98,91.33 139.32,91.67 139.32,92.18 139.53,92.39 140.2,92.39 v2(140.73,92.92)
  IN4 w0.102: v2(126.31,34.64) 125.83,35.12 125.83,37.67 125.24,38.25 125.24,44.04 128.15,46.95 128.15,66.55 130.93,69.33 130.93,71 130.81,71.12 128.25,71.12 128.15,71.22 128.15,71.6 128.28,71.73 128.7,71.73 128.82,71.86 128.82,72.16 128.7,72.28 128.15,72.28 125.37,75.07 125.37,78.62 130.93,84.19 130.93,84.82 136,89.89
  BOTTOM w0.089: JCPU1.AM15 141.2,93.39 v2(140.73,92.92)
  BOTTOM w0.102: v2(126.31,34.64) 128,32.95 JDIMM1.18
DDR_A_D8: length 66.7
  IN4 w0.089: v2(140.73,86.92) 140.73,86.92 140.36,86.55 139.83,86.55 139.36,86.08 139.36,85.73 138.92,85.29 138.58,85.29 138.35,85.07 138.35,84.66 138.01,84.32 136.49,84.32 136,83.83
  IN4 w0.102: 136,83.83 134.62,82.44 134.62,64.1 133.43,62.92 133.43,62.51 133.31,62.38 132.88,62.38 132.75,62.26 132.75,62 132.88,61.88 133.13,61.88 133.26,61.75 133.26,61.5 133.13,61.37 131.92,61.37 131.82,61.27 131.82,60.96 131.92,60.86 133.13,60.86 133.26,60.73 133.26,60.48 133.13,60.35 131.92,60.35 131.82,60.25 131.82,59.95 131.92,59.84 132.29,59.84 132.39,59.74 132.39,59.44 132.29,59.34 131.92,59.34 131.82,59.24 131.82,44.86 130.7,43.74 130.7,38.69 131.68,37.72 131.68,36.71 v2(131.14,36.16)
  BOTTOM w0.089: v2(140.73,86.92) 141.2,87.39 JCPU1.AM9
  BOTTOM w0.102: JDIMM1.21 128.9,38.1 129.26,37.74 129.26,37.72 130.82,36.16 v2(131.14,36.16)
DDR_A_D9: length 66.3
  IN4 w0.089: 136,84.26 136.26,84.52 137.86,84.52 138.16,84.81 138.16,85.23 138.47,85.55 138.89,85.55 139.17,85.82 139.17,86.22 139.3,86.35 139.3,86.48 v2(139.73,86.92)
  IN4 w0.102: 136,84.26 134.31,82.57 134.31,64.25 131.52,61.46 131.52,44.99 130.4,43.87 130.4,42.42 130.3,42.32 129.78,42.32 129.68,42.22 129.68,41.92 129.78,41.81 130.3,41.81 130.4,41.71 130.4,41.41 130.3,41.31 129.12,41.31 128.99,41.18 128.99,40.92 129.12,40.8 130.3,40.8 130.4,40.7 130.4,40.19 130.3,40.09 129.47,40.09 129.35,39.96 129.35,39.71 129.47,39.58 130.3,39.58 130.4,39.48 130.4,39.17 130.3,39.07 129.55,39.07 129.45,38.97 129.45,38.66 129.55,38.56 130.3,38.56 130.4,38.46 130.4,37.44 130.53,37.31 131.01,37.31 131.14,37.44 v2(131.14,37.69)
  BOTTOM w0.089: v2(139.73,86.92) 140.2,87.39 JCPU1.AN9
  BOTTOM w0.102: v2(131.14,37.69) 131.13,37.69 130.12,37.69 129.5,38.31 JDIMM1.23
DDR_A_D10: length 64.8
  IN4 w0.089: 137.57,83.32 137.3,83.06 137.3,82.6 137.16,82.46 136.32,82.46 136.14,82.28 136.14,81.84 136,81.7
  IN4 w0.097: 137.57,83.32 137.94,83.32 138.35,83.73 138.35,84.09 138.61,84.35 139.04,84.35 139.32,84.63 139.32,85.07 139.58,85.34 139.95,85.34 140.54,85.92 v2(140.73,85.92)
  IN4 w0.102: 136,81.7 135.62,81.32 135.62,80.84 135.23,80.44 135.23,63.84 134.2,62.82 134.2,62.41 133.87,62.08 133.87,55.21 132.47,53.81 132.47,44.6 131.92,44.06 131.92,39.36 132.05,39.23 132.68,39.23 132.81,39.1 132.81,36.74 132.68,36.61 132.29,36.61 132.16,36.74 132.16,38.47 132.04,38.6 131.48,38.6 131.35,38.72 131.35,41.19 131.22,41.31 v2(131.14,41.31)
  BOTTOM w0.089: v2(140.73,85.92) 141.2,86.39 JCPU1.AM8
  BOTTOM w0.102: v2(131.14,41.31) 131.73,41.31 132.5,40.55 JDIMM1.33
DDR_A_D11: length 65.1
  IN4 w0.089: 136,82.94 136.35,83.29 137.24,83.29 137.49,83.55 137.89,83.55 138.16,83.81 138.16,84.17 138.54,84.55 138.57,84.55 138.58,84.55 138.89,84.55 139.11,84.76 139.11,85.16 139.73,85.79 v2(139.73,85.92)
  IN4 w0.102: v2(131.14,42.84) 131.45,42.84 131.54,42.93 131.54,44.11 132.15,44.71 132.15,54.3 132.27,54.43 132.6,54.43 132.72,54.56 132.72,54.85 132.6,54.98 132.27,54.98 132.15,55.11 132.15,55.44 132.27,55.56 132.79,55.56 133.02,55.33 133.43,55.33 133.56,55.46 133.56,56.1 133.46,56.2 132.23,56.2 132.13,56.3 132.13,56.61 132.23,56.71 133.46,56.71 133.56,56.81 133.56,57.11 133.46,57.22 132.23,57.22 132.13,57.32 132.13,57.62 132.23,57.72 133.46,57.72 133.56,57.83 133.56,58.13 133.46,58.23 132.23,58.23 132.13,58.33 132.13,58.64 132.23,58.74 133.46,58.74 133.56,58.84 133.56,59.35 133.46,59.45 132.82,59.45 132.7,59.58 132.7,59.83 132.82,59.96 133.46,59.96 133.56,60.06 133.56,62.21 133.89,62.54 133.89,62.94 134.92,63.97 134.92,80.91 135.05,81.04 135.16,81.04 135.29,81.17 135.29,81.55 135.16,81.67 135.05,81.67 134.92,81.8 134.92,82.18 135.1,82.36 135.77,82.36 135.95,82.54 135.95,82.89 136,82.94
  BOTTOM w0.089: v2(139.73,85.92) 140.2,86.39 JCPU1.AN8
  BOTTOM w0.102: v2(131.14,42.84) 132.44,41.53 132.44,41.03 133.1,40.38 JDIMM1.35
DDR_A_D12: length 64.2
  IN4 w0.089: 136,87.32 137.33,87.32 v2(137.73,86.92)
  IN4 w0.102: 136,87.32 132.13,83.45 132.13,68.95 129.33,66.15 129.33,46.52 127.39,44.58 127.39,40.37 128.07,39.69 128.07,32.96 128.2,32.83 128.72,32.83 128.85,32.96 v2(128.85,33.11)
  BOTTOM w0.089: v2(137.73,86.92) 138.2,87.39 JCPU1.AR9
  BOTTOM w0.102: JDIMM1.22 129.2,32.76 v2(128.85,33.11)
DDR_A_D13: length 63.7
  IN4 w0.089: 136.03,86.92 v2(136.73,86.92)
  IN4 w0.102: v2(128.85,34.64) 128.85,34.61 128.72,34.48 128.52,34.48 128.4,34.61 128.4,36.39 128.52,36.51 129.17,36.51 129.29,36.64 129.29,37.04 129.17,37.17 128.52,37.17 128.4,37.29 128.4,39.8 127.73,40.46 127.73,44.49 129.63,46.39 129.63,66.02 132.43,68.82 132.43,83.32 136.03,86.92
  BOTTOM w0.089: JCPU1.AT9 137.2,87.39 v2(136.73,86.92)
  BOTTOM w0.102: JDIMM1.24 129.8,33.69 v2(128.85,34.64)
DDR_A_D14: length 63.7
  IN4 w0.089: 136,86.37 137.27,86.37 137.72,85.92 v2(137.73,85.92)
  IN4 w0.102: 136,86.37 135.92,86.37 132.74,83.19 132.74,68.69 129.94,65.9 129.94,46.26 128.04,44.36 128.04,40.59 128.74,39.89 128.74,38.27 129.6,37.4 129.6,34.65 v2(131.14,33.11)
  BOTTOM w0.089: JCPU1.AR8 138.2,86.39 v2(137.73,85.92)
  BOTTOM w0.102: v2(131.14,33.11) 131.62,33.11 132.8,31.93 JDIMM1.34
DDR_A_D15: length 63.2
  IN4 w0.089: 136,85.92 v2(136.73,85.92)
  IN4 w0.102: v2(131.14,34.64) 130.08,34.64 129.9,34.82 129.9,37.53 129.04,38.39 129.04,40.02 128.34,40.72 128.34,44.17 130.26,46.09 130.26,65.79 131.67,67.2 132.81,67.2 133.04,67.42 133.04,83.07 135.89,85.92 136,85.92
  BOTTOM w0.089: JCPU1.AT8 136.73,85.98 v2(136.73,85.92)
  BOTTOM w0.102: JDIMM1.36 133.4,32.58 131.35,34.64 v2(131.14,34.64)
DDR_A_D16: length 65
  IN4 w0.089: 137.18,77.36 137.18,80.37 137.35,80.53 137.35,81.1 137.57,81.32 138,81.32 138.33,81.65 138.33,82.1 138.55,82.32 138.99,82.32 139.33,82.66 139.33,83.09 139.57,83.32 139.98,83.32 140.33,83.67 140.33,84.09 140.57,84.32 140.97,84.32 141.33,84.68 141.33,85.09 141.57,85.32 141.97,85.32 142.33,85.68 142.33,86.38 142.48,86.52 142.9,86.52 143.3,86.92 v2(143.73,86.92)
  IN4 w0.102: v2(133.19,41.31) 133.07,41.19 133.07,40.58 133.2,40.45 133.87,40.45 133.99,40.32 133.99,37.88 134.12,37.76 134.46,37.76 134.59,37.88 134.59,40.91 134.46,41.03 134.08,41.03 133.96,41.16 133.96,44.75 134.06,44.85 134.18,44.85 134.28,44.95 134.28,45.25 134.18,45.36 134.06,45.36 133.96,45.46 133.96,45.76 134.06,45.86 134.18,45.86 134.28,45.97 134.28,46.27 134.18,46.37 134.06,46.37 133.96,46.47 133.96,49.96 134.08,50.09 134.54,50.09 134.66,50.21 134.66,51.08 134.78,51.2 135.16,51.2 135.29,51.33 135.29,61.49 135.62,61.82 135.62,62.23 136.65,63.25 136.65,70.77 137.18,71.31 137.18,77.36
  BOTTOM w0.089: v2(143.73,86.92) 144.2,87.39 JCPU1.AJ9
  BOTTOM w0.102: v2(133.19,41.31) 134.3,40.21 JDIMM1.39
DDR_A_D17: length 63.7
  IN4 w0.089: 136.88,77.36 136.88,80.48 137.14,80.74 137.14,81.16 137.49,81.51 137.92,81.51 138.14,81.73 138.14,82.18 138.47,82.51 138.91,82.51 139.14,82.74 139.14,83.16 139.49,83.51 139.9,83.51 140.14,83.75 140.14,84.16 140.49,84.51 140.89,84.51 141.14,84.76 141.14,85.16 141.49,85.51 141.89,85.51 142.14,85.76 142.14,86.79 142.27,86.92 v2(142.73,86.92)
  IN4 w0.102: 136.88,77.36 136.88,74.68 136.77,74.58 136.51,74.58 136.38,74.45 136.38,74.2 136.51,74.07 136.77,74.07 136.88,73.97 136.88,73.67 136.77,73.57 136.44,73.57 136.34,73.46 136.34,73.16 136.44,73.06 136.77,73.06 136.88,72.96 136.88,72.65 136.77,72.55 136.44,72.55 136.34,72.45 136.34,72.14 136.44,72.04 136.77,72.04 136.88,71.94 136.88,71.65 136.8,71.58 136.51,71.58 136.34,71.41 136.34,63.38 135.32,62.35 135.32,61.95 134.98,61.62 134.98,52.7 134.86,52.58 134.45,52.58 134.32,52.7 134.32,53.35 134.2,53.48 133.75,53.48 133.63,53.35 133.63,52.12 133.73,52.02 134.77,52.02 134.9,51.89 134.9,51.64 134.77,51.51 133.73,51.51 133.63,51.41 133.63,51.1 133.73,51 134.17,51 134.27,50.9 134.27,50.59 134.17,50.49 133.73,50.49 133.63,50.39 133.63,42.61 133.5,42.49 133.32,42.49 133.19,42.61 v2(133.19,42.84)
  BOTTOM w0.089: v2(142.73,86.92) 143.2,87.39 JCPU1.AK9
  BOTTOM w0.102: v2(133.19,42.84) 133.89,42.14 133.89,41.44 134.9,40.42 JDIMM1.41
DDR_A_D18: length 62.6
  IN4 w0.089: v2(143.73,83.92) 143.73,83.52 143.61,83.39 142.64,83.39 142.35,83.1 142.35,82.51 142.2,82.36 142.2,81.58 142.07,81.46 141.27,81.46 141.14,81.33 141.14,78.8 140.36,78.01 140.36,77.36
  IN4 w0.102: 140.36,77.36 140.36,72.86 140.05,72.55 140.05,71.14 139.51,70.59 139.51,65.71 138.79,65 138.79,60.76 137.95,59.92 137.95,53.79 137.43,53.28 137.43,41.48 137.33,41.38 137.03,41.38 136.93,41.27 136.93,40.97 137.03,40.87 137.33,40.87 137.43,40.77 137.43,40.46 137.33,40.36 137.03,40.36 136.93,40.26 136.93,40.02 137.05,39.89 137.31,39.89 137.43,39.76 137.43,39.45 137.33,39.34 137.03,39.34 136.93,39.24 136.93,38.94 137.03,38.84 137.33,38.84 137.43,38.73 137.43,38.14 137.31,38.01 136.55,38.01 136.42,38.14 136.42,38.69 136.37,38.75 135.76,38.75 135.63,38.87 135.63,39.19 135.76,39.32 136.37,39.32 136.42,39.37 136.42,39.81 136.37,39.87 135.81,39.87 135.68,39.99 135.68,40.35 135.81,40.47 136.37,40.47 136.42,40.53 v2(136.42,41.31)
  BOTTOM w0.089: JCPU1.AJ6 144.2,84.39 v2(143.73,83.92)
  BOTTOM w0.102: JDIMM1.51 137.9,40.59 137.18,41.31 v2(136.42,41.31)
DDR_A_D19: length 62.2
  IN4 w0.089: 139.71,77.69 139.71,78.1 140.33,78.72 140.33,81.36 140.5,81.52 140.9,81.52 141.13,81.75 141.13,82.06 141.46,82.38 141.82,82.38 142.12,82.69 142.12,83.15 142.73,83.76 v2(142.73,83.92)
  IN4 w0.102: 139.71,77.69 139.8,77.6 139.91,77.6 140.04,77.47 140.04,77.23 139.91,77.1 139.84,77.1 139.75,77.01 139.75,76.75 139.85,76.64 139.95,76.64 140.05,76.54 140.05,76.24 139.95,76.14 139.85,76.14 139.75,76.03 139.75,75.73 139.85,75.63 139.95,75.63 140.05,75.53 140.05,75.22 139.95,75.12 139.85,75.12 139.75,75.02 139.75,74.71 139.85,74.61 139.95,74.61 140.05,74.51 140.05,74.21 139.95,74.1 139.59,74.1 139.47,73.98 139.47,73.72 139.59,73.6 139.95,73.6 140.05,73.49 140.05,73.19 139.95,73.09 139.52,73.09 139.41,72.97 139.41,72.14 139.51,72.04 139.64,72.04 139.75,71.94 139.75,71.64 139.64,71.53 139.51,71.53 139.41,71.43 139.41,70.92 139.2,70.72 139.2,70.21 139.07,70.08 138.73,70.08 138.6,69.95 138.6,69.46 138.73,69.33 139.07,69.33 139.2,69.2 139.2,67.78 139.07,67.65 138.71,67.65 138.58,67.53 138.58,66.99 138.71,66.87 139.07,66.87 139.2,66.74 139.2,65.84 138.49,65.13 138.49,62.39 137.98,61.88 137.98,61.34 137.65,61.01 137.65,60.22 137.55,60.12 137.23,60.12 137.13,60.02 137.13,59.71 137.23,59.61 137.55,59.61 137.65,59.51 137.65,59.2 137.55,59.1 137.23,59.1 137.13,59 137.13,58.7 137.23,58.59 137.55,58.59 137.65,58.49 137.65,58.19 137.55,58.09 137.23,58.09 137.13,57.98 137.13,57.68 137.23,57.58 137.55,57.58 137.65,57.48 137.65,57.17 137.55,57.07 137.23,57.07 137.13,56.97 137.13,56.66 137.23,56.56 137.55,56.56 137.65,56.46 137.65,56.16 137.55,56.05 137.23,56.05 137.13,55.95 137.13,55.65 137.23,55.55 137.55,55.55 137.65,55.44 137.65,55.14 137.55,55.04 137.23,55.04 137.13,54.94 137.13,54.63 137.23,54.53 137.55,54.53 137.65,54.43 137.65,54.06 137.52,53.94 137.26,53.94 137.13,53.81 137.13,43.83 137,43.7 136.95,43.7 136.83,43.57 136.83,43.28 136.95,43.15 137,43.15 137.13,43.03 137.13,42.59 137,42.46 136.55,42.46 136.42,42.59 v2(136.42,42.84)
  BOTTOM w0.089: JCPU1.AK6 143.2,84.39 v2(142.73,83.92)
  BOTTOM w0.102: JDIMM1.53 138.5,42.48 138.15,42.84 137.77,42.84 137.64,42.71 137.64,42.56 137.51,42.43 137.12,42.43 136.99,42.56 136.99,42.75 136.91,42.84 v2(136.42,42.84)
DDR_A_D20: length 65.7
  IN4 w0.089: v2(143.73,87.92) 143.29,87.92 142.67,87.29 141.49,87.29 141.33,87.13 141.33,85.68 140.97,85.32 140.57,85.32 140.33,85.09 140.33,84.67 139.98,84.32 139.57,84.32 139.33,84.09 139.33,83.62 139.03,83.32 138.57,83.32 138.33,83.09 138.33,82.65 138.02,82.33 137.57,82.33 137.33,82.1 137.33,81.67 136.98,81.32 136.57,81.32 136.33,81.08 136.33,80.15 136.04,79.85 136.04,77.36
  IN4 w0.102: v2(135.15,34.64) 133.64,36.15 133.64,39.43 132.76,40.31 132.76,43.75 133.3,44.28 133.3,53.49 134.68,54.87 134.68,61.74 135.01,62.08 135.01,62.48 136.04,63.51 136.04,77.36
  BOTTOM w0.089: v2(143.73,87.92) 144.2,88.39 JCPU1.AJ10
  BOTTOM w0.102: v2(135.15,34.64) 134.6,34.09 JDIMM1.40
DDR_A_D21: length 64.9
  IN4 w0.089: 136,80.42 136.06,80.48 136.06,81.08 136.49,81.51 136.89,81.51 137.14,81.76 137.14,82.17 137.49,82.52 137.9,82.52 138.14,82.76 138.14,83.16 138.49,83.51 138.89,83.51 139.14,83.76 139.14,84.16 139.49,84.51 139.89,84.51 140.14,84.76 140.14,85.16 140.49,85.51 140.89,85.51 141.14,85.76 141.14,87.32 141.33,87.52 142.33,87.52 v2(142.73,87.92)
  IN4 w0.102: 136,80.42 135.73,80.15 135.73,63.63 134.71,62.61 134.71,62.2 134.37,61.87 134.37,55 133,53.62 133,44.41 132.46,43.87 132.46,40.18 133.33,39.31 133.33,35.8 133.85,35.28 133.85,34.41 v2(135.15,33.11)
  BOTTOM w0.089: JCPU1.AK10 143.2,88.39 v2(142.73,87.92)
  BOTTOM w0.102: v2(135.15,33.11) 135.2,33.06 JDIMM1.42
DDR_A_D22: length 63.2
  IN4 w0.089: 139.44,77.36 139.44,78.1 140.14,78.8 140.14,81.49 140.32,81.67 140.32,82.08 140.57,82.32 140.97,82.32 141.35,82.7 141.35,83.09 141.56,83.3 141.99,83.3 142.33,83.64 142.33,84.09 142.76,84.52 143.33,84.52 v2(143.73,84.92)
  IN4 w0.102: v2(136.42,33.11) 136.46,33.11 136.89,33.54 136.89,34.54 137.4,35.05 137.4,36.98 137.27,37.11 136.14,37.11 136.01,37.24 136.01,38.01 135.25,38.77 135.25,40.42 136.01,41.19 136.01,43.77 136.82,44.58 136.82,60.85 137.28,61.31 137.28,61.62 138.18,62.52 138.18,65.27 138.9,65.98 138.9,66.38 138.77,66.51 138.39,66.51 138.26,66.64 138.26,67.91 138.39,68.03 138.68,68.03 138.81,68.16 138.81,68.86 138.68,68.99 138.31,68.99 138.18,69.11 138.18,70.13 139.1,71.05 139.1,74.04 139.44,74.38 139.44,77.36
  BOTTOM w0.089: JCPU1.AJ7 144.2,85.39 v2(143.73,84.92)
  BOTTOM w0.102: JDIMM1.50 137.6,31.93 v2(136.42,33.11)
DDR_A_D23: length 62.6
  IN4 w0.089: v2(142.73,84.92) 142.73,84.76 142.68,84.71 ; 139.14,77.36 139.14,78.77 139.33,78.96 139.33,81.3 139.56,81.52 139.9,81.52 140.13,81.75 140.13,82.16 140.49,82.51 140.89,82.51 141.14,82.76 141.14,83.16 141.49,83.51 141.89,83.51 142.14,83.76 142.14,84.16 142.68,84.71
  IN4 w0.097: 142.68,84.71 142.68,84.71
  IN4 w0.102: v2(136.42,34.64) 135.84,34.64 135.71,34.76 135.71,35.81 135.84,35.94 136.84,35.94 136.97,36.07 136.97,36.5 136.84,36.63 135.84,36.63 135.71,36.75 135.71,37.86 134.9,38.67 134.9,40.5 135.71,41.31 135.71,43.89 136.52,44.71 136.52,60.98 136.93,61.39 136.93,61.74 137.88,62.69 137.88,70.26 138.79,71.17 138.79,74.17 139.14,74.51 139.14,77.36
  BOTTOM w0.089: JCPU1.AK7 143.2,85.39 v2(142.73,84.92)
  BOTTOM w0.102: v2(136.42,34.64) 137.14,33.91 137.14,33.1 138.2,32.04 JDIMM1.52
DDR_A_D24: length 58
  IN4 w0.089: v2(146.73,81.92) 146.86,81.8 146.86,81.45 146.73,81.32 144.35,81.32 144.2,81.17 144.2,80.62 144.1,80.52 143.4,80.52 143.29,80.41 143.29,78.24 143.16,78.12 142.62,78.12 142.49,77.99 142.49,77.36
  IN4 w0.102: 142.49,77.36 142.49,76.38 142.36,76.25 142.01,76.25 141.88,76.12 141.88,75.84 142.01,75.72 142.36,75.72 142.49,75.59 142.49,75.34 142.36,75.21 141.92,75.21 141.79,75.08 141.79,74.82 141.92,74.69 142.35,74.69 142.48,74.56 142.48,74.33 142.35,74.21 141.91,74.21 141.78,74.08 141.78,73.82 141.91,73.7 142.36,73.7 142.49,73.57 142.49,73.32 142.36,73.19 141.88,73.19 141.78,73.09 141.78,72.78 141.88,72.68 142.35,72.68 142.48,72.55 142.48,72.3 142.35,72.17 141.88,72.17 141.78,72.07 141.78,71.77 141.88,71.67 142.35,71.67 142.48,71.54 142.48,71.22 142.35,71.09 141.74,71.09 141.61,70.97 141.61,70.6 141.73,70.48 142.13,70.48 142.24,70.38 142.24,69.06 142.11,68.94 141.09,68.94 140.95,68.8 140.95,68.61 141.09,68.47 141.47,68.47 141.59,68.35 141.59,68.16 141.41,67.98 141.05,67.98 140.93,67.86 140.93,64.55 140.86,64.49 140.86,60.82 139.37,59.33 139.37,41.16 139.25,41.03 139.09,41.03 138.96,41.16 v2(138.96,41.31)
  BOTTOM w0.089: JCPU1.AF4 147.2,82.39 v2(146.73,81.92)
  BOTTOM w0.102: JDIMM1.57 139.7,40.57 v2(138.96,41.31)
DDR_A_D25: length 59.3
  IN4 w0.089: v2(146.73,82.92) 146.45,82.92 146.19,82.65 146.19,81.65 146.06,81.52 143.51,81.52 143.13,81.14 143.13,80.69 142.96,80.52 142.48,80.52 142.32,80.37 142.32,78.18 142.18,78.04 142.18,77.36
  IN4 w0.102: 142.18,77.36 142.18,76.68 142.06,76.56 141.6,76.56 141.47,76.43 141.47,71.67 141.31,71.5 141.31,70.81 141.19,70.7 141.19,69.47 140.62,68.9 140.62,64.85 140.47,64.69 140.09,64.69 139.96,64.57 139.96,63.56 140.09,63.44 140.43,63.44 140.56,63.31 140.56,62.89 140.43,62.76 140.04,62.76 139.91,62.64 139.91,62.03 140.04,61.9 140.14,61.9 140.27,61.77 140.27,61.42 140.14,61.29 140.04,61.29 139.91,61.16 139.91,60.3 139.07,59.45 139.07,52.92 138.94,52.79 138.76,52.79 138.63,52.67 138.63,52.26 138.76,52.13 138.92,52.13 139.05,52.01 139.05,51.61 138.92,51.49 138.68,51.49 138.55,51.36 138.55,51.09 138.68,50.96 138.94,50.96 139.07,50.84 139.07,50.55 138.94,50.42 138.68,50.42 138.55,50.29 138.55,50 138.68,49.87 138.94,49.87 139.07,49.75 139.07,49.47 138.97,49.36 138.68,49.36 138.55,49.24 138.55,48.98 138.68,48.86 138.94,48.86 139.07,48.73 139.07,48.48 138.94,48.35 138.68,48.35 138.55,48.22 138.55,47.97 138.68,47.84 138.94,47.84 139.07,47.71 139.07,47.46 138.94,47.33 138.68,47.33 138.55,47.21 138.55,46.95 138.68,46.82 138.94,46.82 139.07,46.7 139.07,46.44 138.94,46.32 138.68,46.32 138.55,46.19 138.55,45.94 138.68,45.81 138.94,45.81 139.07,45.68 139.07,45.43 138.94,45.3 138.69,45.3 138.57,45.17 138.57,44.92 138.69,44.79 138.94,44.79 139.07,44.67 139.07,44.18 138.94,44.06 138.68,44.06 138.55,43.93 138.55,42.6 138.68,42.47 138.86,42.47 138.96,42.57 v2(138.96,42.84)
  BOTTOM w0.089: v2(146.73,82.92) 147.2,83.39 JCPU1.AF5
  BOTTOM w0.102: v2(138.96,42.84) 139.21,42.84 140.3,41.75 JDIMM1.59
DDR_A_D26: length 55.6
  IN4 w0.089: v2(146.73,78.92) 146.73,79.2 146.61,79.32 146.48,79.32 146.35,79.2 146.35,78.57 145.73,77.95 145.41,77.95 144.81,77.36
  IN4 w0.102: v2(142.1,42.84) 142.1,42.58 141.98,42.46 141.78,42.46 141.69,42.56 141.69,58.25 143.01,59.57 143.01,63.37 143.56,63.93 143.98,63.93 144.1,64.05 144.1,64.52 143.98,64.64 143.65,64.64 143.52,64.77 143.52,65.3 143.65,65.43 144.79,65.43 144.92,65.56 144.92,65.89 144.81,65.99 143.59,65.99 143.47,66.12 143.47,66.37 143.59,66.5 144.81,66.5 144.92,66.6 144.92,66.9 144.81,67 144,67 143.87,67.13 143.87,67.39 144,67.51 144.81,67.51 144.92,67.61 144.92,67.92 144.81,68.02 144.48,68.02 144.38,68.12 144.38,68.43 144.48,68.53 144.81,68.53 144.92,68.63 144.92,68.94 144.81,69.04 144.48,69.04 144.38,69.14 144.38,69.65 144.51,69.77 144.82,69.77 144.95,69.9 144.95,71.51 144.91,71.55 144.76,71.55 144.64,71.68 144.64,71.87 144.76,72 144.81,72 144.94,72.12 144.94,72.38 144.81,72.5 144.74,72.5 144.64,72.61 144.64,72.91 144.74,73.01 144.85,73.01 144.95,73.11 144.95,73.42 144.85,73.52 144.74,73.52 144.64,73.62 144.64,73.93 144.74,74.03 144.85,74.03 144.95,74.13 144.95,74.43 144.85,74.54 144.74,74.54 144.64,74.64 144.64,74.94 144.74,75.04 144.85,75.04 144.95,75.15 144.95,75.45 144.85,75.55 144.74,75.55 144.64,75.65 144.64,75.96 144.74,76.06 144.85,76.06 144.95,76.16 144.95,76.47 144.85,76.57 144.74,76.57 144.64,76.67 144.64,77.18 144.81,77.36
  BOTTOM w0.089: JCPU1.AF1 147.2,79.39 v2(146.73,78.92)
  BOTTOM w0.102: JDIMM1.67 142.7,40.11 142.22,40.59 141.78,40.59 141.52,40.84 141.52,42.27 v2(142.1,42.84)
DDR_A_D27: length 56.1
  IN4 w0.089: 144.33,77.36 144.33,77.38 145.17,78.22 145.68,78.22 146.15,78.69 146.15,79.33 v2(146.73,79.92)
  IN4 w0.102: 144.33,77.36 144.33,71.5 144.64,71.19 144.64,70.34 144.08,69.78 144.08,68.04 143.16,67.13 143.16,66.32 143.06,66.22 142.87,66.22 142.77,66.12 142.77,65.82 142.87,65.71 143.09,65.71 143.21,65.59 143.21,65.33 143.09,65.21 142.87,65.21 142.77,65.1 142.77,64.74 142.9,64.62 143.2,64.62 143.33,64.49 143.33,64.12 143.2,63.99 142.85,63.99 142.8,63.93 142.8,63.71 142.71,63.62 142.71,60.05 141.27,58.62 141.27,41.01 141.37,40.91 141.54,40.91 141.64,40.81 141.64,40.5 141.54,40.4 141.37,40.4 141.27,40.3 141.27,39.99 141.37,39.89 141.54,39.89 141.64,39.79 141.64,39.49 141.54,39.38 141.37,39.38 141.27,39.28 141.27,38.98 141.37,38.88 141.54,38.88 141.64,38.78 141.64,38.47 141.54,38.37 141.37,38.37 141.27,38.27 141.27,37.73 141.4,37.6 142.02,37.6 142.15,37.73 142.15,41.26 v2(142.1,41.31)
  BOTTOM w0.089: JCPU1.AF2 147.2,80.39 v2(146.73,79.92)
  BOTTOM w0.102: v2(142.1,41.31) 143.3,40.11 JDIMM1.69
DDR_A_D28: length 57.9
  IN4 w0.089: v2(145.73,81.92) 145.33,82.32 143.57,82.32 143.32,82.08 143.32,81.67 142.98,81.33 142.58,81.33 142.32,81.08 142.32,80.67 142.13,80.48 142.13,78.5 141.3,77.66 141.3,77.48 141.17,77.36
  IN4 w0.102: v2(138.96,34.64) 138.25,35.35 138.25,52.74 138.77,53.26 138.77,59.58 139.61,60.42 139.61,64.65 140.32,65.36 140.32,69.02 140.87,69.58 140.87,70.81 140.98,70.91 140.98,71.65 141.17,71.84 141.17,77.36
  BOTTOM w0.089: JCPU1.AG4 146.2,82.39 v2(145.73,81.92)
  BOTTOM w0.102: v2(138.96,34.64) 138.41,34.09 138.41,32.65 139.4,31.66 JDIMM1.56
DDR_A_D29: length 58.8
  IN4 w0.089: 140.86,77.36 140.86,77.72 141.33,78.19 141.33,80.36 141.5,80.52 141.9,80.52 142.13,80.75 142.13,81.16 142.5,81.52 142.9,81.52 143.13,81.75 143.13,82.16 143.5,82.52 143.9,82.52 144.23,82.85 144.23,82.98 144.57,83.32 145.33,83.32 v2(145.73,82.92)
  IN4 w0.102: v2(138.96,33.11) 137.94,34.13 137.94,53.06 138.46,53.58 138.46,59.71 139.3,60.55 139.3,64.78 140.01,65.49 140.01,70.38 140.61,70.98 140.61,71.79 140.86,72.05 140.86,77.36
  BOTTOM w0.089: JCPU1.AG5 146.2,83.39 v2(145.73,82.92)
  BOTTOM w0.102: v2(138.96,33.11) 139.36,32.71 139.37,32.71 140,32.08 JDIMM1.58
DDR_A_D30: length 54
  IN4 w0.089: v2(145.73,78.92) 145.44,78.92 144.03,77.5 144.03,77.36
  IN4 w0.102: v2(142.11,33.11) 142.4,33.4 142.71,33.4 142.83,33.53 142.83,34.04 142.93,34.14 143.33,34.14 143.45,34.26 143.45,34.52 143.33,34.65 142.93,34.65 142.83,34.75 142.83,36.06 142.71,36.19 142.24,36.19 140.95,37.48 140.95,58.73 142.4,60.18 142.4,63.75 142.46,63.81 142.46,66.86 143.77,68.17 143.77,69.9 144.34,70.47 144.34,71.06 144.03,71.37 144.03,77.36
  BOTTOM w0.089: JCPU1.AG1 146.2,79.39 v2(145.73,78.92)
  BOTTOM w0.102: v2(142.11,33.11) 143,32.22 JDIMM1.68
DDR_A_D31: length 55
  IN4 w0.089: v2(145.73,79.92) 145.28,79.47 145.28,79.17 143.72,77.61 143.72,77.36
  IN4 w0.102: v2(142.11,34.64) 142.11,34.38 142.01,34.28 141.48,34.28 141.38,34.38 141.38,35.52 141.51,35.65 141.71,35.65 141.83,35.78 141.83,36.16 141.73,36.26 141.48,36.26 141.38,36.36 141.38,36.61 140.62,37.37 140.62,58.83 142.1,60.31 142.1,63.87 142.16,63.94 142.16,66.98 143.47,68.29 143.47,70.03 144.03,70.6 144.03,70.93 143.72,71.24 143.72,77.36
  BOTTOM w0.089: JCPU1.AG2 146.2,80.39 v2(145.73,79.92)
  BOTTOM w0.102: JDIMM1.70 143.6,33.15 v2(142.11,34.64)
DDR_A_D32: length 51.5
  IN4 w0.102: v2(164.73,78.92) 164.04,78.23 164.04,77.16 163.94,77.06 163.72,77.06 163.59,76.94 163.59,76.68 163.72,76.55 163.94,76.55 164.04,76.45 164.04,76.15 163.94,76.05 163.72,76.05 163.59,75.92 163.59,75.67 163.72,75.54 163.94,75.54 164.04,75.44 164.04,75.13 163.94,75.03 163.72,75.03 163.59,74.9 163.59,74.65 163.72,74.52 163.91,74.52 164.04,74.4 164.04,74.14 163.91,74.01 163.72,74.01 163.59,73.89 163.59,73.63 163.72,73.51 163.94,73.51 164.04,73.4 164.04,73.1 163.94,73 163.72,73 163.59,72.87 163.59,72.62 163.72,72.49 163.94,72.49 164.04,72.39 164.04,72.08 163.94,71.98 163.74,71.98 163.64,71.88 163.64,71.58 163.74,71.47 163.94,71.47 164.04,71.37 164.04,70.54 163.94,70.43 163.72,70.43 163.59,70.31 163.59,70.05 163.72,69.93 163.94,69.93 164.04,69.82 164.04,69.52 163.94,69.42 163.72,69.42 163.59,69.29 163.59,69.04 163.72,68.91 163.94,68.91 164.04,68.81 164.04,68.5 163.94,68.4 163.72,68.4 163.59,68.27 163.59,68.02 163.72,67.89 163.91,67.89 164.04,67.77 164.04,67.51 163.91,67.39 163.72,67.39 163.59,67.26 163.59,67 163.72,66.88 163.91,66.88 164.04,66.75 164.04,66.29 163.91,66.17 163.74,66.17 163.64,66.06 163.64,64.51 165.57,62.58 165.57,42.65 165.4,42.49 165.22,42.49 165.1,42.61 v2(165.1,42.84)
  BOTTOM w0.089: v2(164.73,78.92) JCPU1.J1
  BOTTOM w0.102: JDIMM1.129 163.7,41.17 163.83,41.3 164.3,41.3 164.42,41.43 164.42,41.78 164.3,41.91 163.83,41.91 163.7,42.04 163.7,42.52 164.02,42.84 v2(165.1,42.84)
DDR_A_D33: length 52
  IN4 w0.089: v2(164.73,79.92) 165.13,79.52 165.13,78.74 164.35,77.95 164.35,77.36
  IN4 w0.102: v2(165.1,41.31) 165.1,38.06 165.22,37.93 165.79,37.93 165.92,38.06 165.92,39.14 165.79,39.27 165.74,39.27 165.62,39.4 165.62,39.83 165.74,39.95 165.79,39.95 165.92,40.08 165.92,40.32 165.79,40.45 165.74,40.45 165.62,40.58 165.62,40.83 165.74,40.96 165.79,40.96 165.92,41.08 165.92,41.36 165.79,41.49 165.68,41.49 165.55,41.62 165.55,41.92 165.68,42.05 165.77,42.05 165.9,42.18 165.9,62.68 164.35,64.24 164.35,64.87 164.22,65 164.08,65 163.95,65.13 163.95,65.58 164.08,65.71 164.22,65.71 164.35,65.84 164.35,77.36
  BOTTOM w0.089: v2(164.73,79.92) JCPU1.J2
  BOTTOM w0.102: v2(165.1,41.31) 164.3,40.52 JDIMM1.131
DDR_A_D34: length 55.7
  IN4 w0.089: 166.91,77.36 166.91,77.6 167.58,78.27 167.58,79.21 167.13,79.66 167.13,81.09 166.9,81.32 166.44,81.32 166.13,81.62 166.13,82.09 165.9,82.32 164.86,82.32 164.73,82.45 v2(164.73,82.92)
  IN4 w0.102: 166.91,77.36 166.91,65.14 168.4,63.65 168.4,62.05 168.9,61.55 168.9,50.98 169.03,50.85 169.34,50.85 169.46,50.72 169.46,50.43 169.34,50.3 169.03,50.3 168.9,50.18 168.9,49.89 169,49.79 169.41,49.79 169.52,49.69 169.52,49.38 169.41,49.28 169,49.28 168.9,49.18 168.9,48.87 169,48.77 169.41,48.77 169.52,48.67 169.52,48.37 169.41,48.26 169,48.26 168.9,48.16 168.9,47.86 169,47.76 169.41,47.76 169.52,47.65 169.52,47.35 169.41,47.25 169,47.25 168.9,47.15 168.9,46.84 169,46.74 169.41,46.74 169.52,46.64 169.52,46.33 169.41,46.23 169,46.23 168.9,46.13 168.9,45.83 169,45.72 169.41,45.72 169.52,45.62 169.52,45.32 169.41,45.22 169,45.22 168.9,45.11 168.9,44.74 169.03,44.61 169.38,44.61 169.5,44.49 169.5,42.57 169.43,42.5 169.14,42.5 169.07,42.57 v2(169.07,42.84)
  BOTTOM w0.089: v2(164.73,82.92) JCPU1.J5
  BOTTOM w0.102: v2(169.07,42.84) 168,41.77 168,41.22 167.3,40.52 JDIMM1.141
DDR_A_D35: length 55.1
  IN4 w0.089: v2(165.73,82.92) 166.33,82.32 166.33,81.75 166.58,81.51 166.98,81.51 167.33,81.16 167.33,79.75 167.88,79.21 167.88,78.21 167.22,77.55 167.22,77.36
  IN4 w0.102: 167.22,77.36 167.22,65.26 168.7,63.78 168.7,62.18 169.21,61.68 169.21,51.6 169.31,51.5 169.72,51.5 169.83,51.4 169.83,48 169.83,47.99 169.83,38.1 169.7,37.97 169.19,37.97 169.07,38.1 v2(169.07,41.31)
  BOTTOM w0.089: v2(165.73,82.92) JCPU1.H5
  BOTTOM w0.102: v2(169.07,41.31) 167.9,40.15 JDIMM1.143
DDR_A_D36: length 51.8
  IN4 w0.089: 164.65,77.36 164.65,77.91 165.33,78.6 165.33,79.52 v2(165.73,79.92)
  IN4 w0.102: v2(165.71,34.64) 166.23,35.16 166.23,62.79 164.65,64.36 164.65,77.36
  BOTTOM w0.089: v2(165.73,79.92) JCPU1.H2
  BOTTOM w0.102: v2(165.71,34.64) 164,32.93 JDIMM1.130
DDR_A_D37: length 50.6
  IN4 w0.097: 164.98,77.36 164.98,77.8 165.73,78.55 v2(165.73,78.92)
  IN4 w0.102: v2(165.71,33.11) 166.56,33.96 166.56,62.89 164.98,64.46 164.98,77.36
  BOTTOM w0.089: v2(165.73,78.92) JCPU1.H1
  BOTTOM w0.102: v2(165.71,33.11) 164.61,32.02 164.6,32.02 JDIMM1.132
DDR_A_D38: length 55.1
  IN4 w0.089: 166.27,77.36 166.27,77.75 167.11,78.59 167.11,79.11 166.52,79.7 166.52,80.23 166.13,80.62 166.13,81.05 165.86,81.32 165.33,81.32 v2(164.73,81.92)
  IN4 w0.102: 166.27,77.36 166.27,64.92 167.79,63.4 167.79,61.8 168.29,61.3 168.29,38.84 167.76,38.3 167.76,35.17 v2(167.23,34.64)
  BOTTOM w0.089: v2(164.73,81.92) JCPU1.J4
  BOTTOM w0.102: JDIMM1.140 167,32.07 166.67,32.4 166.67,34.08 v2(167.23,34.64)
DDR_A_D39: length 54.3
  IN4 w0.089: v2(165.73,81.92) 165.73,81.76 166.33,81.16 166.33,80.75 166.71,80.37 166.71,79.81 167.33,79.2 167.33,78.43
  IN4 w0.102: 167.33,78.43 166.61,77.71 166.61,65.01 168.09,63.52 168.09,61.93 168.6,61.42 168.6,38.48 168.17,38.06 168.17,34.06 v2(167.23,33.11)
  BOTTOM w0.089: v2(165.73,81.92) JCPU1.H4
  BOTTOM w0.102: JDIMM1.142 167.6,32.75 v2(167.23,33.11)
DDR_A_D40: length 56.3
  IN4 w0.089: 168.74,77.36 168.74,79.31 168.33,79.72 168.33,80.24 168.21,80.37 167.86,80.37 167.73,80.49 v2(167.73,80.92)
  IN4 w0.102: v2(171.1,42.84) 170.75,42.84 170.64,42.94 170.64,55.5 170.52,55.63 170.15,55.63 170.02,55.75 170.02,56.26 170.12,56.36 170.54,56.36 170.64,56.46 170.64,56.77 170.54,56.87 170.12,56.87 170.02,56.97 170.02,57.28 170.12,57.38 170.54,57.38 170.64,57.48 170.64,57.78 170.54,57.89 170.12,57.89 170.02,57.99 170.02,58.29 170.12,58.39 170.54,58.39 170.64,58.5 170.64,58.8 170.54,58.9 170.12,58.9 170.02,59 170.02,59.31 170.12,59.41 170.54,59.41 170.64,59.51 170.64,59.82 170.54,59.92 170.12,59.92 170.02,60.02 170.02,60.32 170.12,60.43 170.54,60.43 170.64,60.53 170.64,60.83 170.54,60.93 170.12,60.93 170.02,61.04 170.02,61.34 170.12,61.44 170.54,61.44 170.64,61.54 170.64,62.17 170.52,62.29 169.74,62.29 169.62,62.42 169.62,62.71 169.74,62.84 170.25,62.84 170.38,62.97 170.38,63.25 170.25,63.37 169.64,63.37 169.52,63.5 169.52,64.11 168.74,64.89 168.74,65.54 168.64,65.65 168.17,65.65 168.04,65.77 168.04,66.03 168.17,66.15 168.6,66.15 168.73,66.28 168.73,66.56 168.6,66.69 168.16,66.69 168.03,66.81 168.03,75.86 168.16,75.98 168.6,75.98 168.73,76.11 168.73,76.4 168.6,76.53 168.16,76.53 168.03,76.66 168.03,77.01 168.12,77.11 168.61,77.11 168.74,77.23 168.74,77.36
  BOTTOM w0.089: JCPU1.F2 167.26,80.45 v2(167.73,80.92)
  BOTTOM w0.102: v2(171.1,42.84) 170.04,41.77 170.04,41.35 169.1,40.41 JDIMM1.147
DDR_A_D41: length 54.5
  IN4 w0.089: 167.83,77.36 168.22,77.75 168.22,79.14 167.73,79.62 v2(167.73,79.92)
  IN4 w0.102: 167.83,77.36 167.72,77.25 167.72,65.47 169.21,63.99 169.21,62.39 169.72,61.89 169.72,55.4 169.82,55.3 170.21,55.3 170.32,55.19 170.32,54.89 170.21,54.79 169.82,54.79 169.72,54.69 169.72,54.38 169.82,54.28 170.21,54.28 170.32,54.18 170.32,53.87 170.21,53.77 169.82,53.77 169.72,53.67 169.72,53.37 169.82,53.26 170.21,53.26 170.32,53.16 170.32,52.86 170.21,52.76 169.82,52.76 169.72,52.65 169.72,52.15 169.84,52.02 170.21,52.02 170.34,51.89 170.34,37.86 170.46,37.73 170.97,37.73 171.1,37.86 v2(171.1,41.31)
  BOTTOM w0.089: v2(167.73,79.92) 167.26,79.45 JCPU1.F1
  BOTTOM w0.102: JDIMM1.149 169.7,39.91 v2(171.1,41.31)
DDR_A_D42: length 55.5
  IN4 w0.089: v2(169.73,80.92) 169.73,81.18 169.86,81.31 170.01,81.31 170.12,81.19 170.12,80.69 170.49,80.32 170.9,80.32 171.13,80.09 171.13,78.93 170.58,78.38 170.58,77.36
  IN4 w0.102: v2(173.56,42.84) 173.56,42.59 173.44,42.46 173.23,42.46 173.1,42.59 173.1,43.88 173.23,44.01 173.54,44.01 173.67,44.13 173.67,44.58 173.54,44.7 172.74,44.7 172.62,44.83 172.62,45.14 172.74,45.26 172.87,45.26 173,45.39 173,45.67 172.87,45.8 172.61,45.8 172.48,45.92 172.48,63.86 172.02,64.33 172.02,64.5 172.48,64.97 172.48,65.29 172.37,65.41 172.09,65.41 171.56,64.88 171.38,64.88 171.21,65.05 171.21,65.23 172.31,66.33 172.31,66.51 172.11,66.71 171.93,66.71 170.95,65.72 170.77,65.72 170.59,65.9 170.59,66.56 170.75,66.71 171.22,66.71 171.52,67.01 171.52,67.3 171.33,67.49 171.13,67.49 170.89,67.25 170.75,67.25 170.58,67.41 170.58,67.67 170.79,67.87 170.79,68.03 170.58,68.24 170.58,77.36
  BOTTOM w0.089: v2(169.73,80.92) 169.26,80.45 JCPU1.D2
  BOTTOM w0.102: v2(173.56,42.84) 172.58,41.85 172.58,40.91 172.1,40.43 JDIMM1.157
DDR_A_D43: length 55.8
  IN4 w0.089: v2(169.73,81.92) 169.22,81.92 169.1,82.05 169.1,82.3 169.22,82.42 170.2,82.42 170.33,82.3 170.33,80.76 170.58,80.51 170.98,80.51 171.36,80.13 171.36,78.57 171.26,78.47 170.99,78.47 170.87,78.36 170.87,77.83 170.97,77.73 170.97,77.36
  IN4 w0.102: v2(173.56,41.31) 173.21,41.31 173.08,41.19 173.08,40.79 173.21,40.67 173.84,40.67 173.97,40.79 173.97,44.97 173.87,45.07 173.41,45.07 173.3,45.19 173.3,45.85 173.05,46.1 172.88,46.1 172.79,46.19 172.79,63.99 172.41,64.36 172.41,64.46 172.79,64.84 172.79,65.43 172.4,65.82 172.4,65.99 172.75,66.34 172.75,66.52 170.97,68.31 170.97,77.36
  BOTTOM w0.089: v2(169.73,81.92) 169.26,81.45 JCPU1.D3
  BOTTOM w0.102: v2(173.56,41.31) 174.14,41.89 174.14,42.06 174.38,42.29 174.54,42.29 174.75,42.09 174.75,41.71 173.78,40.74 172.87,40.74 172.7,40.57 JDIMM1.159
DDR_A_D44: length 53.8
  IN4 w0.089: 169.35,77.36 169.35,79.1 169.41,79.16
  IN4 w0.097: 169.41,79.16 169.73,79.48 v2(169.73,79.92)
  IN4 w0.102: 169.35,77.36 169.35,75.81 168.73,75.19 168.73,67.65 169.35,67.03 169.35,65.14 171.25,63.24 171.25,44.45 171.84,43.87 171.84,37.7 169.98,35.84 169.98,33.83 170.1,33.71 170.29,33.71 170.42,33.58 170.42,33.24 170.29,33.11 v2(169.26,33.11)
  BOTTOM w0.089: v2(169.73,79.92) 169.26,79.45 JCPU1.D1
  BOTTOM w0.102: v2(169.26,33.11) 168.8,32.65 JDIMM1.146
DDR_A_D45: length 57.2
  IN4 w0.089: 169.04,77.36 169.04,79.67 169.11,79.73 169.11,80.14 168.8,80.44 168.68,80.44 168.25,80.87 168.25,81.41 167.74,81.92 v2(167.73,81.92)
  IN4 w0.102: 169.04,77.36 169.04,75.93 168.42,75.31 168.42,67.51 169.04,66.89 169.04,65.02 170.95,63.11 170.95,44.33 171.53,43.74 171.53,37.82 170.9,37.19 170.44,37.19 170.32,37.06 170.32,36.88 170.19,36.75 169.02,36.75 168.89,36.63 168.89,36.28 169.02,36.16 169.54,36.16 169.67,36.03 169.67,35.04 v2(169.26,34.64)
  BOTTOM w0.089: v2(167.73,81.92) 167.26,81.45 JCPU1.F3
  BOTTOM w0.102: v2(169.26,34.64) 169.85,34.06 169.85,32.4 169.4,31.95 JDIMM1.148
DDR_A_D46: length 54.9
  IN4 w0.089: v2(170.73,81.92) 171.13,81.52 171.13,80.68 171.5,80.32 171.9,80.32 172.13,80.09 172.13,78.82 171.31,77.99 171.31,77.36
  IN4 w0.102: v2(173.56,34.64) 174.27,35.35 174.27,45.3 173.09,46.48 173.09,66.67 171.31,68.46 171.31,77.36
  BOTTOM w0.089: JCPU1.C3 170.26,81.45 v2(170.73,81.92)
  BOTTOM w0.102: JDIMM1.158 172.4,33.47 v2(173.56,34.64)
DDR_A_D47: length 54.7
  IN4 w0.089: v2(171.73,81.92) 171.36,81.55 171.36,80.76 171.61,80.51 171.98,80.51 172.32,80.16 172.32,78.49 171.61,77.77 171.61,77.36
  IN4 w0.102: v2(173.56,33.11) 174.58,34.13 174.58,45.43 173.4,46.61 173.4,66.8 171.61,68.59 171.61,77.36
  BOTTOM w0.089: v2(171.73,81.92) 171.26,81.45 JCPU1.B3
  BOTTOM w0.102: v2(173.56,33.11) 173,32.55 JDIMM1.160
DDR_A_D48: length 59.4
  IN4 w0.089: v2(171.73,83.92) 171.25,83.92 171.13,83.8 171.13,83.63 171.25,83.51 172.02,83.51 172.37,83.16 172.37,82.68 172.6,82.45 172.98,82.45 173.32,82.1 173.32,77.63 173.05,77.36
  IN4 w0.102: v2(176.26,42.84) 176.26,42.61 176.41,42.45 176.89,42.45 177.02,42.58 177.02,43.93 176.89,44.06 176.16,44.06 176.03,44.18 176.03,44.51 176.16,44.64 176.84,44.64 176.97,44.77 176.97,45.02 176.84,45.15 176.16,45.15 176.03,45.28 176.03,45.99 174.82,47.2 174.82,69.66 174.69,69.79 173.21,69.79 173.08,69.91 173.08,70.17 173.21,70.29 174.69,70.29 174.82,70.42 174.82,70.7 174.69,70.83 173.17,70.83 173.05,70.95 173.05,77.36
  BOTTOM w0.089: JCPU1.B5 171.26,83.45 v2(171.73,83.92)
  BOTTOM w0.102: v2(176.26,42.84) 176.02,42.84 175.89,42.96 175.89,43.33 175.76,43.46 175.4,43.46 175.27,43.33 175.27,41.43 173.9,40.06 JDIMM1.163
DDR_A_D49: length 61.1
  IN4 w0.089: v2(168.73,84.92) 169.33,84.32 169.9,84.32 170.13,84.09 170.13,83.95 170.57,83.52 170.97,83.52 171.17,83.32 171.94,83.32 172.17,83.09 172.17,82.59 172.5,82.26 172.9,82.26 173.13,82.02 173.13,77.82 173.05,77.74 172.84,77.74 172.74,77.63 172.74,77.36
  IN4 w0.102: 172.74,77.36 172.74,69.04 174.52,67.26 174.52,47.07 175.7,45.89 175.7,38.04 175.83,37.91 176.13,37.91 176.26,38.04 176.26,39.06 176.36,39.17 177.12,39.17 177.25,39.29 177.25,39.55 177.12,39.67 176.36,39.67 176.26,39.78 v2(176.26,41.31)
  BOTTOM w0.089: JCPU1.E6 168.26,84.45 v2(168.73,84.92)
  BOTTOM w0.102: JDIMM1.165 174.5,40.13 175.69,41.31 v2(176.26,41.31)
DDR_A_D50: length 58.6
  IN4 w0.089: v2(172.73,83.92) 172.73,84.17 172.83,84.26 173.16,84.26 173.29,84.14 173.29,83.73 173.53,83.49 173.59,83.49
  IN4 w0.102: v2(178.8,42.84) 178.8,42.63 178.92,42.51 179.1,42.51 179.23,42.63 179.23,43.75 178.82,44.16 178.82,44.26 179.1,44.54 179.1,44.66 178.89,44.87 178.75,44.87 178.57,44.69 178.44,44.69 178.24,44.89 178.24,45.08 178.39,45.23 178.39,45.37 176.05,47.71 176.05,75.25 175.93,75.37 174.71,75.37 174.58,75.5 174.58,75.84 174.71,75.97 175.95,75.97 176.04,76.06 176.04,76.49 175.94,76.59 174.49,76.59 174.37,76.72 174.37,77.06 174.49,77.19 175.14,77.19 175.27,77.32 175.27,77.47 174.96,77.77 174.49,77.77 174.37,77.9 174.37,82.93 173.81,83.49 173.59,83.49
  BOTTOM w0.089: JCPU1.A5 172.26,83.45 v2(172.73,83.92)
  BOTTOM w0.102: JDIMM1.175 177.5,40.5 177.63,40.63 178.11,40.63 178.24,40.75 178.24,41 178.11,41.12 178.02,41.12 177.9,41.25 177.9,41.47 178.02,41.59 178.23,41.59 178.35,41.72 178.35,42.16 178.23,42.29 178.16,42.29 178.04,42.42 178.04,43.08 178.16,43.21 178.67,43.21 178.8,43.08 v2(178.8,42.84)
DDR_A_D51: length 60.5
  IN4 w0.089: 173.59,85.04 173.59,85.04 173.38,85.04 173.1,85.32 170.13,85.32 v2(169.73,84.92)
  IN4 w0.102: 173.59,85.04 175.28,83.35 175.28,78.76 176.97,77.08 176.97,48.12 180.22,44.87 180.22,39.62 178.54,37.95 178.54,37.14 v2(177.63,36.23)
  BOTTOM w0.089: JCPU1.D6 169.26,84.45 v2(169.73,84.92)
  BOTTOM w0.102: JDIMM1.177 178.1,36.7 v2(177.63,36.23)
DDR_A_D52: length 59.6
  IN4 w0.089: v2(169.73,83.92) 170.32,83.33 170.89,83.33 171.2,83.02 171.2,82.89 171.58,82.51 171.98,82.51 172.32,82.16 172.32,80.7 172.71,80.32 172.71,78.08 172.44,77.81 172.44,77.36
  IN4 w0.102: v2(176.26,34.64) 175.49,35.4 175.49,35.7 175.62,35.83 176.03,35.83 176.16,35.95 176.16,36.28 176.03,36.41 175.62,36.41 175.49,36.54 175.49,36.83 175.62,36.96 175.75,36.96 175.88,37.08 175.88,37.33 175.76,37.45 175.6,37.45 175.39,37.65 175.39,45.77 174.21,46.95 174.21,67.14 172.44,68.91 172.44,77.36
  BOTTOM w0.089: JCPU1.D5 169.26,83.45 v2(169.73,83.92)
  BOTTOM w0.102: JDIMM1.164 174.2,32.58 v2(176.26,34.64)
DDR_A_D53: length 60.4
  IN4 w0.089: v2(168.73,83.92) 169.28,83.37 169.95,83.37 170.25,83.07 170.25,82.73 170.51,82.48 ; 171.26,82.32 171.9,82.32 172.13,82.09 172.13,80.62 172.52,80.24 172.52,78.31 172.13,77.93
  IN4 w0.097: 171.26,82.32 171.1,82.48 170.51,82.48
  IN4 w0.102: v2(176.26,33.11) 176.26,32.75 176.13,32.63 175.21,32.63 175.09,32.75 175.09,45.64 173.91,46.82 173.91,67.01 172.13,68.79 172.13,77.93
  BOTTOM w0.089: JCPU1.E5 168.26,83.45 v2(168.73,83.92)
  BOTTOM w0.102: JDIMM1.166 174.8,31.66 v2(176.26,33.11)
DDR_A_D54: length 60.3
  IN4 w0.089: 173.59,84.14 173.21,84.52 172.53,84.52 172.12,84.92 v2(171.73,84.92)
  IN4 w0.102: 173.59,84.14 174.67,83.06 174.67,78.51 176.36,76.82 176.36,47.84 179.56,44.64 179.56,40.14 177.15,37.73 177.15,36.97 176.77,36.59 176.77,34 v2(177.63,33.13)
  BOTTOM w0.089: v2(171.73,84.92) 171.26,84.45 JCPU1.B6
  BOTTOM w0.102: JDIMM1.174 177.2,32.7 v2(177.63,33.13)
DDR_A_D55: length 59.8
  IN4 w0.089: 173.59,84.59 173.46,84.59 173.14,84.92 v2(172.73,84.92)
  IN4 w0.102: v2(177.63,34.66) 177.07,35.22 177.07,36.46 178.16,37.55 178.16,38 179.89,39.73 179.89,44.77 176.66,48 176.66,76.95 174.98,78.64 174.98,83.22 173.6,84.59 173.59,84.59
  BOTTOM w0.089: JCPU1.A6 172.26,84.45 v2(172.73,84.92)
  BOTTOM w0.102: v2(177.63,34.66) 178.16,34.13 178.16,32.78 177.8,32.41 JDIMM1.176
DDR_A_D56: length 72
  IN4 w0.089: v2(168.73,90.92) 168.73,90.45 168.86,90.33 169.91,90.33 170.14,90.09 170.14,89.38 170.32,89.2 170.32,88.76 170.57,88.52 170.97,88.52 171.32,88.16 171.32,87.76 171.57,87.52 171.97,87.52 172.17,87.32 173.32,87.32 173.44,87.2 173.44,86.63
  IN4 w0.102: v2(181.49,42.84) 181.49,42.57 181.59,42.47 181.94,42.47 182.04,42.57 182.04,43.89 181.91,44.02 181.49,44.02 181.36,44.14 181.36,44.4 181.49,44.53 181.82,44.53 181.91,44.61 181.91,44.75 181.62,45.05 181.49,45.05 181.36,45.17 181.36,45.31 178.08,48.59 178.08,77.54 176.4,79.23 176.4,83.31 176.4,84.53 176.27,84.66 175.57,84.66 175.45,84.78 175.45,85.17 175.57,85.29 176.27,85.29 176.4,85.42 176.4,86.02 176.27,86.14 175.85,86.14 175.73,86.27 175.73,86.84 175.52,87.05 175.29,87.05 175.17,86.92 175.17,85.67 175.04,85.55 174.67,85.55 174.54,85.67 174.54,87.32 174.42,87.45 174.1,87.45 173.97,87.32 173.97,86.63 173.85,86.5 173.57,86.5 173.44,86.63
  BOTTOM w0.089: JCPU1.E12 168.26,90.45 v2(168.73,90.92)
  BOTTOM w0.102: v2(181.49,42.84) 181.21,42.84 181.08,42.71 181.08,42.52 180.96,42.39 180.68,42.39 180.55,42.52 180.55,42.71 180.42,42.84 180.18,42.84 180.06,42.71 180.06,40.72 179.93,40.59 179.43,40.59 179.3,40.46 JDIMM1.181
DDR_A_D57: length 72.4
  IN4 w0.089: 173.59,87.77 173.27,87.77 173.2,87.69 173.2,87.58 173.13,87.51 172.34,87.51 172.13,87.72 172.13,88.21 172.03,88.32 171.44,88.32 171.13,88.62 171.13,89.2 171.02,89.32 170.51,89.32 170.33,89.49 170.33,91.02 170.21,91.15 169.86,91.15 169.73,91.02 v2(169.73,90.92)
  IN4 w0.102: 173.59,87.77 175.24,87.77 176.08,86.92 176.08,86.65 176.2,86.54 176.47,86.54 176.7,86.3 176.7,83.94 176.7,83.18 176.7,83.18 176.7,79.35 178.39,77.67 178.39,48.71 182.34,44.76 182.34,42.21 182.24,42.11 182.06,42.11 181.94,41.98 181.94,41.72 182.06,41.6 182.24,41.6 182.34,41.5 182.34,41.13 182.24,41.03 181.98,41.03 181.88,40.92 181.88,40.62 181.98,40.52 182.24,40.52 182.34,40.42 182.34,40.11 182.24,40.01 181.98,40.01 181.88,39.91 181.88,39.6 181.98,39.5 182.24,39.5 182.34,39.4 182.34,39.06 182.22,38.94 182.04,38.94 181.91,38.81 181.91,38.52 182.04,38.39 182.22,38.39 182.34,38.26 182.34,37.96 182.16,37.78 181.76,37.78 181.36,38.18 181.36,41.19 v2(181.49,41.31)
  BOTTOM w0.089: v2(169.73,90.92) 169.26,90.45 JCPU1.D12
  BOTTOM w0.102: JDIMM1.183 179.9,39.98 181.24,41.31 v2(181.49,41.31)
DDR_A_D58: length 72.4
  IN4 w0.089: 173.59,90.21 173.03,90.21 172.92,90.32 172.13,90.32 v2(171.73,89.92)
  IN4 w0.102: 173.59,90.21 176.29,90.21 179.98,86.51 179.98,86.37 179.38,85.77 179.38,85.59 179.56,85.41 179.74,85.41 180.34,86.01 180.48,86.01 180.7,85.8 180.7,85.65 179.55,84.51 179.55,84.33 179.73,84.15 179.91,84.15 181.06,85.29 181.2,85.29 181.42,85.08 181.42,84.93 181.01,84.53 181.01,84.35 181.19,84.17 181.37,84.17 181.77,84.57 181.92,84.57 184.12,82.37 184.12,79.51 179.93,75.31 179.93,49.35 183.88,45.4 183.88,45.2 184.01,45.07 184.12,45.07 184.25,44.95 184.25,44.67 184.12,44.54 184.01,44.54 183.88,44.41 183.88,44.13 184.01,44.01 184.31,44.01 184.43,43.88 184.43,42.59 184.31,42.46 184.16,42.46 184.03,42.59 v2(184.03,42.84)
  BOTTOM w0.089: v2(171.73,89.92) 171.26,89.45 JCPU1.B11
  BOTTOM w0.102: v2(184.03,42.84) 182.3,41.11 JDIMM1.191
DDR_A_D59: length 71.4
  IN4 w0.089: 173.59,89.05 173.27,89.05 173.15,89.18 173.15,89.66 173.02,89.79 172.86,89.79 172.73,89.91 v2(172.73,89.92)
  IN4 w0.102: 173.59,89.05 173.72,89.18 173.72,89.77 173.85,89.9 174.2,89.9 174.33,89.77 174.33,89.18 174.46,89.05 174.81,89.05 174.94,89.18 174.94,89.77 175.07,89.9 175.4,89.9 175.52,89.77 175.52,89.18 175.65,89.05 176.87,89.05 177.94,87.98 177.94,87.38 178.06,87.25 178.58,87.25 178.71,87.12 178.71,86.8 178.61,86.7 178.04,86.7 177.94,86.6 177.94,86.35 178.06,86.22 178.94,86.22 179.07,86.09 179.07,85.78 178.94,85.65 178.06,85.65 177.94,85.52 177.94,85.14 178.06,85.01 178.96,85.01 179.09,84.89 179.09,84.44 178.96,84.32 178.06,84.32 177.94,84.19 177.94,83.84 178.06,83.72 178.58,83.72 178.71,83.59 178.71,83.24 178.58,83.11 178.06,83.11 177.94,82.98 177.94,82.67 177.94,79.86 179.85,77.95 181.17,77.95 181.3,77.83 181.3,77.44 181.17,77.32 179.75,77.32 179.62,77.19 179.62,49.22 183.57,45.27 183.57,41.44 183.7,41.31 v2(184.03,41.31)
  BOTTOM w0.089: v2(172.73,89.92) 172.26,89.45 JCPU1.A11
  BOTTOM w0.102: JDIMM1.193 182.9,40.19 v2(184.03,41.31)
