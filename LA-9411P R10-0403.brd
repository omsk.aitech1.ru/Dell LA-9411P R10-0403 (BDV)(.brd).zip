# Allegro board LA-9411P R10-0403.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
DDR_A_D60: length 72.2
  IN4 w0.089: v2(168.73,89.92) 169.33,89.32 169.33,88.75 169.57,88.52 169.76,88.52 170.26,88.02 170.26,87.83 170.57,87.52 170.71,87.52 171.33,86.89 171.33,86.75 171.77,86.32 171.98,86.32 172,86.29 172.89,86.29 173.11,86.08 173.11,86.03 173.59,85.55
  IN4 w0.102: v2(180.29,34.64) 179.31,34.64 179.21,34.74 179.21,35.18 179.31,35.28 179.66,35.28 179.76,35.38 179.76,35.81 179.66,35.92 179.32,35.92 179.22,36.02 179.22,36.5 179.35,36.63 180.6,36.63 180.73,36.75 180.73,37.01 180.6,37.13 179.37,37.13 179.24,37.26 179.24,37.85 179.35,37.95 180.62,37.95 180.73,38.05 180.73,45.08 177.48,48.33 177.48,77.29 175.79,78.97 175.79,83.56 173.8,85.55 173.59,85.55
  BOTTOM w0.089: JCPU1.E11 168.26,89.45 v2(168.73,89.92)
  BOTTOM w0.102: v2(180.29,34.64) 179,33.34 JDIMM1.180
DDR_A_D61: length 72
  IN4 w0.089: 173.59,85.98 173.59,85.99 173.07,86.51 172.45,86.51 172.13,86.83 172.13,87.09 171.89,87.33 171.49,87.33 171.13,87.68 171.13,88.09 170.9,88.32 170.5,88.32 170.13,88.68 170.13,89.12 169.73,89.52 v2(169.73,89.92)
  IN4 w0.102: v2(180.29,33.11) 180.29,32.44 180.42,32.31 181.16,32.31 181.29,32.44 181.29,33.44 181.16,33.57 180.84,33.57 180.72,33.69 180.72,34.07 180.84,34.2 181.14,34.2 181.26,34.33 181.26,34.61 181.14,34.73 180.82,34.73 180.69,34.86 180.69,35.14 180.82,35.27 181.26,35.27 181.39,35.39 181.39,35.69 181.26,35.81 180.19,35.81 180.06,35.94 180.06,36.19 180.19,36.32 180.93,36.32 181.06,36.45 181.06,45.18 177.78,48.46 177.78,77.41 176.09,79.1 176.09,83.43 176.09,83.69 173.93,85.85 173.72,85.85 173.59,85.98
  BOTTOM w0.089: JCPU1.D11 169.26,89.45 v2(169.73,89.92)
  BOTTOM w0.102: JDIMM1.182 179.6,32.42 v2(180.29,33.11)
DDR_A_D62: length 72.9
  IN4 w0.089: v2(171.71,90.83) 172.03,90.51 173.59,90.51
  IN4 w0.102: 173.59,90.51 176.41,90.51 184.43,82.49 184.43,79.38 180.23,75.19 180.23,49.48 184.74,44.97 184.74,42.46 184.43,42.16 184.43,35.04 v2(184.03,34.64)
  BOTTOM w0.089: v2(171.71,90.83) 171.33,90.45 JCPU1.B12
  BOTTOM w0.102: v2(184.03,34.64) 182.6,33.21 JDIMM1.192
DDR_A_D63: length 72.3
  IN4 w0.089: 173.59,90.92 v2(172.73,90.92)
  IN4 w0.102: v2(184.03,33.11) 184.74,33.83 184.74,42.03 185.04,42.34 185.04,45.09 180.54,49.6 180.54,75.06 184.73,79.26 184.73,82.62 176.43,90.92 173.59,90.92
  BOTTOM w0.089: JCPU1.A12 172.26,90.45 v2(172.73,90.92)
  BOTTOM w0.102: JDIMM1.194 183.2,32.29 v2(184.03,33.11)
DDR_A_DQS0: length 76.4
  IN4 w0.089: 136,91.08 136.24,91.33 137.97,91.33 138.32,91.67 138.32,92.24 138.49,92.41 138.72,92.41 138.82,92.31 138.82,92 v2(138.73,91.92)
  IN4 w0.102: v2(124.87,35.02) 124.63,34.78 124.51,34.78 124.38,34.91 124.38,44.33 127.34,47.29 127.34,66.89 129.48,69.04 129.48,69.96 129.14,70.31 127.43,70.31 127.34,70.4 127.34,71.95 124.55,74.73 124.55,78.96 129.55,83.96 129.55,84.64 136,91.08
  BOTTOM w0.089: v2(138.73,91.92) 139.2,92.39 JCPU1.AP14
  BOTTOM w0.102: JDIMM1.12 126.2,32.05 126.01,32.23 126.01,32.6 125.65,32.97 125.65,34.45 125.41,34.68 125.2,34.68 v2(124.87,35.02)
DDR_A_DQS1: length 64.4
  IN4 w0.089: 136,85.31 136.19,85.5 136.97,85.5 136.99,85.48 137.48,85.48 137.49,85.5 137.87,85.5 138.16,85.78 138.16,86.16 138.16,86.16 138.16,86.44 138.63,86.92 v2(138.73,86.92)
  IN4 w0.102: 136,85.31 133.59,82.89 133.59,67.02 133.26,66.69 131.88,66.69 131.34,66.15 131.34,65.76 131.57,65.53 133.46,65.53 133.59,65.4 133.59,65.05 133.46,64.92 133.12,64.92 132.86,64.67 132.86,63.87 132.71,63.72 132.25,63.72 132.1,63.87 132.1,64.72 131.87,64.95 131.06,64.95 130.79,64.68 130.79,63.28 131.01,63.07 131.35,63.07 131.48,62.94 131.48,62.45 131.35,62.32 131.02,62.32 130.79,62.09 130.79,45.29 130.21,44.7 130.07,44.7 129.99,44.78 129.71,44.78 129.35,44.41 129.35,44 129.66,43.69 129.66,43.43 129.22,42.99 129.08,42.99 v2(128.85,43.22)
  BOTTOM w0.089: v2(138.73,86.92) 139.2,87.39 JCPU1.AP9
  BOTTOM w0.102: v2(128.85,43.22) 129.19,42.87 129.65,42.87 129.84,42.88 130.58,42.14 130.58,41.95 130.58,40.97 130.93,40.62 130.93,40.39 131.3,40.02 JDIMM1.29
DDR_A_DQS2: length 63.9
  IN4 w0.089: 137.69,77.36 137.69,79.26 138.13,79.71 138.13,81.16 138.48,81.51 138.94,81.51 139.14,81.71 139.14,82.17 139.48,82.51 139.9,82.51 140.14,82.75 140.14,83 140.13,83.01 140.13,83.18 140.47,83.52 140.94,83.52 141.13,83.72 141.13,84.01 141.13,84.17 141.47,84.51 141.72,84.51 141.92,84.51 142.13,84.73 142.13,85.14 142.48,85.48 142.48,85.48 142.49,85.5 142.95,85.5 143.21,85.76 143.21,85.85 143.15,85.92 v2(142.73,85.92)
  IN4 w0.102: 137.69,77.36 137.69,77.04 137.92,76.81 138.31,76.81 138.41,76.71 138.41,76.41 138.31,76.31 137.92,76.31 137.69,76.08 137.69,75.59 137.92,75.37 138.31,75.37 138.41,75.26 138.41,74.96 138.31,74.86 137.92,74.86 137.69,74.63 137.69,71.1 137.16,70.56 137.16,63 136.15,62 136.15,61.64 135.8,61.28 135.8,50.86 135.69,50.76 135.42,50.76 135.16,50.51 135.16,50.07 135.42,49.82 135.69,49.82 135.8,49.72 135.8,49.41 135.69,49.31 134.72,49.31 134.46,49.06 134.46,48.63 134.72,48.37 135.69,48.37 135.8,48.27 135.8,47.97 135.69,47.87 134.72,47.87 134.46,47.61 134.46,47.18 134.72,46.93 135.69,46.93 135.8,46.82 135.8,46.52 135.69,46.42 135.16,46.42 134.93,46.19 134.93,45.71 135.16,45.48 135.69,45.48 135.8,45.38 135.8,45.01 135.68,44.89 135.38,44.89 134.98,44.49 134.98,43.28 134.74,43.04 134.64,43.04 v2(134.46,43.22)
  BOTTOM w0.089: JCPU1.AK8 143.2,86.39 v2(142.73,85.92)
  BOTTOM w0.102: JDIMM1.47 136.7,40.02 136.51,40.21 136.51,40.46 135.94,41.03 135.94,42.75 135.75,42.94 134.74,42.94 v2(134.46,43.22)
DDR_A_DQS3: length 56.5
  IN4 w0.089: v2(145.73,80.92) 146.04,80.92 146.1,80.86 146.1,80.66 145.95,80.51 144.47,80.51 144.13,80.18 144.13,78.78 143,77.65 143,77.36
  IN4 w0.102: v2(140.23,35.02) 140.5,34.75 140.6,34.75 140.66,34.8 140.66,36.31 139.9,37.07 139.9,59.13 141.37,60.61 141.37,64.17 141.44,64.24 141.44,67.29 142.74,68.59 142.74,70.35 143,70.6 143,77.36
  BOTTOM w0.089: JCPU1.AG3 146.2,81.39 v2(145.73,80.92)
  BOTTOM w0.102: JDIMM1.64 141.8,32.05 141.61,32.23 141.61,32.5 141.31,32.81 141.31,34.33 140.86,34.79 140.46,34.79 v2(140.23,35.02)
DDR_A_DQS4: length 53.1
  IN4 w0.089: 165.73,77.48 166.33,78.09 166.33,80.16 165.98,80.51 165.52,80.51 165.33,80.7 165.33,80.97 165.4,81.05 165.61,81.05 v2(165.73,80.92)
  IN4 w0.102: 165.73,77.48 165.73,64.74 167.28,63.19 167.28,61.59 167.6,61.27 167.6,60.7 167.28,60.38 167.28,60.08 167.38,59.98 167.56,59.98 167.79,59.75 167.79,59.27 167.56,59.04 167.38,59.04 167.28,58.94 167.28,58.63 167.38,58.53 167.56,58.53 167.79,58.3 167.79,57.82 167.56,57.59 167.38,57.59 167.28,57.49 167.28,57.18 167.38,57.08 167.56,57.08 167.79,56.85 167.79,56.37 167.56,56.14 167.38,56.14 167.28,56.04 167.28,55.74 167.38,55.63 167.56,55.63 167.79,55.41 167.79,54.92 167.56,54.69 167.38,54.69 167.28,54.59 167.28,54.29 167.38,54.19 167.56,54.19 167.79,53.96 167.79,53.47 167.56,53.25 167.38,53.25 167.28,53.14 167.28,52.84 167.38,52.74 167.56,52.74 167.79,52.51 167.79,52.03 167.56,51.8 167.38,51.8 167.28,51.7 167.28,51.39 167.38,51.29 167.56,51.29 167.79,51.06 167.79,50.58 167.56,50.35 167.38,50.35 167.28,50.25 167.28,49.94 167.38,49.84 167.56,49.84 167.79,49.61 167.79,49.13 167.56,48.9 167.38,48.9 167.28,48.8 167.28,48.5 167.38,48.39 167.56,48.39 167.79,48.17 167.79,47.68 167.56,47.46 167.38,47.46 167.28,47.35 167.28,47.05 167.38,46.95 167.56,46.95 167.79,46.72 167.79,46.24 167.56,46.01 167.38,46.01 167.28,45.91 167.28,45.6 167.38,45.5 167.56,45.5 167.79,45.27 167.79,42.93 167.55,42.7 167.32,42.7 v2(167.08,42.46)
  BOTTOM w0.089: v2(165.73,80.92) JCPU1.H3
  BOTTOM w0.102: JDIMM1.137 166.1,40.42 166.1,40.42 166.1,42.43 166.38,42.71 166.82,42.71 v2(167.08,42.46)
DDR_A_DQS5: length 55.7
  IN4 w0.089: v2(168.73,81.92) 168.64,81.82 168.64,81.69 168.77,81.56 169.05,81.56 169.3,81.31 169.3,80.82 169.61,80.52 169.95,80.52 170.33,80.14 170.33,78.74 170.06,78.46 170.06,77.45 170.07,77.44 170.07,77.38 170.07,77.37 170.07,77.36
  IN4 w0.102: 170.07,77.36 170.07,65.44 171.98,63.54 171.98,44.75 172.56,44.17 172.56,37.19 171.79,36.41 171.79,34.76 171.56,34.53 171.37,34.53 v2(171.1,34.26)
  BOTTOM w0.089: v2(168.73,81.92) 168.26,81.45 JCPU1.E3
  BOTTOM w0.102: JDIMM1.154 171.2,31.93 170.92,32.21 170.92,32.46 170.61,32.78 170.61,34.36 170.77,34.52 170.84,34.52 v2(171.1,34.26)
DDR_A_DQS6: length 59.7
  IN4 w0.089: v2(170.73,84.92) 170.73,84.68 170.87,84.55 172.12,84.55 172.32,84.34 172.32,83.78 172.32,83.78 172.59,83.51 173.03,83.51 173.36,83.17 173.36,83.07 173.59,82.84
  IN4 w0.102: 173.59,82.84 173.86,82.58 173.86,76.12 174.07,75.91 174.07,75.43 173.77,75.12 173.77,74.77 173.96,74.58 174.23,74.58 174.52,74.87 175.17,74.87 175.54,74.49 175.54,73.89 175.29,73.64 173.96,73.64 173.86,73.54 173.86,73.15 173.96,73.05 175.32,73.05 175.54,72.82 175.54,72.33 175.32,72.11 173.96,72.11 173.86,72 173.86,71.67 173.97,71.55 175.29,71.55 175.54,71.3 175.54,47.5 177.73,45.31 177.73,44.67 178.3,44.09 178.3,43.13 177.97,42.8 177.87,42.8 v2(177.53,42.46)
  BOTTOM w0.089: JCPU1.C6 170.26,84.45 v2(170.73,84.92)
  BOTTOM w0.102: v2(177.53,42.46) 177.3,42.68 177.15,42.68 176.96,42.49 176.96,40.72 176.64,40.4 176.3,40.4 176.2,40.3 176.2,39.77 176.3,39.66 JDIMM1.171
DDR_A_DQS7: length 73.4
  IN4 w0.089: v2(170.73,90.92) 170.73,90.87 171.04,90.56 171.09,90.56 171.31,90.35 171.31,89.71 171.5,89.52 172.06,89.52 172.33,89.24 172.33,88.66 172.48,88.51 173.56,88.51 173.57,88.52 173.59,88.52
  IN4 w0.102: 173.59,88.52 175.52,88.52 176.11,87.92 176.26,87.92 176.51,88.18 176.87,88.18 177.18,87.87 177.18,87.51 176.92,87.25 176.92,87.11 177.43,86.6 177.43,84.24 177.43,82.88 177.43,82.88 177.43,79.65 179.11,77.97 179.11,49.01 183.07,45.06 183.07,37.64 183.19,37.52 183.37,37.52 183.62,37.26 183.62,36.71 183.37,36.46 182.57,36.46 182.44,36.33 182.44,35.9 182.57,35.78 183.28,35.78 183.54,35.52 183.54,34.8 183.28,34.54 182.11,34.54 v2(181.82,34.26)
  BOTTOM w0.089: v2(170.73,90.92) 170.26,90.45 JCPU1.C12
  BOTTOM w0.102: JDIMM1.188 181.4,31.89 181.21,32.08 181.21,34.18 181.47,34.43 181.65,34.43 v2(181.82,34.26)
DDR_A_DQS#0: length 76.4
  IN4 w0.089: v2(138.73,92.92) 138.73,92.77 138.57,92.61 138.41,92.61 138.12,92.33 138.12,91.76 137.89,91.53 136.14,91.53 136,91.39
  IN4 w0.102: 136,91.39 129.34,84.73 129.34,84.05 124.34,79.05 124.34,74.64 127.12,71.86 127.12,70.31 127.34,70.09 129.05,70.09 129.27,69.87 129.27,69.13 127.12,66.98 127.12,47.38 124.16,44.42 124.16,34.82 124.42,34.57 124.56,34.57 v2(124.87,34.26)
  BOTTOM w0.089: v2(138.73,92.92) 139.2,93.39 JCPU1.AP15
  BOTTOM w0.102: JDIMM1.10 125.6,32.05 125.79,32.23 125.79,32.51 125.42,32.87 125.42,34.35 125.32,34.45 125.07,34.45 v2(124.87,34.26)
DDR_A_DQS#1: length 64.3
  IN4 w0.089: v2(138.73,85.92) 138.73,86.43 138.67,86.5 138.5,86.5 138.36,86.36 138.36,86.08 138.36,86.08 138.36,85.76 138.36,85.76 138.36,85.7 137.95,85.29 137.58,85.29 137.56,85.28 136.9,85.28 136.89,85.29 136.29,85.29 136,85
  IN4 w0.102: v2(128.85,42.46) 128.99,42.46 129.88,43.34 129.88,43.78 129.56,44.09 129.56,44.32 129.8,44.56 129.9,44.56 129.98,44.49 130.3,44.49 131.01,45.2 131.01,62 131.11,62.1 131.44,62.1 131.69,62.36 131.69,63.03 131.44,63.28 131.1,63.28 131.01,63.37 131.01,64.59 131.15,64.73 131.78,64.73 131.89,64.63 131.89,63.78 132.16,63.5 132.8,63.5 133.08,63.78 133.08,64.58 133.21,64.71 133.55,64.71 133.8,64.96 133.8,65.49 133.55,65.75 131.66,65.75 131.55,65.85 131.55,66.06 131.97,66.47 133.35,66.47 133.8,66.93 133.8,82.8 136,85
  BOTTOM w0.089: JCPU1.AP8 139.2,86.39 v2(138.73,85.92)
  BOTTOM w0.102: v2(128.85,42.46) 129.04,42.65 129.75,42.65 130.35,42.04 130.35,40.88 130.7,40.52 JDIMM1.27
DDR_A_DQS#2: length 63.7
  IN4 w0.089: v2(143.73,85.92) 143.51,85.92 143.42,85.83 143.42,85.67 143.04,85.29 142.58,85.29 142.56,85.28 142.56,85.28 142.34,85.06 142.34,84.64 142,84.31 141.83,84.31 141.64,84.31 141.64,84.31 141.55,84.31 141.34,84.09 141.34,83.63 141.02,83.32 140.55,83.32 140.34,83.11 140.34,82.67 140,82.32 139.57,82.32 139.33,82.08 139.33,81.61 139.02,81.31 138.57,81.31 138.34,81.08 138.34,79.62 137.89,79.18 137.89,77.46 137.9,77.46 137.9,77.39 137.9,77.38 137.9,77.36
  IN4 w0.102: v2(134.46,42.46) 134.89,42.89 135.2,43.19 135.2,44.4 135.47,44.67 135.77,44.67 136.01,44.92 136.01,45.47 135.78,45.69 135.25,45.69 135.15,45.8 135.15,46.1 135.25,46.2 135.78,46.2 136.01,46.43 136.01,46.91 135.78,47.14 134.81,47.14 134.68,47.27 134.68,47.52 134.81,47.65 135.78,47.65 136.01,47.88 136.01,48.36 135.78,48.59 134.81,48.59 134.68,48.72 134.68,48.97 134.81,49.1 135.78,49.1 136.01,49.33 136.01,49.81 135.78,50.04 135.51,50.04 135.38,50.16 135.38,50.42 135.51,50.54 135.78,50.54 136.01,50.77 136.01,61.19 136.37,61.55 136.37,61.91 137.37,62.91 137.37,70.47 137.9,71.01 137.9,74.54 138.01,74.64 138.4,74.64 138.63,74.87 138.63,75.35 138.4,75.58 138.01,75.58 137.9,75.68 137.9,75.99 138.01,76.09 138.4,76.09 138.63,76.32 138.63,76.8 138.4,77.03 138.01,77.03 137.9,77.13 137.9,77.36
  BOTTOM w0.089: v2(143.73,85.92) 144.2,86.39 JCPU1.AJ8
  BOTTOM w0.102: v2(134.46,42.46) 134.72,42.71 135.65,42.71 135.71,42.65 135.71,40.94 136.29,40.36 136.29,40.21 136.1,40.02 JDIMM1.45
DDR_A_DQS#3: length 56.5
  IN4 w0.089: 143.21,77.36 143.21,77.38 143.21,77.39 143.21,77.57 144.34,78.7 144.34,80.09 144.56,80.32 146.04,80.32 146.29,80.57 146.29,80.78 146.44,80.92 v2(146.73,80.92)
  IN4 w0.102: 143.21,77.36 143.21,70.51 142.96,70.26 142.96,68.5 141.65,67.2 141.65,64.15 141.59,64.08 141.59,60.52 140.11,59.04 140.11,37.16 140.88,36.4 140.88,34.71 140.69,34.53 140.5,34.53 v2(140.23,34.26)
  BOTTOM w0.089: v2(146.73,80.92) 147.2,81.39 JCPU1.AF3
  BOTTOM w0.102: v2(140.23,34.26) 140.53,34.56 140.76,34.56 141.08,34.24 141.08,32.71 141.39,32.41 141.39,32.23 141.2,32.05 JDIMM1.62
DDR_A_DQS#4: length 53.1
  IN4 w0.089: v2(164.73,80.92) 165,80.92 165.11,80.81 165.11,80.61 165.4,80.32 165.9,80.32 166.14,80.08 166.14,78.2 165.61,77.67
  IN4 w0.102: 165.61,77.67 165.51,77.57 165.51,64.65 167.06,63.1 167.06,61.5 167.38,61.18 167.38,60.79 167.06,60.47 167.06,59.99 167.29,59.76 167.47,59.76 167.57,59.66 167.57,59.35 167.47,59.25 167.29,59.25 167.06,59.03 167.06,58.54 167.29,58.31 167.47,58.31 167.57,58.21 167.57,57.91 167.47,57.81 167.29,57.81 167.06,57.58 167.06,57.09 167.29,56.87 167.47,56.87 167.57,56.76 167.57,56.46 167.47,56.36 167.29,56.36 167.06,56.13 167.06,55.65 167.29,55.42 167.47,55.42 167.57,55.32 167.57,55.01 167.47,54.91 167.29,54.91 167.06,54.68 167.06,54.2 167.29,53.97 167.47,53.97 167.57,53.87 167.57,53.56 167.47,53.46 167.29,53.46 167.06,53.23 167.06,52.75 167.29,52.52 167.47,52.52 167.57,52.42 167.57,52.12 167.47,52.01 167.29,52.01 167.06,51.79 167.06,51.3 167.29,51.07 167.47,51.07 167.57,50.97 167.57,50.67 167.47,50.57 167.29,50.57 167.06,50.34 167.06,49.85 167.29,49.63 167.47,49.63 167.57,49.53 167.57,49.22 167.47,49.12 167.29,49.12 167.06,48.89 167.06,48.41 167.29,48.18 167.47,48.18 167.57,48.08 167.57,47.77 167.47,47.67 167.29,47.67 167.06,47.44 167.06,46.96 167.29,46.73 167.47,46.73 167.57,46.63 167.57,46.32 167.47,46.22 167.29,46.22 167.06,46 167.06,45.51 167.29,45.28 167.47,45.28 167.57,45.18 167.57,43.02 167.47,42.93 167.37,42.93 v2(167.08,43.22)
  BOTTOM w0.089: v2(164.73,80.92) JCPU1.J3
  BOTTOM w0.102: JDIMM1.135 165.5,40.28 165.87,40.65 165.87,42.53 166.28,42.94 166.8,42.94 v2(167.08,43.22)
DDR_A_DQS#5: length 55.8
  IN4 w0.089: v2(168.73,80.92) 168.59,80.92 168.46,81.05 168.46,81.23 168.59,81.36 168.97,81.36 169.11,81.22 169.11,80.73 169.52,80.31 169.87,80.31 170.13,80.05 170.13,78.82 169.86,78.55 169.86,77.36
  IN4 w0.102: v2(171.1,35.02) 171.37,34.75 171.47,34.75 171.58,34.85 171.58,36.5 172.35,37.28 172.35,44.08 171.76,44.66 171.76,63.45 169.86,65.35 169.86,77.36
  BOTTOM w0.089: v2(168.73,80.92) 168.26,80.45 JCPU1.E2
  BOTTOM w0.102: v2(171.1,35.02) 170.83,34.75 170.67,34.75 170.38,34.45 170.38,32.68 170.7,32.37 170.7,32.11 170.6,32.02 JDIMM1.152
DDR_A_DQS#6: length 59.7
  IN4 w0.089: 173.24,82.89 173.16,82.96 173.16,83.07 172.94,83.29 172.51,83.29 172.12,83.69 172.12,84.26 172.03,84.34 170.66,84.34 170.58,84.26 170.58,84.07 v2(170.73,83.92)
  IN4 w0.102: 173.24,82.89 173.64,82.49 173.64,76.03 173.86,75.82 173.86,75.51 173.55,75.21 173.55,74.68 173.87,74.36 174.32,74.36 174.61,74.65 175.08,74.65 175.33,74.4 175.33,73.98 175.2,73.85 173.87,73.85 173.64,73.63 173.64,73.06 173.87,72.83 175.23,72.83 175.33,72.73 175.33,72.42 175.23,72.32 173.87,72.32 173.64,72.09 173.64,71.58 173.88,71.34 175.2,71.34 175.33,71.21 175.33,47.41 177.52,45.22 177.52,44.58 178.09,44 178.09,43.22 177.88,43.01 177.73,43.01 v2(177.53,43.22)
  BOTTOM w0.089: JCPU1.C5 170.26,83.45 v2(170.73,83.92)
  BOTTOM w0.102: v2(177.53,43.22) 177.25,42.94 177.08,42.94 176.73,42.59 176.73,40.81 176.55,40.63 176.2,40.63 176.03,40.46 176.03,40.46 175.7,40.13 JDIMM1.169
DDR_A_DQS#7: length 73.3
  IN4 w0.089: v2(170.73,89.92) 170.73,90.27 170.82,90.36 171.01,90.36 171.12,90.25 171.12,89.62 171.4,89.33 171.96,89.33 172.14,89.15 172.14,88.56 172.4,88.31 173.56,88.31 173.57,88.3 173.59,88.3
  IN4 w0.102: v2(181.82,35.02) 181.82,35.02 182.08,34.76 183.19,34.76 183.32,34.89 183.32,35.43 183.19,35.56 182.48,35.56 182.22,35.81 182.22,36.42 182.48,36.68 183.28,36.68 183.41,36.8 183.41,37.17 183.28,37.3 183.1,37.3 182.85,37.55 182.85,44.97 178.9,48.92 178.9,77.88 177.21,79.56 177.21,82.97 177.21,86.51 176.7,87.02 176.7,87.34 176.96,87.6 176.96,87.78 176.78,87.96 176.6,87.96 176.34,87.7 176.02,87.7 175.43,88.3 173.59,88.3
  BOTTOM w0.089: v2(170.73,89.92) 170.26,89.45 JCPU1.C11
  BOTTOM w0.102: JDIMM1.186 180.8,31.89 180.98,32.07 180.98,34.27 181.4,34.68 181.53,34.68 181.82,34.97 v2(181.82,35.02)
DDR_A_MA0: length 57.5
  IN4 w0.089: v2(154.73,85.92) 154.33,85.52 154.33,79.06 155.14,78.26 155.14,77.36
  IN4 w0.165: 155.14,77.36 155.14,69.89 154.73,69.48 154.73,41.52 155.48,40.77 155.48,36.09 155.38,35.99 155.38,34.53 154.73,33.88 v2(154.73,33.88)
  BOTTOM w0.089: JCPU1.V8 155.2,86.39 v2(154.73,85.92)
  BOTTOM w0.165: v2(154.73,33.88) 154.73,33.75 155.18,33.3 155.18,32.65 154.4,31.87 JDIMM1.98
DDR_A_MA1: length 67
  IN4 w0.089: 153.65,77.36 153.65,78.11 153.14,78.61 153.14,83.16 152.78,83.52 150.57,83.52 150.17,83.92 v2(149.73,83.92)
  IN4 w0.165: v2(152.98,43.6) 152.98,43.4 152.85,43.28 152.52,43.28 152.4,43.4 152.4,45.53 151.81,46.11 151.81,47.37 151.68,47.5 151.26,47.5 151.13,47.37 151.13,46.87 151.03,46.77 150.59,46.77 150.49,46.87 150.49,48.13 150.58,48.22 151.79,48.22 151.89,48.33 151.89,48.73 151.79,48.83 150.59,48.83 150.49,48.94 150.49,49.34 150.59,49.44 151.79,49.44 151.89,49.55 151.89,49.95 151.79,50.05 150.66,50.05 150.5,50.21 150.5,50.51 150.66,50.66 151.79,50.66 151.89,50.76 151.89,51.17 151.79,51.27 150.66,51.27 150.5,51.43 150.5,51.73 150.66,51.88 151.79,51.88 151.89,51.98 151.89,52.39 151.79,52.49 151.27,52.49 151.16,52.59 151.16,53.09 151.27,53.19 152.11,53.19 152.31,53.38 153.14,53.38 153.24,53.48 153.24,73.27 153.65,73.68 153.65,77.36
  BOTTOM w0.089: JCPU1.AC6 150.2,84.39 v2(149.73,83.92)
  BOTTOM w0.165: JDIMM1.97 154.1,40.36 154.41,40.67 154.41,42.43 154.51,42.53 155.15,42.53 155.26,42.63 155.26,43.5 155.15,43.6 v2(152.98,43.6)
DDR_A_MA2: length 77.8
  IN4 w0.089: 154.64,77.36 154.64,78.38 154.14,78.88 154.14,85.9 154.57,86.32 155.48,86.32 155.73,86.58 v2(155.73,86.92)
  IN4 w0.165: v2(154.73,35.4) 154.73,35.6 154.61,35.72 154.31,35.72 154.18,35.6 154.18,32.58 154.05,32.45 153.62,32.45 153.49,32.58 153.49,36.49 153.62,36.62 154.84,36.62 154.97,36.75 154.97,37.1 154.84,37.23 153.56,37.23 153.44,37.36 153.44,37.71 153.56,37.84 154.84,37.84 154.97,37.97 154.97,38.32 154.84,38.45 152.57,38.45 152.45,38.57 152.45,38.92 152.57,39.04 154.84,39.04 154.97,39.17 154.97,39.53 154.84,39.65 153.58,39.65 153.45,39.78 153.45,40.14 153.59,40.28 154.64,40.28 154.76,40.4 154.76,40.76 154.23,41.29 154.23,72.86 154.64,73.27 154.64,77.36
  BOTTOM w0.089: v2(155.73,86.92) JCPU1.V9
  BOTTOM w0.165: v2(154.73,35.4) 154.08,34.75 154.08,32.32 153.8,32.04 JDIMM1.96
DDR_A_MA3: length 77.2
  IN4 w0.089: 154.14,77.36 154.14,77.94 153.33,78.75 153.33,86.44 153.44,86.55 155.18,86.55 155.28,86.65 155.28,87.19 155.38,87.29 156.63,87.29 156.72,87.2 v2(156.72,86.93)
  IN4 w0.165: v2(152.98,42.08) 152.98,42.31 152.88,42.41 152.49,42.41 152.38,42.31 152.38,40.89 152.49,40.78 153.63,40.78 153.74,40.89 153.74,42.33 153.49,42.58 153.49,42.94 153.74,43.19 153.74,43.61 153.63,43.71 153.52,43.71 153.43,43.8 153.43,44.17 153.74,44.47 153.74,44.84 153.62,44.96 153.02,44.96 152.89,45.09 152.89,45.44 153.02,45.57 153.63,45.57 153.74,45.67 153.74,46.08 153.63,46.18 152.45,46.18 152.32,46.31 152.32,46.66 152.45,46.79 153.63,46.79 153.74,46.89 153.74,47.3 153.63,47.4 152.42,47.4 152.29,47.53 152.29,47.88 152.42,48.01 153.63,48.01 153.74,48.11 153.74,48.52 153.63,48.62 152.51,48.62 152.38,48.75 152.38,49.1 152.51,49.23 153.63,49.23 153.74,49.33 153.74,49.74 153.63,49.84 152.51,49.84 152.38,49.97 152.38,50.32 152.51,50.45 153.63,50.45 153.74,50.55 153.74,50.96 153.63,51.06 152.51,51.06 152.38,51.18 152.38,51.54 152.51,51.67 153.63,51.67 153.74,51.77 153.74,52.17 153.63,52.28 152.51,52.28 152.38,52.4 152.38,52.76 152.51,52.89 153.61,52.89 153.74,53.01 153.74,73.07 154.14,73.48 154.14,77.36
  BOTTOM w0.089: v2(156.72,86.93) 156.2,87.44 JCPU1.U9
  BOTTOM w0.165: JDIMM1.95 153.5,39.94 152.89,40.55 152.89,40.77 152.99,40.87 153.81,40.87 153.91,40.97 153.91,42.29 153.81,42.39 153.3,42.39 v2(152.98,42.08)
DDR_A_MA4: length 67.9
  IN4 w0.089: v2(150.73,82.92) 151.37,82.92 152.33,81.96 152.33,78.73 153.15,77.9 153.15,77.36
  IN4 w0.165: v2(152.98,35.4) 152.68,35.4 152.55,35.27 152.55,34.8 152.42,34.67 152.02,34.67 151.89,34.8 151.89,36 152.02,36.13 152.33,36.13 152.46,36.26 152.46,36.65 152.33,36.78 152.02,36.78 151.89,36.9 151.89,37.28 152.02,37.41 152.32,37.41 152.45,37.54 152.45,37.88 152.32,38.01 152.02,38.01 151.89,38.14 151.89,39.43 152.02,39.55 152.82,39.55 152.94,39.68 152.94,40.15 152.82,40.28 152.02,40.28 151.89,40.4 151.89,45.34 151.3,45.92 151.3,46.08 151.11,46.27 150.39,46.27 150,46.66 150,52.27 150.1,52.37 150.57,52.37 150.67,52.47 150.67,52.84 150.54,52.97 150.12,52.97 150,53.1 150,53.37 150.31,53.68 151.91,53.68 152.1,53.88 152.64,53.88 152.74,53.98 152.74,73.48 153.15,73.89 153.15,77.36
  BOTTOM w0.089: v2(150.73,82.92) JCPU1.AC5
  BOTTOM w0.165: v2(152.98,35.4) 153.83,36.25 153.98,36.25 154.36,35.87 154.36,35.73 153.59,34.96 153.59,32.71 152.6,31.73 JDIMM1.92
DDR_A_MA5: length 69.5
  IN4 w0.089: 152.16,77.36 152.16,78.25 151.95,78.46 151.95,81.61 151.23,82.33 150.32,82.33 150.14,82.51 149.81,82.51 149.74,82.58 149.74,82.91 v2(149.73,82.92)
  IN4 w0.165: 152.16,77.36 152.16,75.95 151.7,75.48 151.7,75.25 151.8,75.15 152.06,75.15 152.14,75.07 152.14,74.7 151.99,74.55 151.86,74.55 151.73,74.68 150.9,74.68 150.8,74.58 150.8,74.1 150.9,74 151.65,74 151.75,73.9 151.75,73.51 151.65,73.41 150.9,73.41 150.8,73.3 150.8,72.86 150.9,72.76 151.65,72.76 151.75,72.66 151.75,72.2 151.65,72.1 151.47,72.1 151.37,72 151.37,71.54 151.47,71.44 151.65,71.44 151.75,71.33 151.75,70.88 151.65,70.78 151.47,70.78 151.37,70.67 151.37,70.22 151.47,70.12 151.65,70.12 151.75,70.01 151.75,69.56 151.65,69.46 151.47,69.46 151.37,69.35 151.37,68.9 151.47,68.79 151.65,68.79 151.75,68.69 151.75,68.03 151.65,67.93 151.24,67.93 151.14,67.83 151.14,67.35 151.24,67.25 151.65,67.25 151.75,67.14 151.75,61.81 151.65,61.7 151.3,61.7 151.2,61.6 151.2,61.13 151.3,61.02 151.65,61.02 151.75,60.92 151.75,60.47 151.65,60.36 150.9,60.36 150.8,60.26 150.8,59.8 150.9,59.7 151.65,59.7 151.75,59.6 151.75,59.14 151.65,59.04 150.9,59.04 150.8,58.94 150.8,58.48 150.9,58.38 151.65,58.38 151.75,58.28 151.75,57.82 151.65,57.72 150.9,57.72 150.8,57.62 150.8,57.16 150.9,57.06 151.65,57.06 151.75,56.96 151.75,56.5 151.65,56.4 150.9,56.4 150.8,56.3 150.8,55.87 150.9,55.77 151.65,55.77 151.75,55.66 151.75,54.93 151.5,54.67 151.1,54.67 151,54.77 151,55.11 150.9,55.21 150.48,55.21 150.37,55.11 150.37,54.77 150.27,54.67 149.9,54.67 148.98,53.75 148.98,45.89 149.77,45.1 150.02,45.1 150.21,45.28 150.54,45.28 150.89,44.94 150.89,43.4 150.74,43.25 150.37,43.25 150.21,43.4 v2(150.21,43.6)
  BOTTOM w0.089: JCPU1.AC4 v2(149.73,82.92)
  BOTTOM w0.165: JDIMM1.91 152.3,44.1 151.99,44.41 151.03,44.41 v2(150.21,43.6)
DDR_A_MA6: length 69.3
  IN4 w0.089: v2(148.71,85) 149.33,84.37 149.33,83.79 149.63,83.5 149.75,83.5 150.22,83.03 150.22,82.91 150.6,82.52 151.31,82.52 152.14,81.69 152.14,78.59 152.66,78.08 152.66,77.36
  IN4 w0.165: v2(152.98,33.88) 152.63,33.88 152.52,33.77 152.52,32.69 152.4,32.56 151.31,32.56 151.18,32.69 151.18,33.16 151.31,33.28 151.7,33.28 151.8,33.39 151.8,33.86 151.7,33.96 151.48,33.96 151.38,34.06 151.38,34.5 151.27,34.6 150.85,34.6 150.72,34.73 150.72,35.16 150.85,35.29 151.25,35.29 151.38,35.42 151.38,35.8 151.25,35.93 150.8,35.93 150.67,36.05 150.67,36.51 150.8,36.64 151.25,36.64 151.38,36.76 151.38,37.12 151.25,37.25 150.8,37.25 150.67,37.37 150.67,37.74 150.8,37.87 151.25,37.87 151.38,38 151.38,45.14 150.75,45.78 149.79,45.78 149.49,46.08 149.49,53.56 150.11,54.18 151.7,54.18 152.25,54.73 152.25,73.68 152.66,74.09 152.66,77.36
  BOTTOM w0.089: JCPU1.AD6 149.2,84.5 v2(148.71,85)
  BOTTOM w0.165: v2(152.98,33.88) 152,32.9 JDIMM1.90
DDR_A_MA7: length 69.2
  IN4 w0.089: 151.17,77.36 151.17,77.89 151.57,78.29 151.57,80.9 151.14,81.33 150.29,81.33 149.73,81.89 v2(149.73,81.92)
  IN4 w0.165: 151.17,77.36 151.17,76.36 149.8,74.99 149.8,72.45 150.38,71.87 150.38,68.63 149.8,68.05 149.8,67.28 150.2,66.88 150.2,66.62 150.76,66.06 150.76,62.79 150.2,62.23 150.2,61.07 149.8,60.67 149.8,58.47 149.38,58.04 149.38,57.47 149.11,57.2 148.54,57.2 148.15,56.81 148.15,56 148.02,55.88 146.7,55.88 146.57,55.75 146.57,53.11 146.67,53.01 147.86,53.01 147.96,52.91 147.96,45.49 149.14,44.31 149.14,40.52 149.3,40.36 150.78,40.36 150.89,40.26 150.89,39.74 150.78,39.63 149.19,39.63 149.08,39.53 149.08,39.14 149.19,39.04 150.78,39.04 150.89,38.94 150.89,38.47 150.78,38.36 149.34,38.36 149.23,38.26 149.23,37.86 149.34,37.75 149.63,37.75 149.76,37.63 149.76,37.26 149.63,37.13 149.34,37.13 149.23,37.03 149.23,36.62 149.34,36.52 149.63,36.52 149.76,36.4 149.76,35.91 149.63,35.79 149.34,35.79 149.23,35.68 149.23,35.18 149.34,35.08 150.09,35.08 150.21,35.2 v2(150.21,35.4)
  BOTTOM w0.089: v2(149.73,81.92) JCPU1.AC3
  BOTTOM w0.165: JDIMM1.86 150.8,31.82 151.18,32.19 151.18,34.44 v2(150.21,35.4)
DDR_A_MA8: length 70.3
  IN4 w0.089: 151.67,77.36 151.67,78.06 151.76,78.16 151.76,81.34 151.58,81.52 150.45,81.52 150.27,81.7 150.27,81.91 149.87,82.32 149.63,82.32 149.36,82.59 149.36,83.3 148.75,83.91 v2(148.75,83.96)
  IN4 w0.165: 151.67,77.36 151.67,76.15 151.2,75.69 151.2,75.3 151.08,75.18 150.69,75.18 150.3,74.79 150.3,72.66 150.88,72.08 150.88,68.42 150.3,67.84 150.3,67.49 150.7,67.09 150.7,66.86 150.8,66.76 151.16,66.76 151.26,66.66 151.26,62.28 151.16,62.18 150.85,62.18 150.7,62.03 150.7,60.87 150.3,60.47 150.3,58.08 150.19,57.96 150,57.96 149.87,57.83 149.87,57.43 149.94,57.35 150.17,57.35 150.3,57.23 150.3,56.81 150.2,56.71 148.74,56.71 148.64,56.6 148.64,56.16 148.74,56.06 150.15,56.06 150.29,55.92 150.29,55.73 149.67,55.11 149.39,55.11 149.04,55.46 148.79,55.46 148.57,55.24 148.57,55 148.89,54.69 148.89,54.43 148.62,54.15 148.09,54.15 147.93,54.32 147.93,55.19 147.73,55.38 147.27,55.38 147.07,55.18 147.07,53.61 147.17,53.5 148.37,53.5 148.47,53.4 148.47,45.7 149.64,44.53 149.64,41.01 149.79,40.86 150.75,40.86 150.87,40.98 150.87,42.31 150.77,42.41 150.55,42.41 v2(150.21,42.08)
  BOTTOM w0.089: v2(148.75,83.96) 149.2,83.5 JCPU1.AD5
  BOTTOM w0.165: v2(150.21,42.08) 150.21,41.85 150.32,41.75 150.64,41.75 150.74,41.85 150.74,43.32 150.85,43.42 151.6,43.42 151.7,43.32 JDIMM1.89
DDR_A_MA9: length 68
  IN4 w0.089: v2(149.73,80.92) 150.09,80.92 150.16,80.85 150.16,77.36
  IN4 w0.165: v2(147.72,43.6) 147.19,43.07 147.06,43.07 146.78,43.34 146.57,43.34 146.22,43.7 146.22,43.88 146.51,44.17 146.69,44.17 146.85,44.02 147.14,44.02 147.27,44.14 147.27,44.59 146.96,44.9 146.96,45.34 146.83,45.47 146.48,45.47 146.35,45.34 146.35,44.87 146.2,44.72 145.94,44.72 145.58,45.07 145.58,46 145.68,46.1 146.86,46.1 146.96,46.2 146.96,46.62 146.86,46.72 145.71,46.72 145.58,46.85 145.58,47.25 145.71,47.38 146.86,47.38 146.96,47.48 146.96,47.94 146.86,48.04 145.68,48.04 145.58,48.14 145.58,48.6 145.68,48.7 146.86,48.7 146.96,48.8 146.96,49.24 146.86,49.34 145.68,49.34 145.58,49.44 145.58,49.92 145.68,50.02 146.86,50.02 146.96,50.12 146.96,50.61 146.86,50.71 145.71,50.71 145.58,50.84 145.58,51.26 145.68,51.36 146.86,51.36 146.96,51.46 146.96,51.92 146.86,52.02 145.68,52.02 145.58,52.12 145.58,56.67 146.18,57.26 146.56,57.26 146.69,57.39 146.69,57.77 147.1,58.19 148.13,58.19 148.81,58.88 148.81,61.08 149.21,61.48 149.21,62.65 149.77,63.2 149.77,65.65 149.21,66.21 149.21,66.47 148.81,66.87 148.81,68.46 149.39,69.04 149.39,71.46 148.81,72.04 148.81,75.4 150.16,76.75 150.16,77.36
  BOTTOM w0.089: v2(149.73,80.92) JCPU1.AC2
  BOTTOM w0.165: JDIMM1.85 150.5,40.12 149.72,40.9 149.72,44 149.45,44.27 148.39,44.27 v2(147.72,43.6)
DDR_A_MA10: length 71.6
  IN4 w0.089: 158.11,77.36 158.11,78.48 158.13,78.51 158.13,82.37 157.99,82.51 156.53,82.51 156.3,82.74 156.3,84.35 v2(155.69,84.96)
  IN4 w0.165: 158.11,77.36 158.11,73.27 157.73,72.89 157.73,70.36 158.11,69.98 158.11,66.83 157.73,66.45 157.73,63.93 158.11,63.54 158.11,61.84 158.21,61.73 158.84,61.73 158.95,61.63 158.95,61.24 158.84,61.14 158.21,61.14 158.11,61.04 158.11,60.64 158.21,60.54 158.86,60.54 158.96,60.44 158.96,59.95 158.86,59.85 158.68,59.85 158.58,59.75 158.58,59.27 158.68,59.17 158.78,59.17 158.96,58.99 158.96,53.05 158.45,52.54 158.45,44.7 158.17,44.42 158.17,42.42 158.26,42.33 158.26,41.39 158.45,41.2 158.45,40.73 158.35,40.63 157.91,40.63 157.81,40.53 157.81,39.66 157.7,39.56 157.53,39.56 157.42,39.46 157.42,38.89 157.53,38.79 158.75,38.79 158.91,38.63 158.91,36.98 158.81,36.88 158.32,36.88 158.22,36.98 158.22,38.01 158.12,38.11 157.21,38.11 156.77,38.55 156.77,40.14 157.18,40.54 157.18,41.97 157.29,42.08 v2(157.68,42.08)
  BOTTOM w0.089: JCPU1.V6 155.2,84.47 v2(155.69,84.96)
  BOTTOM w0.165: JDIMM1.107 157.1,40.31 157,40.41 156.49,40.41 156.38,40.51 156.38,40.96 156.49,41.06 156.98,41.06 157.08,41.16 157.08,41.64 156.98,41.74 156.54,41.74 156.44,41.85 156.44,42.98 156.54,43.08 157.13,43.08 157.23,42.98 157.23,42.42 157.34,42.32 157.44,42.32 v2(157.68,42.08)
DDR_A_MA11: length 66.3
  IN4 w0.089: 149.67,77.36 149.67,78.85 v2(149.73,78.92)
  IN4 w0.165: v2(150.21,33.88) 150.21,33.94 150.43,34.16 150.61,34.16 150.94,33.83 150.94,33.65 150.67,33.39 150.67,31.61 150.57,31.51 148.83,31.51 148.73,31.61 148.73,32.5 148.83,32.6 149.68,32.6 149.78,32.7 149.78,33.16 149.68,33.26 148.7,33.26 148.57,33.39 148.57,33.82 148.7,33.95 149.39,33.95 149.51,34.07 149.51,34.45 149.39,34.58 148.87,34.58 148.74,34.71 148.74,38.46 148.64,38.56 146.85,38.56 146.75,38.66 146.75,42.67 146.57,42.85 146.37,42.85 145.64,43.57 145.64,44.31 145.09,44.87 145.09,56.87 146.9,58.69 147.92,58.69 148.32,59.08 148.32,61.29 148.72,61.69 148.72,66.27 148.32,66.67 148.32,68.66 148.9,69.24 148.9,71.26 148.32,71.83 148.32,75.61 149.67,76.95 149.67,77.36
  BOTTOM w0.089: v2(149.73,78.92) 150.2,79.39 JCPU1.AC1
  BOTTOM w0.165: JDIMM1.84 150.2,32.01 150.67,32.47 150.67,33.65 150.45,33.88 v2(150.21,33.88)
DDR_A_MA12: length 70
  IN4 w0.089: 150.68,77.36 150.68,78.23 150.78,78.33 151.18,78.33 151.28,78.43 151.28,80.87 151.14,81.01 150.3,81.01 149.99,81.32 149.26,81.32 149.14,81.43 149.14,82.82 149.05,82.91 v2(148.68,82.91)
  IN4 w0.165: v2(147.72,42.08) 147.72,42.18 147.6,42.3 147.38,42.3 147.26,42.18 147.26,41.06 147.46,40.86 147.46,40.59 147.26,40.39 147.26,39.23 147.43,39.05 148.46,39.05 148.59,39.18 148.59,39.49 148.46,39.62 147.96,39.62 147.84,39.74 147.84,40.1 147.96,40.22 148.51,40.22 148.64,40.35 148.64,40.71 148.51,40.83 148.26,40.83 148.16,40.94 148.16,41.34 148.26,41.44 148.5,41.44 148.62,41.57 148.62,41.96 148.5,42.09 148.45,42.09 148.29,42.24 148.29,42.62 148.38,42.71 148.48,42.71 148.61,42.83 148.61,43.28 148.48,43.41 148.32,43.41 148.22,43.51 148.22,43.82 148.45,44.05 148.45,44.28 147.46,45.28 147.46,52.39 147.33,52.51 146.24,52.51 146.08,52.67 146.08,56.46 146.37,56.76 146.59,56.76 146.98,56.37 147.53,56.37 147.65,56.5 147.65,56.9 147.53,57.02 147.31,57.02 147.18,57.15 147.18,57.57 147.31,57.7 148.75,57.7 148.88,57.82 148.88,58.24 149.31,58.67 149.31,60.88 149.71,61.28 149.71,62.44 150.27,63 150.27,65.86 149.71,66.41 149.71,66.68 149.31,67.08 149.31,68.25 149.89,68.83 149.89,71.67 149.31,72.25 149.31,75.2 150.68,76.56 150.68,77.36
  BOTTOM w0.089: JCPU1.AD4 149.14,82.45 v2(148.68,82.91)
  BOTTOM w0.165: v2(147.72,42.08) 148.27,42.62 148.27,42.99 148.37,43.09 149.12,43.09 149.22,42.99 149.22,41.95 149.12,41.85 148.59,41.85 148.49,41.74 148.49,41.27 148.59,41.17 149.12,41.17 149.22,41.07 149.22,40.7 149.9,40.02 JDIMM1.83
DDR_A_MA13: length 63.7
  IN4 w0.089: v2(155.7,85.95) 156.15,86.4 160.21,86.4 160.33,86.27 160.33,78.73 160.64,78.42 160.64,77.36
  IN4 w0.165: v2(162.05,43.6) 162.05,43.4 161.92,43.28 161.64,43.28 161.45,43.47 161.45,52.53 161.55,52.64 162.52,52.64 162.62,52.74 162.62,56.21 162.52,56.31 162.23,56.31 162.12,56.41 162.12,56.88 162.23,56.98 162.52,56.98 162.62,57.09 162.62,57.59 162.52,57.69 161.54,57.69 161.44,57.79 161.44,58.26 161.54,58.36 162.52,58.36 162.62,58.46 162.62,58.92 162.52,59.02 161.54,59.02 161.44,59.12 161.44,59.58 161.54,59.68 162.14,59.68 162.24,59.78 162.24,60.27 162.14,60.38 161.54,60.38 161.44,60.48 161.44,62.64 160.63,63.45 160.63,77.35 160.64,77.36
  BOTTOM w0.089: JCPU1.V7 v2(155.7,85.95)
  BOTTOM w0.165: v2(162.05,43.6) 161.6,44.04 161.6,44.28 161.5,44.39 160.99,44.39 160.89,44.28 160.89,40.97 160.79,40.87 160.35,40.87 160.24,40.77 160.24,40.36 160.7,39.9 JDIMM1.119
DDR_A_MA14: length 68.8
  IN4 w0.089: 148.47,77.36 148.46,77.37 148.46,78.5 148.59,78.63 148.73,78.63 148.85,78.75 148.85,79.93 148.98,80.06 149.21,80.06 149.33,80.19 149.33,80.97 148.9,81.41 148.67,81.41 148.55,81.54 148.55,81.76 148.67,81.88 v2(148.73,81.88)
  IN4 w0.165: v2(147.72,35.4) 147.72,35.19 147.85,35.06 148.1,35.06 148.23,35.19 148.23,37.93 148.1,38.06 147.39,38.06 147.25,37.92 147.25,35.72 147.13,35.6 146.81,35.6 146.68,35.72 146.68,37.56 146.55,37.69 145.05,37.69 144.65,38.09 144.65,43.9 144.1,44.46 144.1,57.29 145.55,58.74 145.55,62.11 146.03,62.6 146.26,62.6 146.41,62.45 147.58,62.45 147.73,62.6 147.73,65.86 147.33,66.26 147.33,69.08 147.91,69.65 147.91,70.85 147.33,71.42 147.33,76.02 148.45,77.14 148.45,77.15 148.5,77.19 148.5,77.33 148.47,77.36
  BOTTOM w0.089: JCPU1.AD3 149.17,81.45 v2(148.73,81.88)
  BOTTOM w0.165: JDIMM1.80 149,32.16 148.57,32.59 148.57,33.79 148.67,33.9 149.33,33.9 149.44,34 149.44,35.65 149.33,35.75 148.07,35.75 v2(147.72,35.4)
DDR_A_MA15: length 68.7
  IN4 w0.089: 147.97,77.36 148.14,77.53 148.14,78.87 148.62,79.35 148.62,80.86 v2(148.73,80.97)
  IN4 w0.165: v2(147.72,33.88) 147.28,33.44 147.28,32.73 147.41,32.6 148.1,32.6 148.23,32.47 148.23,32.04 148.1,31.91 144.64,31.91 144.51,32.04 144.51,32.55 144.64,32.68 145.93,32.68 146.06,32.8 146.06,33.55 146.19,33.68 146.61,33.68 146.73,33.81 146.73,34.23 146.61,34.35 146.3,34.35 146.17,34.48 146.17,37.05 146.05,37.18 144.86,37.18 144.15,37.89 144.15,43.69 143.6,44.23 143.6,57.49 145.06,58.94 145.06,62.32 146.01,63.27 146.29,63.27 146.61,62.95 147.14,62.95 147.23,63.04 147.23,65.65 146.83,66.05 146.83,69.28 147.41,69.86 147.41,70.64 146.83,71.22 146.83,76.22 147.97,77.36
  BOTTOM w0.089: JCPU1.AD2 149.2,80.5 v2(148.73,80.97)
  BOTTOM w0.165: JDIMM1.78 148.4,32 148.06,32.33 147.43,32.33 147.11,32.65 147.11,33.54 147.45,33.88 v2(147.72,33.88)
DDR_A_RAS#: length 68
  IN4 w0.089: v2(156.7,83.92) 157.1,83.52 158.76,83.52 159.13,83.15 159.13,77.39 159.1,77.36
  IN4 w0.165: v2(157.78,33.88) 157.78,33.73 157.32,33.27 157.32,32.4 157.21,32.29 155.75,32.29 155.65,32.19 155.65,31.46 155.75,31.36 159.8,31.36 159.9,31.46 159.9,39.04 159.44,39.5 159.44,41.73 159.25,41.92 159.25,42.8 159.17,42.89 159.17,44.01 159.44,44.29 159.44,52.13 159.95,52.64 159.95,62.03 159.1,62.88 159.1,77.36
  BOTTOM w0.089: v2(156.7,83.92) 156.2,84.41 JCPU1.U6
  BOTTOM w0.165: v2(157.78,33.88) 158.35,33.3 158.35,32.27 158,31.92 JDIMM1.110
DDR_A_WE#: length 63.7
  IN4 w0.089: 159.6,77.36 159.6,78.06 159.53,78.13 159.41,78.13 159.32,78.21 159.32,84.19 159.2,84.32 156.87,84.32 156.57,84.62 156.57,84.76 v2(156.73,84.92)
  IN4 w0.165: 159.6,77.36 159.6,63.08 160.45,62.23 160.45,57.09 160.61,56.93 160.9,56.93 161.13,56.7 161.13,56.39 161.01,56.27 160.55,56.27 160.45,56.17 160.45,55.71 160.55,55.61 161.53,55.61 161.63,55.51 161.63,55.05 161.53,54.95 160.59,54.95 160.46,54.82 160.46,54.41 160.59,54.29 161.5,54.29 161.63,54.16 161.63,53.75 161.5,53.63 160.61,53.63 160.45,53.46 160.45,51.95 160.28,51.79 160.07,51.79 159.94,51.66 159.94,51.03 160.07,50.9 160.33,50.9 160.46,50.77 160.46,50.37 160.33,50.24 160.07,50.24 159.94,50.11 159.94,49.71 160.07,49.58 160.33,49.58 160.46,49.45 160.46,49.05 160.33,48.92 160.07,48.92 159.94,48.79 159.94,48.38 160.07,48.26 160.33,48.26 160.46,48.13 160.46,47.72 160.33,47.6 160.07,47.6 159.94,47.47 159.94,47.06 160.07,46.94 160.33,46.94 160.46,46.81 160.46,46.4 160.33,46.28 160.07,46.28 159.94,46.15 159.94,45.66 160.07,45.53 160.33,45.53 160.46,45.4 160.46,45.06 160.33,44.93 160.07,44.93 159.94,44.81 159.94,44.08 159.66,43.8 159.66,43.14 159.79,43.01 159.95,43.01 160.22,43.28 160.27,43.28 160.4,43.4 v2(160.4,43.6)
  BOTTOM w0.089: v2(156.73,84.92) JCPU1.U7
  BOTTOM w0.165: v2(160.4,43.6) 160.12,43.6 160.02,43.7 160.02,44.14 159.91,44.24 159.36,44.24 159.25,44.14 159.25,42.94 159.01,42.69 158.76,42.69 158.66,42.59 158.66,41.81 158.76,41.71 159,41.71 159.15,41.55 159.15,40.5 158.9,40.24 JDIMM1.113
DDR_B_BS0: length 82.5
  IN1 w0.089: 156.24,77.86 155.84,78.27 155.52,78.27 154.32,79.47 154.32,80.08 154.58,80.33 155.15,80.33 155.32,80.5 155.32,82.62 156.22,83.52 157.9,83.52 158.14,83.76 158.14,84.53 158.53,84.92 v2(158.73,84.92)
  IN1 w0.165: 156.24,77.86 156.24,73.53 156.49,73.28 156.49,62.68 156.66,62.51 156.95,62.51 157.12,62.35 157.12,62.02 156.95,61.85 156.66,61.85 156.49,61.69 156.49,61.36 156.66,61.19 156.95,61.19 157.12,61.03 157.12,60.7 156.95,60.53 156.66,60.53 156.49,60.37 156.49,60.04 156.66,59.87 156.95,59.87 157.12,59.71 157.12,59.38 156.95,59.21 156.66,59.21 156.49,59.05 156.49,58.72 156.66,58.55 156.95,58.55 157.12,58.39 157.12,58.06 156.95,57.89 156.66,57.89 156.49,57.73 156.49,57.15 156.66,56.98 156.95,56.98 157.12,56.82 157.12,56.49 156.95,56.32 156.66,56.32 156.49,56.16 156.49,45.5 156.86,45.13 156.86,43.93 157.02,43.77 157.02,40.48 157.15,40.36 158.15,40.36 158.27,40.23 158.27,27.18 158.15,27.06 157.14,27.06 157.01,26.93 157.01,26.61 157.14,26.48 158.15,26.48 158.27,26.35 158.27,25.98 158.15,25.86 157.14,25.86 157.01,25.73 157.01,25.36 157.14,25.23 158.4,25.23 158.53,25.11 158.53,24.75 158.4,24.63 157.14,24.63 157.01,24.5 157.01,23.18 157.14,23.05 157.4,23.05 157.52,23.18 v2(157.52,23.4)
  BOTTOM w0.089: v2(158.73,84.92) JCPU1.R7
  BOTTOM w0.165: v2(157.52,23.4) 158.12,24 158.12,24.45 157.7,24.87 JDIMM2.109
DDR_B_BS1: length 84.9
  IN1 w0.089: 156.74,77.36 156.74,77.69 155.9,78.52 155.54,78.52 155.2,78.86 155.2,80.1 155.52,80.42 155.8,80.42 156.13,80.75 156.13,82.2 156.02,82.31 156.02,83.05 156.29,83.32 158.03,83.32 158.33,83.62 158.33,84.28 158.44,84.39 159.01,84.39 159.13,84.51 159.13,85.17 159.33,85.37 159.33,85.79 159.46,85.92 v2(159.73,85.92)
  IN1 w0.165: 156.74,77.36 156.74,73.73 156.99,73.48 156.99,63.11 157.11,62.98 157.49,62.98 157.61,62.85 157.61,55.98 157.49,55.85 157.11,55.85 156.99,55.73 156.99,45.71 158.19,44.5 158.19,44.26 158.43,44.02 158.64,44.02 158.77,43.89 158.77,43.41 158.64,43.28 158.24,43.28 158.12,43.16 158.12,42.75 158.24,42.62 158.64,42.62 158.77,42.5 158.77,42.09 158.64,41.96 158.24,41.96 158.12,41.84 158.12,41.38 158.24,41.25 158.64,41.25 158.77,41.12 158.77,25.57 159.02,25.31 159.02,24.26 158.89,24.13 158.15,24.13 158.02,24 158.02,23.67 158.15,23.55 158.91,23.55 159.03,23.42 159.03,23.04 158.91,22.91 158.11,22.91 157.98,22.78 157.98,22.4 158.11,22.28 158.91,22.28 159.03,22.15 159.03,20.78 158.91,20.65 158.24,20.65 158.11,20.78 158.11,21.58 157.98,21.7 157.65,21.7 157.52,21.83 v2(157.52,21.87)
  BOTTOM w0.089: v2(159.73,85.92) JCPU1.P8
  BOTTOM w0.165: JDIMM2.108 157.4,18.83 157.01,19.23 157.01,21.36 v2(157.52,21.87)
DDR_B_BS2: length 77.9
  IN1 w0.089: 146.33,77.36 146.33,78.28 146.33,78.28 146.33,86.05 146.56,86.28 146.62,86.28 147.26,86.92 147.26,86.98 147.69,87.41 151.22,87.41 v2(151.73,87.92)
  IN1 w0.165: v2(147.44,21.87) 147,22.31 147,23.6 145.3,25.3 145.3,26.79 144.67,27.42 144.67,48.61 144.38,48.9 144.38,61.05 144.87,61.55 144.87,67.73 146.33,69.19 146.33,77.36
  BOTTOM w0.089: v2(151.73,87.92) JCPU1.AA9
  BOTTOM w0.165: v2(147.44,21.87) 148,22.44 148,24.32 148.7,25.02 JDIMM2.79
DDR_B_CAS#: length 83.2
  IN1 w0.089: v2(159.73,84.92) 159.73,85.07 159.61,85.19 159.44,85.19 159.32,85.07 159.32,83.54 159.11,83.32 158.57,83.32 158.33,83.09 158.33,82.62 158.22,82.51 158.03,82.32 157.26,82.32 157.13,82.19 157.13,80.66 157.01,80.53 156.45,80.53 156.32,80.41 156.32,78.64 157.38,77.58 157.6,77.58 157.73,77.46 157.73,77.36
  IN1 w0.165: v2(160.35,28.22) 160.35,28.02 160.22,27.89 159.89,27.89 159.76,28.02 159.76,29.29 159.89,29.42 160.39,29.42 160.52,29.55 160.52,32.55 160.39,32.68 159.89,32.68 159.76,32.8 159.76,33.41 159.96,33.62 159.96,34.13 159.76,34.33 159.76,35.29 159.97,35.5 159.97,36.08 159.76,36.29 159.76,37.93 159.89,38.05 160.39,38.05 160.52,38.18 160.52,38.52 160.39,38.65 159.89,38.65 159.76,38.77 159.76,39.1 159.89,39.23 160.39,39.23 160.52,39.36 160.52,39.65 160.39,39.78 159.89,39.78 159.76,39.9 159.76,40.21 159.89,40.33 160.39,40.33 160.52,40.46 160.52,40.75 160.39,40.88 159.89,40.88 159.76,41 159.76,44.34 159.51,44.58 159.51,44.82 159.97,45.28 159.97,45.46 159.68,45.74 159.5,45.74 159.04,45.28 158.85,45.28 158.72,45.41 158.72,45.86 158.59,45.99 158.1,45.99 157.98,46.12 157.98,46.46 158.1,46.59 158.48,46.59 158.6,46.72 158.6,47.12 158.48,47.25 158.1,47.25 157.98,47.38 157.98,47.79 158.1,47.91 158.48,47.91 158.6,48.04 158.6,48.45 158.48,48.57 158.14,48.57 157.98,48.74 157.98,49.3 158.14,49.47 158.48,49.47 158.6,49.6 158.6,50 158.48,50.13 158.1,50.13 157.98,50.26 157.98,50.66 158.1,50.79 158.48,50.79 158.6,50.92 158.6,51.32 158.48,51.45 158.1,51.45 157.98,51.58 157.98,51.98 158.1,52.11 158.48,52.11 158.6,52.24 158.6,52.64 158.48,52.77 158.1,52.77 157.98,52.9 157.98,53.3 158.1,53.43 158.48,53.43 158.6,53.56 158.6,53.96 158.48,54.09 158.1,54.09 157.98,54.22 157.98,54.77 158.1,54.9 158.48,54.9 158.6,55.02 158.6,63.71 158.44,63.87 158.2,63.87 157.98,64.09 157.98,64.95 158.22,65.19 158.22,66.25 158.4,66.43 158.4,66.75 158.28,66.88 158.1,66.88 157.98,67 157.98,67.32 158.1,67.45 158.48,67.45 158.6,67.58 158.6,67.93 158.48,68.06 158.1,68.06 157.98,68.19 157.98,68.59 158.1,68.72 158.48,68.72 158.6,68.85 158.6,69.15 158.48,69.28 158.1,69.28 157.98,69.41 157.98,69.71 158.1,69.84 158.48,69.84 158.6,69.96 158.6,70.23 158.48,70.35 158.1,70.35 157.98,70.48 157.98,72.81 158.1,72.94 158.27,72.94 158.4,73.07 158.4,73.47 158.27,73.6 158.1,73.6 157.98,73.73 157.98,73.89 157.73,74.14 157.73,77.36
  BOTTOM w0.089: v2(159.73,84.92) JCPU1.P7
  BOTTOM w0.165: JDIMM2.115 159.5,27.37 v2(160.35,28.22)
DDR_B_D0: length 89.8
  IN1 w0.089: 136,95.15 136.26,95.41 137.23,95.41 v2(137.73,95.92)
  IN1 w0.102: v2(123.02,23.94) 122.86,23.94 122.35,24.45 122.35,25.69 120.47,27.57 120.47,32.99 119.74,33.72 119.74,38.3 121.74,40.3 121.74,47.89 122.16,48.31 122.16,60.4 122.35,60.59 122.35,60.93 122.22,61.06 121.81,61.06 121.69,61.19 121.69,61.53 121.81,61.66 122.22,61.66 122.35,61.79 122.35,62.08 122.25,62.18 121.78,62.18 121.68,62.28 121.68,62.58 121.78,62.69 122.25,62.69 122.35,62.79 122.35,63.09 122.25,63.19 121.78,63.19 121.68,63.3 121.68,63.6 121.78,63.7 122.25,63.7 122.35,63.8 122.35,64.11 122.25,64.21 121.78,64.21 121.68,64.31 121.68,64.62 121.78,64.72 122.25,64.72 122.35,64.82 122.35,65.33 122.23,65.45 121.84,65.45 121.74,65.55 121.74,80.89 136,95.15
  BOTTOM w0.089: JCPU1.AR18 138.2,96.39 v2(137.73,95.92)
  BOTTOM w0.102: JDIMM2.5 124.1,25.02 v2(123.02,23.94)
DDR_B_D1: length 88.4
  IN1 w0.089: 136,95.62 136.3,95.92 v2(136.73,95.92)
  IN1 w0.102: 136,95.62 121.37,81 121.37,40.4 119.44,38.47 119.44,33.52 120.15,32.8 120.15,27.46 120.89,26.72 120.89,25.81 120.99,25.71 121.34,25.71 121.47,25.58 121.47,25.32 121.34,25.2 120.99,25.2 120.89,25.1 120.89,24.55 v2(123.02,22.41)
  BOTTOM w0.089: v2(136.73,95.92) 137.2,96.39 JCPU1.AT18
  BOTTOM w0.102: JDIMM2.7 124.7,24.09 v2(123.02,22.41)
DDR_B_D2: length 94.7
  IN1 w0.089: v2(140.73,94.92) 140.73,94.92 140.32,94.51 140.32,94.35 140.14,94.16 140.14,93.76 139.89,93.51 139.49,93.51 139.14,93.16 139.14,92.7 138.95,92.51 137.49,92.51 137.32,92.35 137.32,91.67 137.17,91.52 136.22,91.52 136.11,91.41
  IN1 w0.102: 136.11,91.41 135.92,91.41 124.54,80.03 124.54,72.92 124.91,72.55 124.91,66.69 125.02,66.58 125.41,66.58 125.51,66.48 125.51,65.97 125.41,65.87 124.99,65.87 124.89,65.77 124.89,65.47 124.99,65.36 125.41,65.36 125.51,65.26 125.51,64.96 125.41,64.86 124.99,64.86 124.89,64.76 124.89,64.45 124.99,64.35 125.41,64.35 125.51,64.25 125.51,63.94 125.41,63.84 124.99,63.84 124.89,63.74 124.89,63.43 124.99,63.33 125.41,63.33 125.51,63.23 125.51,62.93 125.41,62.82 124.99,62.82 124.89,62.72 124.89,62.42 124.99,62.32 125.41,62.32 125.51,62.22 125.51,61.91 125.41,61.81 124.99,61.81 124.89,61.71 124.89,61.4 124.99,61.3 125.41,61.3 125.51,61.2 125.51,60.89 125.41,60.79 124.99,60.79 124.89,60.69 124.89,60.39 124.99,60.28 125.41,60.28 125.51,60.18 125.51,59.88 125.41,59.78 124.99,59.78 124.89,59.68 124.89,59.37 124.99,59.27 125.41,59.27 125.51,59.17 125.51,58.86 125.41,58.76 124.99,58.76 124.89,58.66 124.89,58.35 124.99,58.25 125.41,58.25 125.51,58.15 125.51,44.63 124.91,44.03 124.91,39.07 125.79,38.19 125.79,37.11 125.89,37.01 126.51,37.01 126.62,36.91 126.62,36.6 126.51,36.5 125.89,36.5 125.79,36.4 125.79,32.66 125.89,32.55 126.31,32.55 126.44,32.43 126.44,32.17 126.31,32.05 125.89,32.05 125.79,31.95 125.79,24.42 126.27,23.94 v2(126.41,23.94)
  BOTTOM w0.089: v2(140.73,94.92) 141.2,95.39 JCPU1.AM17
  BOTTOM w0.102: JDIMM2.15 127.1,24.63 v2(126.41,23.94)
DDR_B_D3: length 94
  IN1 w0.089: 136.11,90.94 136.49,91.32 137.39,91.32 137.59,91.52 137.9,91.52 138.13,91.75 138.13,91.89 138.57,92.32 139.03,92.32 139.33,92.62 139.33,93.09 139.57,93.32 140.16,93.32 140.33,93.49 140.33,94.09 140.72,94.48 140.95,94.48 141.18,94.7 141.18,95.47 v2(140.73,95.92)
  IN1 w0.102: 136.11,90.94 135.92,90.94 124.85,79.87 124.85,73.15 124.98,73.02 125.52,73.02 125.65,72.9 125.65,72 125.52,71.87 125.36,71.87 125.23,71.74 125.23,71.34 125.36,71.21 125.67,71.21 125.8,71.08 125.8,70.72 125.67,70.6 125.32,70.6 125.22,70.49 125.22,70.19 125.32,70.09 125.71,70.09 125.82,69.99 125.82,69.68 125.71,69.58 125.32,69.58 125.22,69.48 125.22,69.17 125.32,69.07 125.71,69.07 125.82,68.97 125.82,68.67 125.71,68.56 125.32,68.56 125.22,68.46 125.22,68.16 125.32,68.06 125.71,68.06 125.82,67.95 125.82,67.65 125.71,67.55 125.32,67.55 125.22,67.45 125.22,67.14 125.32,67.04 125.71,67.04 125.82,66.94 125.82,44.36 125.24,43.79 125.24,40.91 125.35,40.81 125.55,40.81 125.65,40.71 125.65,40.4 125.55,40.3 125.35,40.3 125.24,40.2 125.24,39.46 125.37,39.33 125.7,39.33 125.83,39.2 125.83,38.87 126.92,37.78 126.92,22.92 v2(126.41,22.41)
  BOTTOM w0.089: v2(140.73,95.92) 141.2,96.39 JCPU1.AM18
  BOTTOM w0.102: v2(126.41,22.41) 127.7,23.7 JDIMM2.17
DDR_B_D4: length 90.5
  IN1 w0.089: 136,94.22 136.3,94.52 136.93,94.52 137.33,94.92 v2(137.73,94.92)
  IN1 w0.102: v2(123.02,19.36) 123.73,20.08 123.73,25.36 122.37,26.71 122.37,36.43 122.27,36.53 121.78,36.53 121.65,36.65 121.65,36.91 121.78,37.03 122.27,37.03 122.37,37.14 122.37,47.66 122.96,48.25 122.96,68.58 122.86,68.68 122.45,68.68 122.35,68.78 122.35,69.08 122.45,69.19 122.86,69.19 122.96,69.29 122.96,69.59 122.86,69.69 122.45,69.69 122.35,69.8 122.35,70.1 122.45,70.2 122.86,70.2 122.96,70.3 122.96,70.61 122.86,70.71 122.45,70.71 122.35,70.81 122.35,71.12 122.45,71.22 122.86,71.22 122.96,71.32 122.96,71.83 122.7,72.08 122.7,80.92 136,94.22
  BOTTOM w0.089: JCPU1.AR17 138.2,95.39 v2(137.73,94.92)
  BOTTOM w0.102: JDIMM2.4 123.8,19.05 123.48,19.36 v2(123.02,19.36)
DDR_B_D5: length 88.8
  IN1 w0.089: 136,94.69 136.23,94.92 v2(136.73,94.92)
  IN1 w0.102: 136,94.69 122.04,80.73 122.04,68.31 122.17,68.19 122.53,68.19 122.65,68.06 122.65,67.55 122.55,67.45 122.39,67.45 122.26,67.32 122.26,67.07 122.39,66.94 122.55,66.94 122.65,66.84 122.65,66.54 122.55,66.43 122.42,66.43 122.3,66.31 122.3,66.05 122.42,65.93 122.55,65.93 122.65,65.82 122.65,48.37 122.04,47.76 122.04,40.11 120.04,38.11 120.04,33.92 120.78,33.19 120.78,27.84 123.43,25.19 123.43,21.3 v2(123.02,20.89)
  BOTTOM w0.089: JCPU1.AT17 137.2,95.39 v2(136.73,94.92)
  BOTTOM w0.102: v2(123.02,20.89) 124.4,19.51 JDIMM2.6
DDR_B_D6: length 93.3
  IN1 w0.089: v2(139.73,94.92) 139.14,94.33 139.14,93.7 138.95,93.51 137.49,93.51 137.14,93.16 137.14,92.7 136.96,92.52 136.29,92.52 136.11,92.34
  IN1 w0.102: 136.11,92.34 135.92,92.34 123.93,80.36 123.93,72.59 124.25,72.28 124.25,54.21 124.35,54.11 124.51,54.11 124.63,53.98 124.63,53.52 124.51,53.4 124.29,53.4 124.19,53.3 124.19,52.99 124.29,52.89 124.8,52.89 124.9,52.79 124.9,52.48 124.8,52.38 124.29,52.38 124.19,52.28 124.19,51.98 124.29,51.87 124.8,51.87 124.9,51.77 124.9,51.47 124.8,51.37 124.29,51.37 124.19,51.26 124.19,50.96 124.29,50.86 124.8,50.86 124.9,50.76 124.9,50.45 124.8,50.35 124.29,50.35 124.19,50.25 124.19,49.94 124.29,49.84 124.8,49.84 124.9,49.74 124.9,45.29 124.25,44.64 124.25,37.17 124.35,37.07 124.68,37.07 124.78,36.97 124.78,36.66 124.68,36.56 124.35,36.56 124.25,36.46 124.25,26.95 125.13,26.07 125.13,23.26 125.65,22.74 125.65,20.89 125.92,20.62 125.92,19.85 v2(126.41,19.36)
  BOTTOM w0.089: v2(139.73,94.92) 140.2,95.39 JCPU1.AN17
  BOTTOM w0.102: v2(126.41,19.36) 127.06,19.36 127.4,19.03 JDIMM2.16
DDR_B_D7: length 92.3
  IN1 w0.089: 136.11,91.87 136.56,92.32 137.03,92.32 137.33,92.62 137.33,93.09 137.57,93.32 139.03,93.32 139.33,93.62 139.33,94.09 139.57,94.32 139.7,94.32 140.13,94.75 140.13,95.52 v2(139.73,95.92)
  IN1 w0.102: 136.11,91.87 135.92,91.87 124.24,80.19 124.24,72.73 124.58,72.39 124.58,57.94 124.69,57.84 125.1,57.84 125.21,57.74 125.21,57.43 125.1,57.33 124.69,57.33 124.58,57.23 124.58,56.92 124.69,56.82 125.1,56.82 125.21,56.72 125.21,56.41 125.1,56.31 124.7,56.31 124.57,56.19 124.57,55.91 124.7,55.78 125.08,55.78 125.2,55.65 125.2,55.31 125.08,55.18 124.7,55.18 124.57,55.05 124.57,54.75 124.7,54.63 125.1,54.63 125.21,54.53 125.21,44.75 124.58,44.13 124.58,38.93 125.46,38.06 125.46,23.36 125.98,22.84 125.98,21.02 126.11,20.89 v2(126.41,20.89)
  BOTTOM w0.089: v2(139.73,95.92) 140.2,96.39 JCPU1.AN18
  BOTTOM w0.102: v2(126.41,20.89) 128,19.3 JDIMM2.18
