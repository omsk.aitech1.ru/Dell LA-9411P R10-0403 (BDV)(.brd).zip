# Allegro board LA-9411P R10-0403.brd (continued)
## Copper pours and planes (outline as drawn) (continued)
GND on BOTTOM (solid shape): 303.51,171.59 303.51,168.29 302.62,167.4 302.62,161.35 302.24,160.97 300.83,160.97 300.5,161.3 299.19,161.3 299.07,161.43 299.07,164.31 299.32,164.56 300.71,164.56 300.85,164.69 300.85,166.76 300.72,166.89 299.19,166.89 299.07,167.02 299.07,170.19 299.58,170.7 299.58,171.84 299.7,171.97 303.13,171.97
GND on BOTTOM (solid shape): 339.58,174.13 339.58,172.43 339.58,172.35 339.83,172.1 343.29,172.1 343.39,172.2 343.39,172.3 343.52,172.43 343.52,172.43 343.76,172.43 343.87,172.31 343.87,168.91 343.76,168.8 338.69,168.8 338.31,169.18 338.31,174 338.56,174.26 339.45,174.26
GND on BOTTOM (solid shape): 303.26,158.51 303.26,157.81 303.26,155.84 302.62,155.21 302.62,151.4 302.74,151.28 302.74,149.41 302.19,148.86 300.97,148.86 300.85,148.98 300.85,149.49 300.72,149.62 299.45,149.62 299.19,149.87 299.19,152.79 299.45,153.05 300.72,153.05 300.97,153.3 300.97,155.21 300.85,155.33 299.32,155.33 299.19,155.46 299.19,158.64 299.32,158.76 303,158.76
GND on BOTTOM (solid shape): 358.12,212.69 368.02,212.69 368.15,212.55 368.29,212.55 368.63,212.41 368.78,212.06 368.78,204.06 368.68,203.77 368.44,203.59 358.38,203.59 357.87,204.1 357.87,204.85 353.8,208.91 351.46,208.91 351.32,209.05 351.32,212.62 351.75,213.05 357.75,213.05
GND on BOTTOM (solid shape): 251.99,170.17 252.28,170.01 252.57,170.17 253.28,170.17 253.28,170.16 253.4,170.15 253.51,170.16 253.52,170.17 258.02,170.17 258.25,169.94 258.25,167.75 258.02,167.53 256.15,167.53 256.14,167.53 256.01,167.55 255.89,167.53 255.88,167.53 247.43,167.53 247.12,167.83 247.12,169.76 247.53,170.17
GND on BOTTOM (solid shape): 23.16,174.24 23.16,168.72 22.89,168.45 13.55,168.45 10.94,167.36 8.37,168.54 1.51,168.54 1.25,168.8 1.25,173.75 1.47,173.96 2.84,173.96 4.15,175.27 22.13,175.27
GND on BOTTOM (solid shape): 126.12,20.44 126.17,20.53 126.26,20.54 126.38,20.51 126.49,20.52 126.52,20.52 127.82,19.22 127.82,18.97 127.8,18.95 127.77,18.93 127.7,18.89 127.63,18.93 127.6,18.95 127.58,18.97 127.58,19.1 127.14,19.54 126.72,19.54 126.52,19.7 126.26,19.69 126.17,19.7 126.12,19.78
GND on BOTTOM (solid shape): 217.53,12.08 217.53,11.27 217.5,11.19 217.41,11.17 216.97,10.82 217.41,10.47 217.5,10.45 217.53,10.37 217.53,9.03 217.41,8.9 215.88,8.9 215.63,9.16 215.63,9.66 215.37,9.92 213.6,9.92 213.47,10.05 213.47,12.08 213.72,12.33 217.28,12.33
GND on BOTTOM (solid shape): 308.21,161.61 308.21,161.48 308.19,161.45 307.35,161.45 307.23,161.34 307.14,161.24 307.14,161.08 306.71,160.64 306.67,160.61 306.64,160.57 306.5,160.43 306.27,160.43 306.25,160.41 304.76,160.41 304.71,160.46 304.71,161.38 304.76,161.43 305.42,161.43 305.5,161.34 305.51,161.34 305.58,161.24 305.68,161.16 305.7,161.15 305.72,161.15 305.85,161.12 305.98,161.15 305.99,161.15 306.4,161.15 306.41,161.15 306.54,161.12 306.67,161.15 306.69,161.15 306.73,161.17 306.8,161.17 307.29,161.66 308.16,161.66
GND on BOTTOM (solid shape): 170.6,20.51 170.66,20.42 170.66,19.66 170.6,19.57 170.5,19.58 170.23,19.63 170.01,19.48 169.99,19.46 169.96,19.46 169.73,19.46 169.27,19 169.22,18.97 169.17,18.93 169.1,18.89 169.03,18.93 168.98,18.97 168.98,18.99 168.98,19.23 170.2,20.45 170.22,20.46 170.23,20.45 170.37,20.46 170.5,20.51
GND on BOTTOM (solid shape): 158.73,151.65 158.73,147.71 158.48,147.46 158.48,146.19 158.35,146.06 155.3,146.06 155.18,146.19 155.18,147.46 155.05,147.59 153.27,147.59 153.14,147.46 153.14,146.19 153.02,146.06 147.05,146.06 146.79,146.32 146.79,148.86 146.54,149.11 145.65,149.11 145.52,148.98 145.52,146.06 145.4,145.94 142.22,145.94 142.1,146.06 142.1,147.46 141.97,147.59 140.44,147.59 140.19,147.33 140.19,146.19 139.94,145.94 134.48,145.94 134.1,146.32 134.09,146.34 134.09,147.46 133.71,147.84 132.7,147.84 132.19,147.33 132.19,146.19 131.94,145.94 129.01,145.94 128.76,146.19 128.76,147.46 128.51,147.71 127.24,147.71 126.98,147.46 126.98,146.06 126.86,145.94 121.14,145.94 120.89,146.19 120.89,147.46 121.14,147.71 123.68,147.71 124.32,148.35 124.32,149.87 124.44,150 134.6,150 137.65,153.05 157.34,153.05
GND on BOTTOM (solid shape): 136.81,42.48 137.04,42.25 137.59,42.25 137.82,42.48 137.82,42.64 137.84,42.66 138.07,42.66 138.32,42.41 138.32,40.17 138.3,40.15 138.27,40.13 138.2,40.09 138.12,40.13 138.1,40.15 138.08,40.17 138.08,40.67 137.25,41.49 136.76,41.49 136.54,41.68 136.26,41.66 136.16,41.67 136.11,41.75 136.11,42.43 136.16,42.51 136.26,42.52 136.51,42.49 136.71,42.64 136.73,42.66 136.81,42.66
GND on BOTTOM (solid shape): 338,237.58 338.26,237.51 338.44,237.31 338.44,230.39 340.38,228.45 346.17,228.45 348.09,226.53 356.09,226.53 356.47,226.91 356.47,227.22 357.74,228.49 358.38,228.49 358.88,228.99 368.51,228.99 368.7,228.81 368.78,228.56 368.78,227.56 368.63,227.21 368.29,227.07 367.71,227.07 367.71,227.09 359.39,227.09 359.39,227.08 359.16,227.08 358.58,226.5 358.58,226.28 357.5,225.2 343.7,225.2 342.18,226.71 337.04,226.71 336.79,226.96 336.79,237.36 336.96,237.52 337.2,237.58
GND on BOTTOM (solid shape): 180.51,20.75 180.54,20.75 180.56,20.73 180.78,20.58 181.04,20.63 181.15,20.63 181.2,20.55 181.2,19.79 181.15,19.7 181.04,19.71 180.78,19.76 180.56,19.61 180.54,19.59 180.51,19.59 180,19.59 179.42,19.01 179.42,18.97 179.37,18.93 179.3,18.89 179.22,18.93 179.18,18.97 179.18,18.99 179.18,19.6 180.33,20.75
GND on BOTTOM (solid shape): 13.68,174.78 13.68,173.1 14.29,172.05 14.5,170.86 12.24,167.58 8.37,168.54 1.51,168.54 1.25,168.8 1.25,173.75 1.48,173.97 2.92,173.97 4.22,175.27 13.19,175.27
GND on BOTTOM (solid shape): 366.98,160.71 366.55,159.66 365.5,159.22 364,159.22 361.51,158.19 360.48,155.71 360.48,153.06 360.05,152.01 359,151.57 338.11,151.57 338.11,156.93 348.06,156.93 350.22,154.77 353.07,154.77 353.73,155.44 355.96,155.44 357.23,156.71 357.23,165.14 359.32,167.22 366.98,167.22
GND on BOTTOM (solid shape): 317.31,228.56 317.88,228.61 318.46,228.57 320.65,228.57 321.9,228.57 321.9,225.17 320.97,221.92 317.9,220.5 314.82,221.93 313.9,225.19 313.9,228.56
GND on BOTTOM (solid shape): 210.88,78.7 210.93,78.65 210.97,78.59 210.96,78.52 210.99,78.12 211.37,78.02 211.38,78.02 211.54,78.02 211.58,78 211.62,77.96 211.66,77.9 211.65,77.83 211.62,77.75 211.6,77.66 211.35,77.41 211.2,77.41 211.14,77.46 211.01,77.57 210.83,77.56 210.83,77.56 210.68,77.56 210.66,77.57 210.64,77.59 210.58,77.67 210.49,77.73 210.44,77.79 210.45,77.87 210.46,77.91 210.48,77.94 210.48,77.97 210.48,78.09 210.4,78.21 210.38,78.25 210.38,78.37 210.43,78.48 210.45,78.59 210.48,78.66 210.55,78.69 210.61,78.7 210.68,78.71 210.85,78.71
GND on BOTTOM (solid shape): 196.15,73.69 196.15,73.31 196.11,73.26 196.09,73.26 195.9,73.1 195.92,72.86 195.93,72.81 195.92,72.76 195.75,72.5 195.86,72.2 195.86,72.15 195.84,72.11 195.77,71.96 195.81,71.79 196.01,71.67 196.24,71.75 196.27,71.77 196.31,71.75 196.32,71.75 196.33,71.71 196.31,71.67 196.22,71.51 196.26,71.33 196.27,71.32 196.27,71.25 196.17,71.25 195.99,71.08 195.58,71.08 195.52,71.01 195.16,71.01 195.02,70.87 194.95,70.82 194.9,70.75 194.77,70.75 194.41,71.11 194.09,71.11 194.05,71.11 193.49,71.67 193.46,71.74 193.49,71.81 193.49,72.17 193.73,72.4 194.57,73.25 195.2,73.25 195.33,73.38 195.33,73.7 195.56,73.93 195.92,73.93
GND on BOTTOM (solid shape): 197.38,73.93 197.44,73.93 197.5,73.88 197.55,73.86 197.59,73.85 197.69,73.85 197.78,73.9 197.83,73.95 197.92,74 198,73.95 198.08,73.87 198.18,73.83 198.22,73.83 198.31,73.79 198.32,73.69 198.31,73.63 198.3,73.57 198.19,73.55 198.11,73.48 198.06,73.39 198.05,73.28 198.05,73.26 197.91,73.12 197.88,73.12 197.65,73.11 197.44,73 197.41,72.98 197.37,73 197.23,73.08 197.07,73.09 197.03,73.11 197.01,73.14 197.02,73.18 197.02,73.24 197.05,73.27 197.09,73.27 197.31,73.54 197.06,73.78 197.04,73.78 196.89,73.93 196.89,74.25 197.06,74.25
GND on BOTTOM (solid shape): 206.69,60.95 206.81,60.82 206.98,60.77 207,60.77 207.08,60.68 207.09,60.67 207.24,60.49 207.48,60.5 207.55,60.51 207.61,60.47 207.84,60.36 208.09,60.44 208.15,60.46 208.22,60.44 208.43,60.38 208.62,60.5 208.66,60.68 208.57,60.84 208.56,60.85 208.55,60.89 208.56,60.93 208.58,60.94 208.62,60.96 208.65,60.94 208.66,60.93 208.83,60.84 209.02,60.9 209.08,60.92 209.14,60.9 209.14,60.82 209.47,60.5 209.47,59.55 208.02,58.1 207.48,58.1 207.24,58.34 207.24,58.78 206.4,59.62 206.39,59.65 206.39,59.74 206.5,59.86 206.55,60.03 206.55,60.29 206.38,60.48 206.38,60.6 206.6,60.82 206.6,60.97 206.68,60.97
GND on BOTTOM (solid shape): 142.93,188.95 145.32,187.46 146.25,184.81 140.59,180.8 138.68,187.46 137.18,188.96 132.93,188.96 132.51,188.54 132.51,187.43 132.42,187.34 128.79,187.34 128.42,187.71 128.42,190.36 128.57,190.51 141.37,190.51
GND on BOTTOM (solid shape): 321.7,237.58 322.04,237.44 322.19,237.09 322.19,235.03 322.18,235.03 322.18,227.98 322.69,227.47 323.71,227.47 323.96,227.22 323.96,225.18 323.32,224.55 321.9,224.55 314.63,222.26 319.25,228.32 319.25,228.35 320.53,229.63 320.53,237.42 320.7,237.54 320.9,237.58
GND on BOTTOM (solid shape): outline of 162 points within 78.99,170.83 98.92,180.37
GND on BOTTOM (solid shape): outline of 215 points within 1.18,198.01 72.6,218.3
GND on BOTTOM (solid shape): 202.83,69.26 202.87,69.22 202.9,69.17 202.9,69.1 202.85,68.57 203.38,68.58 203.51,68.58 203.53,68.55 203.56,68.53 203.64,68.49 203.72,68.48 203.78,68.48 203.87,68.46 203.9,68.36 204,68.09 204.28,68.08 204.34,68.1 204.4,68.07 204.48,67.93 204.61,67.83 204.62,67.78 204.61,67.73 204.59,67.56 204.67,67.41 204.69,67.4 204.69,67.37 204.69,67.25 204.6,67.13 204.58,66.98 204.56,66.96 204.54,66.94 204.41,66.93 204.29,66.87 204.24,66.88 204.2,66.91 204.17,66.94 204.14,66.97 204.11,67.01 204.1,67.06 204.1,67.5 203.68,67.61 203.67,67.6 203.51,67.6 203.47,67.64 203.42,67.68 203.33,67.71 203.24,67.7 203.15,67.73 203.12,67.82 203.04,68.08 202.77,68.12 202.7,68.12 202.64,68.17 202.57,68.26 202.46,68.33 202.4,68.38 202.41,68.47 202.43,68.63 202.34,68.77 202.31,68.81 202.3,68.86 202.36,68.97 202.38,69.1 202.39,69.12 202.41,69.14 202.57,69.17 202.7,69.27 202.71,69.28 202.79,69.28
GND on BOTTOM (solid shape): 200.08,71.57 200.14,71.51 200.37,71.29 200.68,71.34 200.72,71.36 200.75,71.34 200.91,71.24 201.09,71.28 201.17,71.29 201.23,71.24 201.3,71.15 201.39,71.09 201.44,71.03 201.43,70.95 201.4,70.72 201.56,70.56 201.67,70.55 201.78,70.59 201.86,70.6 201.92,70.55 201.99,70.46 202.08,70.4 202.13,70.34 202.12,70.25 202.08,70.11 202.13,69.96 202.15,69.93 202.18,69.91 202.23,69.83 202.19,69.75 202.11,69.64 202.08,69.51 202.05,69.45 201.99,69.42 201.91,69.4 201.84,69.37 201.77,69.36 201.71,69.4 201.67,69.45 201.62,69.49 201.58,69.55 201.6,69.63 201.58,70.09 201.12,70.12 201.11,70.11 201.03,70.11 201.01,70.11 200.99,70.12 200.81,70.21 200.62,70.14 200.54,70.12 200.46,70.18 200.4,70.26 200.32,70.32 200.27,70.39 200.29,70.48 200.36,70.61 200.34,70.75 200.28,70.83 200.2,70.89 200.19,70.89 200.16,70.92 200.16,70.94 200.16,70.97 200.07,71.31 199.72,71.39 199.68,71.39 199.66,71.42 199.65,71.45 199.62,71.49 199.64,71.54 199.69,71.55 199.7,71.55 199.85,71.51 199.99,71.56
GND on BOTTOM (solid shape): outline of 92 points within 198.03,73.78 201.02,76.63
GND on BOTTOM (solid shape): outline of 97 points within 204.96,61.27 207.26,64.57
GND on BOTTOM (solid shape): outline of 302 points within 270.49,165.1 279.26,170.32
GND on BOTTOM (solid shape): outline of 109 points within 201.47,64.91 204.54,67.91
GND on BOTTOM (solid shape): outline of 344 points within 253.12,1.02 304.23,63.9
GND on BOTTOM (solid shape): outline of 135 points within 217.13,71.08 222.46,74.8
GND on BOTTOM (solid shape): outline of 122 points within 200.33,76.5 204.43,80.35
GND on BOTTOM (solid shape): outline of 368 points within 210.19,119.11 223.33,121.5
GND on BOTTOM (solid shape): outline of 160 points within 196.66,67.8 201.51,72.17
GND on BOTTOM (solid shape): outline of 502 points within 142.6,92.34 166.17,100.79
GND on BOTTOM (solid shape): outline of 268 points within 211.73,66.06 218.46,71.75
GND on BOTTOM (solid shape): outline of 634 points within 203.78,74.27 216.93,87.07
GND on BOTTOM (solid shape): outline of 5639 points within 121.27,16.14 145.4,45.35
GND on GND1 (solid shape): outline of 272043 points within 0.51,0.51 369.63,237.58
GND on IN1 (solid shape): 368.73,188.73 368.73,185.88 368.54,185.69 358,185.69 357.61,186.07 357.61,188.61 358,188.99 368.47,188.99
GND on IN1 (solid shape): 13.95,196.99 13.95,191.27 13.57,190.89 4.25,190.89 2.94,192.21 1.46,192.21 1.25,192.42 1.25,195.97 1.51,196.23 7.22,196.23 7.86,195.59 9.51,195.59 10.4,196.48 10.4,198.13 10.78,198.51 12.43,198.51
GND on IN1 (solid shape): 338,237.58 338.26,237.51 338.44,237.31 338.44,230.39 339.83,228.99 339.83,227.72 338.82,226.71 337.04,226.71 336.79,226.96 336.79,237.36 336.96,237.52 337.2,237.58
GND on IN1 (solid shape): 368.35,212.55 368.65,212.38 368.78,212.06 368.78,204.06 368.74,203.88 368.64,203.72 358.25,203.72 357.87,204.1 357.87,212.23 358.12,212.48 367.97,212.48 367.97,212.55
GND on IN1 (solid shape): 368.51,228.99 368.7,228.81 368.78,228.56 368.78,227.56 368.63,227.21 368.29,227.07 367.97,227.07 367.97,227.09 359.15,227.09 358.57,226.51 358.57,226.27 358.38,226.07 356.6,226.07 356.47,226.2 356.47,227.22 357.74,228.49 358.38,228.49 358.88,228.99
GND on IN1 (solid shape): 321.7,237.58 322.04,237.44 322.19,237.09 322.19,235.72 322.18,235.72 322.18,228.1 322.56,227.72 323.96,227.72 324.09,227.6 324.09,224.93 323.83,224.68 321.93,224.68 321.55,225.06 321.55,226.33 320.4,227.47 320.4,230.91 320.41,230.98 320.41,231.06 320.41,237.09 320.55,237.44 320.9,237.58
GND on IN1 (solid shape): 13.68,174.78 13.68,173.1 14.29,172.05 14.5,170.86 12.24,167.58 8.37,168.54 1.51,168.54 1.25,168.8 1.25,173.75 1.59,174.08 3,174.08 4.19,175.27 13.19,175.27
GND on IN1 (solid shape): 146.54,149.62 146.54,148.83 146.48,148.74 146.38,148.75 145.87,148.71 145.86,148.2 145.88,148.13 145.86,148.07 145.87,147.55 146.38,147.51 146.48,147.52 146.54,147.43 146.54,139.84 146.16,139.46 144.64,139.46 144.25,139.84 144.25,140.72 144.26,140.72 144.26,150 144.38,150.13 146.03,150.13
GND on IN1 (solid shape): 366.98,160.71 366.55,159.66 365.5,159.22 364,159.22 361.51,158.19 360.48,155.71 360.48,153.06 360.05,152.01 359,151.57 338.11,151.57 338.11,157.06 348.04,157.06 350.3,154.8 353.07,154.8 353.83,155.56 356.12,155.56 357.26,156.71 357.26,165.09 359.39,167.22 366.98,167.22
GND on IN1 (solid shape): outline of 205 points within 122.28,138.57 142.98,152.16
GND on IN1 (solid shape): outline of 217 points within 147.94,138.57 161.27,153.17
GND on IN2 (solid shape): 368.73,188.67 368.73,185.88 368.54,185.69 358,185.69 357.61,186.07 357.61,188.73 357.87,188.99 368.41,188.99
GND on IN2 (solid shape): 13.95,196.99 13.95,191.27 13.57,190.89 4.25,190.89 2.94,192.2 1.47,192.2 1.25,192.42 1.25,195.97 1.51,196.23 7.22,196.23 7.86,195.59 9.51,195.59 10.4,196.48 10.4,198.13 10.78,198.51 12.43,198.51
GND on IN2 (solid shape): 368.68,212.36 368.75,212.22 368.78,212.06 368.78,204.06 368.68,203.77 368.44,203.59 358.12,203.59 357.87,203.85 357.87,212.1 358.12,212.36
GND on IN2 (solid shape): 157.61,153.08 153.91,149.37 153.91,148.16 153.87,148.12 153.87,146.42 154.44,145.85 158.3,145.85 158.39,145.78 158.37,145.67 157.46,144.77 157.46,136.68 157.07,136.28 149.02,136.28 149.02,138.59 148.57,139.03 148.57,151.48 148.57,152.67 149.21,153.3 157.61,153.3
GND on IN2 (solid shape): 338,237.58 338.26,237.51 338.44,237.31 338.44,230.39 339.83,228.99 339.83,227.72 338.82,226.71 337.04,226.71 336.79,226.96 336.79,237.36 336.96,237.52 337.2,237.58
GND on IN2 (solid shape): 158.89,152.65 158.95,152.74 159.06,152.72 159.08,152.7 159.08,152.36 159.1,152.33 159.11,152.32 159.19,152.21 159.3,152.13 159.31,152.12 159.49,151.94 159.49,149 158.98,149 158.77,148.78 158.77,147.75 158.55,147.54 155.41,147.54 155.28,147.66 155.28,148.06 155.18,148.16 155.18,148.85 158.89,152.56
GND on IN2 (solid shape): 368.51,228.99 368.7,228.81 368.78,228.56 368.78,227.56 368.63,227.21 368.29,227.07 367.97,227.07 367.97,227.09 359.16,227.09 358.58,226.5 358.58,226.28 358.38,226.07 356.6,226.07 356.47,226.2 356.47,227.22 357.74,228.49 358.38,228.49 358.88,228.99
GND on IN2 (solid shape): 321.7,237.58 322.04,237.44 322.19,237.09 322.19,235.47 322.18,235.47 322.18,228.1 322.56,227.72 323.96,227.72 324.09,227.6 324.09,224.93 323.83,224.68 321.93,224.68 321.55,225.06 321.55,226.33 320.4,227.47 320.4,230.91 320.41,230.98 320.41,231.06 320.41,237.09 320.55,237.44 320.9,237.58
GND on IN2 (solid shape): 13.68,174.78 13.68,173.1 14.29,172.05 14.5,170.86 12.24,167.58 8.37,168.54 1.51,168.54 1.25,168.8 1.25,173.75 1.53,174.02 3,174.02 4.25,175.27 13.19,175.27
GND on IN2 (solid shape): outline of 85 points within 144.26,141.62 146.67,150
GND on IN2 (solid shape): 366.98,160.71 366.55,159.66 365.5,159.22 364,159.22 361.51,158.19 360.48,155.71 360.48,153.06 360.05,152.01 359,151.57 338.11,151.57 338.11,157.06 348.04,157.06 350.3,154.8 353.07,154.8 353.83,155.56 356.12,155.56 357.26,156.71 357.26,165.09 359.39,167.22 366.98,167.22
GND on IN2 (solid shape): outline of 89 points within 142.71,93.8 165.75,99.82
GND on IN2 (solid shape): outline of 373 points within 123.05,136.54 142.98,151.9
GND on IN3 (solid shape): 368.73,188.67 368.73,185.88 368.54,185.69 358,185.69 357.61,186.07 357.61,188.73 357.87,188.99 368.41,188.99
GND on IN3 (solid shape): 13.95,196.99 13.95,191.27 13.57,190.89 4.21,190.89 2.9,192.21 1.46,192.21 1.25,192.42 1.25,195.97 1.51,196.23 7.22,196.23 7.86,195.59 9.51,195.59 10.4,196.48 10.4,198.13 10.78,198.51 12.43,198.51
GND on IN3 (solid shape): 368.68,212.36 368.75,212.22 368.78,212.06 368.78,204.06 368.74,203.88 368.64,203.72 358.12,203.72 357.87,203.97 357.87,212.1 358.12,212.36
GND on IN3 (solid shape): 338,237.58 338.26,237.51 338.44,237.31 338.44,230.39 339.83,228.99 339.83,227.72 338.82,226.71 337.04,226.71 336.79,226.96 336.79,237.36 336.96,237.52 337.2,237.58
GND on IN3 (solid shape): 368.51,228.99 368.7,228.81 368.78,228.56 368.78,227.56 368.63,227.21 368.29,227.07 367.58,227.07 367.58,227.09 359.14,227.09 358.59,226.54 358.59,226.28 358.38,226.07 356.6,226.07 356.47,226.2 356.47,227.22 357.74,228.49 358.38,228.49 358.88,228.99
GND on IN3 (solid shape): 321.7,237.58 322.04,237.44 322.19,237.09 322.19,235.66 322.18,235.66 322.18,228.1 322.56,227.72 323.96,227.72 324.09,227.6 324.09,224.93 323.83,224.68 321.93,224.68 321.55,225.06 321.55,226.33 320.4,227.47 320.4,230.91 320.41,230.98 320.41,231.06 320.41,237.09 320.55,237.44 320.9,237.58
GND on IN3 (solid shape): 13.68,174.78 13.68,173.1 14.29,172.05 14.5,170.86 12.24,167.58 8.37,168.54 1.51,168.54 1.25,168.8 1.25,173.75 1.48,173.97 2.95,173.97 4.25,175.27 13.19,175.27
GND on IN3 (solid shape): 366.98,160.71 366.55,159.66 365.5,159.22 364,159.22 361.51,158.19 360.48,155.71 360.48,153.06 360.05,152.01 359,151.57 338.11,151.57 338.11,154.7 340.47,157.06 348.04,157.06 350.3,154.8 353.07,154.8 353.83,155.56 356.12,155.56 357.26,156.71 357.26,165.09 359.39,167.22 366.98,167.22
GND on IN3 (solid shape): outline of 452 points within 122.92,144.03 159.49,152.92
GND on IN3 (solid shape): outline of 19458 points within 122.92,93.74 167.33,133.24
GND on IN4 (solid shape): 368.7,188.64 368.7,185.85 368.54,185.69 358,185.69 357.61,186.07 357.61,188.61 358,188.99 368.35,188.99
GND on IN4 (solid shape): 13.95,196.99 13.95,191.27 13.57,190.89 4.24,190.89 2.94,192.19 1.48,192.19 1.25,192.42 1.25,195.97 1.51,196.23 7.22,196.23 7.86,195.59 9.51,195.59 10.4,196.48 10.4,198.13 10.78,198.51 12.43,198.51
GND on IN4 (solid shape): 368.53,212.48 368.71,212.3 368.78,212.06 368.78,204.06 368.74,203.88 368.64,203.72 358.12,203.72 357.87,203.97 357.87,212.23 358.12,212.48
GND on IN4 (solid shape): 338,237.58 338.26,237.51 338.44,237.31 338.44,230.39 339.83,228.99 339.83,227.72 338.82,226.71 337.04,226.71 336.79,226.96 336.79,237.36 336.96,237.52 337.2,237.58
GND on IN4 (solid shape): 368.51,228.99 368.7,228.81 368.78,228.56 368.78,227.56 368.63,227.21 368.29,227.07 367.77,227.07 367.77,227.09 359.15,227.09 358.58,226.52 358.58,226.28 358.38,226.07 356.6,226.07 356.47,226.2 356.47,227.22 357.74,228.49 358.38,228.49 358.88,228.99
GND on IN4 (solid shape): 321.7,237.58 322.04,237.44 322.19,237.09 322.19,235.98 322.18,235.98 322.18,228.1 322.56,227.72 323.96,227.72 324.09,227.6 324.09,224.93 323.83,224.68 321.93,224.68 321.55,225.06 321.55,226.33 320.4,227.47 320.4,230.91 320.41,230.98 320.41,231.06 320.41,237.09 320.55,237.44 320.9,237.58
GND on IN4 (solid shape): 13.68,174.78 13.68,173.1 14.29,172.05 14.5,170.86 12.24,167.58 8.37,168.54 1.51,168.54 1.25,168.8 1.25,173.75 1.39,173.88 2.81,173.88 4.2,175.27 13.19,175.27
GND on IN4 (solid shape): 366.98,160.71 366.55,159.66 365.5,159.22 364,159.22 361.51,158.19 360.48,155.71 360.48,153.06 360.05,152.01 359,151.57 338.11,151.57 338.11,157.06 348.04,157.06 350.3,154.8 353.07,154.8 353.83,155.56 356.12,155.56 357.26,156.71 357.26,165.09 359.39,167.22 366.98,167.22
GND on IN4 (solid shape): outline of 387 points within 124.32,136.66 158.73,152.9
GND on GND3 (solid shape): outline of 272314 points within 0.51,0.51 369.63,237.58
GND on TOP: 263.37,81.23 265.39,81.23 266.1,80.52 266.1,77.16 264.84,75.91 259.81,75.91 259.6,76.12 259.6,79.64 259.99,80.04 262.9,80.04 263.22,79.72 264.7,79.72 264.8,79.82 264.8,80.58 264.47,80.91 263.37,80.91 263.3,80.97 263.3,81.17
GND on TOP: 101.51,177.25 101.67,177.09 101.67,172.47 101.49,172.29 100.12,172.29 100.02,172.39 100.02,177.2 100.07,177.25
GND on TOP: 267.01,87.35 266.95,87.41 266.95,87.87 266.78,88.04 265.97,88.04 265.83,87.9 262.68,87.9 262.06,88.52 262.06,88.7 262.2,88.84 262.49,88.84 262.61,88.72 265.16,88.72 265.43,88.99 266.29,88.99 266.39,89.09 266.39,89.32 266.02,89.69 259.72,89.69 259.56,89.85 259.56,92.44 259.7,92.58 264.52,92.58 267.61,89.5 267.61,87.45 267.51,87.35
GND on BOTTOM: 196.07,162.38 194.43,162.38 194.08,162.03 193.3,162.03 191.73,163.6 187.55,163.6 184.22,160.27 184.22,158.19 190.17,152.25 193.19,152.25 196.2,155.26 196.2,162.25
GND on BOTTOM: outline of 165 points within 162.92,15.89 186.29,45.61 ; 1 cut-out
GND on BOTTOM: outline of 232 points within 208.63,61.45 213.11,67.91
GND on BOTTOM: outline of 551 points within 200.25,63.03 214.69,80.1
GND on IN1: 87.71,188.16 89.7,190.14 97.93,190.14 98.73,189.34 102.75,189.34 102.76,189.33 103.19,189.33 103.93,188.59 103.93,188.16 108.14,183.95 108.14,174.36 104.97,171.2 101.39,171.2 99.75,172.83 89.01,172.83 87.71,174.13 87.71,174.52 87.75,174.53 87.98,174.8 87.9,175.14 87.88,175.21 87.9,175.28 87.98,175.62 87.75,175.88 87.71,175.9
GND on GND2: outline of 442 points within 0.51,0.51 369.64,240.8 ; 3 cut-outs
GND on IN2: 89.39,172.58 87.78,174.19 87.78,174.55 87.99,174.81 87.9,175.14 87.88,175.21 87.9,175.28 87.99,175.6 87.78,175.87 87.78,189.76 88.48,190.46 97.29,190.46 98.38,189.37 102.75,189.37 106.89,185.23 106.89,171.74 106.68,171.53 102.23,171.53 101.11,172.65 98.5,172.65 98.43,172.58
GND on IN3: 89.22,172.08 86.9,174.4 86.9,179.73 87.14,180.1 86.9,180.47 86.9,181.32 86.95,181.4 87.04,181.41 87.55,181.63 87.3,182.13 87.23,182.2 87.25,182.3 87.28,182.33 87.3,182.37 87.36,182.58 87.28,182.79 87.16,182.9 87,182.94 86.93,182.97 86.9,183.04 86.9,185.8 86.93,185.87 87,185.9 87.36,186.15 87.26,186.56 87.23,186.63 87.25,186.71 87.38,186.98 87.28,187.26 87.25,187.33 87.28,187.39 87.41,187.68 87.29,187.96 87.26,188.03 87.28,188.09 87.4,188.35 87.31,188.61 87.29,188.67 87.31,188.73 87.39,189.17 87,189.38 86.93,189.41 86.9,189.48 86.9,189.69 87.44,190.22 97.91,190.22 98.84,189.29 102.69,189.29 107.4,184.58 107.4,171.77 106.97,171.34 101.85,171.34 101.1,172.08
GND on VCC: 123.15,132.73 122.54,133.34 122.54,136.43 123.91,137.81 165.36,137.81 165.97,137.19 165.97,133.85 165.36,133.24 128.02,133.24 127.51,132.73
GND on VCC: 124.29,30.75 122.03,33.01 122.03,45.63 125.46,49.06 125.46,71.11 122.66,73.9 122.66,80.81 135.47,93.61 141.1,93.61 141.59,93.13 141.59,88.81 142.12,88.28 146.92,88.28 146.92,78.6 145.14,76.83 145.14,64.76 143.24,62.86 143.24,59.55 141.84,58.16 141.84,43.47 142.35,42.96 142.35,36.86 143.75,35.47 143.75,31.36 143.13,30.75
GND on VCC: 1.02,168.39 1.02,171.07 1.02,171.07 1.02,173.83 2.22,173.83 3.28,174.26 3.73,175.33 7.93,175.33 12.42,175.33 12.47,175.33 12.63,175.33 12.64,175.34 13.87,176.4 13.43,177.97 13.43,188.22 13.87,189.78 12.64,190.84 12.63,190.86 12.47,190.86 12.42,190.86 4.67,190.86 4.67,190.86 3.73,190.86 3.28,191.92 2.22,192.36 1.02,192.36 1.02,193.87 1.02,193.87 1.02,196.33 7.42,196.33 8.99,195.89 10.05,197.12 10.07,197.14 10.07,197.29 10.07,197.35 10.07,212.85 10.07,212.9 10.07,213.06 10.05,213.07 8.99,214.3 7.42,213.86 1.02,213.86 1.02,218.52 20.94,218.52 20.94,213.1 16.62,208.78 16.62,168.39
GND on VCC: outline of 104 points within 313.55,185.56 369.13,237.06
GND on VCC: 335.7,151.57 335.14,152.14 335.14,156.75 335.5,157.11 347.98,157.11 350.27,154.83 353.02,154.83 353.78,155.59 356.07,155.59 357.23,156.75 357.23,165.13 360.9,168.8 367.07,168.8 367.02,168.61 367,168.43 366.98,168.42 366.98,168.27 366.98,168.21 366.98,160.71 366.55,159.66 365.5,159.22 364,159.22 363.92,159.22 363.79,159.22 363.78,159.22 361.51,158.19 360.49,155.92 360.48,155.92 360.48,155.79 360.48,155.71 360.48,153.06 360.05,152.01 359,151.57
GND on VCC: 165.32,32.14 164.83,32.63 164.83,42.96 165.46,43.6 165.46,62.47 163.43,64.51 163.43,77.76 164.45,78.77 164.45,90.2 165.57,91.33 176.53,91.33 184.89,82.97 184.89,79.37 180.7,75.17 180.7,49.69 185.28,45.12 185.28,32.63 184.79,32.14
GND_CHASSIS on BOTTOM (solid shape): 309.15,218.48 309.15,215.4 308.26,214.52 301.1,214.52 299.45,216.17 299.45,218.33 299.79,218.67 308.96,218.67
GNDA on TOP (solid shape): 349.32,176 349.32,173.48 349.23,173.39 348.35,173.39 348.12,173.62 348.12,176.14 348.28,176.3 349.02,176.3
GNDA on TOP (solid shape): 349.45,172.91 349.45,170.64 349.24,170.44 348.53,170.44 348.32,170.64 348.32,172.98 348.45,173.11 349.25,173.11
GNDA on TOP (solid shape): 350.73,169.41 350.73,165.33 350.59,165.19 349.63,165.19 349.55,165.26 349.55,169.49 349.68,169.62 350.52,169.62
GNDA on TOP (solid shape): 336.06,160.32 336.06,159.22 335.91,159.07 334.81,159.07 334.69,159.18 334.69,159.5 334.73,159.54 335.2,159.54 335.24,159.58 335.24,159.98 335.2,160.02 334.73,160.02 334.67,160.08 334.67,160.31 334.79,160.44 335.95,160.44
GNDA on GND1: outline of 105 points within 335.14,155.33 369.64,185.05
GNDA on GND2: outline of 99 points within 335.14,155.33 369.64,185.05
GNDA on IN2: outline of 131 points within 335.38,155.33 368.66,185.05
GNDA on IN3: outline of 86 points within 335.14,155.33 368.92,185.05
GNDA on VCC: outline of 102 points within 335.14,155.33 369.13,185.05
GNDA on IN4: 350.48,155.33 348.2,157.62 336.02,157.62 335.52,158.13 335.52,159.91 336.15,160.54 336.15,161.43 335.88,161.7 335.88,162.97 339.08,166.17 339.19,166.2 339.25,166.1 339.86,165.84 339.6,166.45 339.5,166.51 339.52,166.62 341.19,168.29 343.88,168.29 344.28,168.69 344.28,174.23 344.03,174.49 344.03,175.29 344.08,175.38 344.19,175.37 344.76,175.65 344.19,175.93 344.08,175.93 344.03,176.02 344.03,176.06 344.53,176.56 344.53,181.09 345.32,181.88 345.34,181.88 347.65,184.19 347.67,184.19 347.86,184.29 347.96,184.48 347.96,184.5 348.51,185.05 369.04,185.05 369.04,183.54 369,183.46 368.91,183.45 368.79,183.49 368.66,183.5 367.75,183.5 367.33,183.33 367.13,182.93 367.12,182.89 365.62,182.89 365.62,182.64 363.46,182.64 363.46,182.89 361.49,182.89 361.48,182.93 361.28,183.33 360.86,183.5 359.95,183.5 359.53,183.33 359.33,182.93 359.32,182.89 359.01,182.89 358.25,182.13 358.25,180.86 358.5,180.61 358.5,175.53 358.12,175.15 358.12,173.88 359.52,172.48 368.41,172.48 368.79,172.1 368.79,171.34 366.76,169.3 360.68,169.3 356.73,165.34 356.73,156.96 355.86,156.1 353.57,156.1 352.81,155.33
GNDA on GND3: outline of 90 points within 335.14,155.33 369.64,185.05
GNDA_CHG on BOTTOM (solid shape): 77.07,187.46 77.07,186.7 77.58,186.19 79.74,186.19 79.99,185.94 79.99,184.29 79.74,184.04 79.04,184.04 78.53,184.04 77.64,184.04 77.64,183.97 77.58,183.91 77.58,181.88 77.71,181.75 77.71,180.73 77.45,180.48 76.06,180.48 75.93,180.61 75.93,181.62 76.18,181.88 76.18,182.64 76.56,182.64 76.69,182.64 76.69,183.15 76.18,183.15 76.18,183.78 75.8,184.16 75.8,187.34 76.06,187.59 76.94,187.59
GNDA_GPU_CORE on TOP (solid shape): 308.12,164.2 308.56,164.2 308.56,164.73 312.66,164.73 312.78,164.6 312.78,160.92 312.66,160.79 308.47,160.79 307.7,161.56 307.7,162.34 307.58,162.47 307.58,164.6 307.7,164.73 308.12,164.73
3301_PWRSRC on TOP (solid shape): 156.29,168.19 156.4,168.17 156.5,168.19 156.51,168.2 156.6,168.2 157.23,167.56 157.88,167.56 157.97,167.47 157.97,166.18 157.91,166.12 157.13,166.12 156.4,166.85 156.4,167.58 156.07,167.91 154.1,167.91 154.04,167.96 154.04,168.11 154.09,168.16 155.24,168.16 155.25,168.17 155.39,168.17 155.42,168.2 156.28,168.2
+BATT_SUM on TOP (solid shape): 125.46,181.74 125.46,177.69 125.08,177.3 123.17,177.3 122.66,177.81 115.3,177.81 115.17,177.94 115.17,182.12 115.34,182.29 115.35,182.29 115.41,182.35 117.52,182.35 117.86,182.68 124.51,182.68
+BATT_SUM on TOP (solid shape): 247.95,89.53 247.95,85.61 246.49,84.15 246.49,82.94 246.36,82.82 246.36,81.9 246.11,81.65 243,81.65 242.71,81.93 242.71,84.05 242.17,84.59 241.66,84.59 241.54,84.72 241.54,85.23 241.66,85.36 242.81,85.36 243.12,85.67 243.12,86 243.11,86.02 243.11,89.55 243.23,89.66 247.82,89.66
+BATT_SUM on BOTTOM (solid shape): 117.18,182.03 117.18,180.81 117.41,180.58 117.42,180.58 117.5,180.5 121.88,180.5 121.9,180.48 122.23,180.48 122.62,180.88 122.62,181.34 122.78,181.5 123.45,181.5 123.56,181.39 123.56,181.05 123.88,180.73 128.13,180.73 128.63,180.23 128.63,176.54 128.51,176.42 123.87,176.42 122.32,177.96 115.85,177.96 115.55,178.26 115.55,181.88 115.81,182.13 117.09,182.13
+BATT_SUM on BOTTOM (solid shape): outline of 1102 points within 242.73,81.69 280.98,147.97
+BATT_SUM on IN3 (solid shape): outline of 149 points within 145.4,185.43 169.15,192.04
+BATT_SUM on IN3 (solid shape): outline of 1036 points within 270.19,146.57 283.03,191.29
+BATT_SUM on IN4 (solid shape): outline of 7653 points within 116.31,178.48 273.44,191.82
+BL_PWR_SRC on BOTTOM (solid shape): 179.13,152.81 179.13,149.38 179.5,149.01 180.92,149.01 181.25,148.68 181.25,147.32 181.05,147.12 179.95,147.12 179.87,147.21 178.65,147.21 178.56,147.12 177.8,147.12 177.21,147.7 177.21,148.13 177.25,148.17 177.25,149.75 177.15,149.85 175.4,149.85 175.24,150 175.24,151.01 175.35,151.12 177.39,151.12 177.94,151.67 177.94,152.85 178.1,153.01 178.93,153.01
+CAMERA_VDD on TOP (solid shape): 193.77,166.18 195.82,166.18 195.91,166.09 195.91,164.74 195.83,164.67 195.05,164.67 194.89,164.5 194.89,163.75 194.83,163.69 192.57,163.69 191.85,164.4 191.85,166.4 192.03,166.57 193.38,166.57
+CAMERA_VDD on BOTTOM (solid shape): 194.45,164.36 196.05,164.36 196.19,164.22 196.19,163.92 196.01,163.74 193.96,163.74 193.75,163.52 192.69,163.52 192.35,163.87 192.35,164.97 192.58,165.2 193.61,165.2
+DC1_PWR_SRC on TOP (solid shape): 142.22,11.86 142.22,8.52 141.84,8.14 141.84,4.5 141.66,4.32 138.9,4.32 138.67,4.55 138.67,12.01 139,12.34 141.74,12.34
+DC1_PWR_SRC on TOP (solid shape): outline of 140 points within 162.29,5.6 170.53,14.11
+DC1_PWR_SRC on BOTTOM (solid shape): 149.97,10.49 149.97,9.22 150.41,8.78 150.41,7.51 150.38,7.47 150.26,7.47 150.22,7.51 150.22,8.33 148.95,9.6 148.95,10.43 149.08,10.55 149.91,10.55
+DC1_PWR_SRC on IN4 (solid shape): outline of 651 points within 138.98,8.54 169.01,15.68
+DC_IN on TOP (solid shape): 139.43,171.59 139.43,167.91 138.41,166.89 138.41,162.32 139.21,161.52 139.21,160.49 139.01,160.29 138.05,160.29 137.96,160.28 137.88,160.24 137.83,160.22 137.78,160.17 137.75,160.16 137.43,160.16 137.18,159.91 134.87,159.91 134.68,159.98 134.49,159.91 133.71,159.91 133.46,160.16 133.46,167.02 133.71,167.27 135.49,167.27 135.75,167.53 135.75,168.41 135.36,168.8 133.83,168.8 133.82,168.84 133.81,168.9 133.78,168.96 133.8,169.02 133.86,169.02 134.44,169.42 133.77,169.21 133.73,169.12 133.62,169.1 133.31,169.1 133.12,168.84 133.11,168.8 132.57,168.8 132.19,169.18 132.19,171.59 132.32,171.72 139.3,171.72
+DC_IN_SS on TOP (solid shape): 53.4,180.33 53.4,179.04 52.26,179.04 51.56,178.35 50.44,178.35 50.33,178.46 50.33,179.92 50.97,180.57 53.16,180.57
+DC_IN_SS on TOP (solid shape): 130.41,168.54 130.41,164.22 130.16,163.97 121.78,163.97 121.52,164.22 121.52,166.08 122.26,166.82 122.26,168.66 122.39,168.8 130.16,168.8
+DC_IN_SS on BOTTOM (solid shape): 128.25,168.41 128.25,165.37 128,165.11 122.91,165.11 122.27,165.75 122.27,168.54 122.4,168.67 128,168.67
+DCIN on TOP (solid shape): 81.8,186.64 82.72,186.64 82.79,186.58 82.79,186.22 82.72,186 82.79,185.79 82.79,185.11 82.72,185.05 81.9,185.05 81.77,185.18 81.77,185.49 81.77,185.56 81.76,185.57 81.76,185.77 81.69,185.84 80.15,185.84 79.87,185.56 78.9,185.56 78.86,185.57 78.85,185.61 78.85,185.76 78.86,185.8 78.9,185.81 79.17,185.81 80.34,186.98 81.45,186.98
+DCIN_JACK on TOP (solid shape): 137.9,177.81 139.43,177.81 139.56,177.69 139.56,173.37 139.3,173.11 135.75,173.11 135.49,173.37 135.49,177.69 135.75,177.94 137.78,177.94
+DCIN_JACK on BOTTOM (solid shape): 139.56,176.42 139.56,166.76 139.43,166.64 136.94,166.64 136.85,166.69 136.85,166.79 136.54,167.32 136.23,166.79 136.23,166.69 136.14,166.64 135.87,166.64 135.62,166.89 135.62,176.54 135.75,176.67 139.3,176.67
+DOCK_PWR_BAR on TOP (solid shape): outline of 194 points within 195.13,180.5 208.19,187.39
+DOCK_PWR_BAR on TOP (solid shape): outline of 291 points within 154.82,180.02 169.95,191.12
+DOCK_PWR_BAR on BOTTOM (solid shape): 118.96,184.24 118.96,183.41 118.72,183.17 118.72,182.87 118.92,182.66 122.11,182.66 122.21,182.56 122.21,180.89 122.06,180.73 117.7,180.73 117.38,181.05 117.38,182.08 117.18,182.28 115.83,182.28 115.63,182.49 115.63,184.23 115.71,184.31 116.17,184.31 116.24,184.38 118.82,184.38
+DOCK_PWR_BAR on IN2 (solid shape): outline of 183 points within 156.7,182.13 166.86,189.5
+DOCK_PWR_BAR on IN3 (solid shape): outline of 4761 points within 115.62,169.43 166.73,189.75
+DOCK_PWR_BAR on VCC: 157.7,182.38 157.08,183 157.08,192.06 157.1,192.08 159.97,192.08 160.38,191.76 160.87,191.59 160.89,191.58 161.04,191.58 161.1,191.58 171.1,191.58 171.16,191.58 171.31,191.58 171.33,191.59 171.82,191.76 172.23,192.08 209.97,192.08 210.38,191.76 210.87,191.59 210.89,191.58 211.04,191.58 211.1,191.58 211.69,191.58 211.69,183.25 210.82,182.38 180.3,182.38 179.41,183.27 171.33,183.27 170.44,182.38
+GPU_CORE on TOP (solid shape): 219.58,135.38 219.58,134.92 219.45,134.79 218.95,134.79 218.82,134.92 218.69,134.92 218.68,134.92 218.57,134.94 218.47,134.92 218.46,134.92 217.74,134.92 217.68,134.98 217.68,135.3 217.68,135.31 217.73,135.36 217.73,135.51 217.75,135.54 217.75,135.61 217.76,135.63 217.77,135.65 218.3,135.65 218.55,135.9 219.06,135.9
+GPU_CORE on TOP (solid shape): 218.37,131.37 218.37,130.95 218.34,130.9 218.3,130.85 218.27,130.81 217.83,130.81 217.52,130.5 217.52,130.47 217.15,130.1 217.15,129.55 217.03,129.43 216.57,129.43 216.13,129.87 216.13,130.82 216.71,131.41 217.47,131.41 217.62,131.42 217.76,131.49 218.25,131.49
+GPU_CORE on TOP (solid shape): outline of 175 points within 246.57,146.95 267.7,165.11
+GPU_CORE on BOTTOM (solid shape): 218.42,138.47 218.68,138.35 218.95,138.47 219.15,138.47 219.31,138.3 219.31,138.08 217.24,136.02 217.24,136.01 217.15,135.95 217.08,135.86 217.08,135.85 216.17,134.94 215.89,134.94 215.79,135.05 215.79,136.34 217.91,138.47
+GPU_CORE on BOTTOM (solid shape): outline of 213 points within 246.67,146.7 268.03,166.51
+GPU_CORE on IN1 (solid shape): outline of 2406 points within 215.63,125.02 228.79,138.22
+GPU_CORE on IN2 (solid shape): outline of 8738 points within 216.31,125.27 269.2,164.99
+GPU_CORE on IN3 (solid shape): outline of 19242 points within 215.96,117.77 252.9,164.07
+GPU_CORE on IN4 (solid shape): outline of 6494 points within 216.33,124.79 251.23,164.1
+GPU_CORE on VCC: 217.64,127.39 217.03,128.01 217.03,137.07 217.51,137.55 226.78,137.55 227.29,138.06 234.48,138.06 236.3,139.89 236.3,154.22 240.14,158.05 240.14,163.94 240.29,164.1 251.29,164.1 252.08,163.31 252.08,132.32 249.81,130.06 246,130.06 243.34,127.39
+LCDVDD on TOP (solid shape): 175.72,170.03 175.73,169.99 175.75,169.94 175.75,168.32 175.96,168.11 175.96,166.21 175.81,166.05 173.14,166.05 173.14,166.05 172.89,166.05 172.82,166.12 172.82,167.69 172.89,167.76 173.1,167.76 174.61,168.17 173.16,168.76 173.11,168.76 173.1,168.77 173.1,170.03 173.32,170.26 175.5,170.26
+LCDVDD on BOTTOM (solid shape): 175.76,168.52 175.76,168.14 175.18,167.56 175.18,167.24 175.31,167.11 176.45,167.11 176.51,167.05 176.51,166.41 176.45,166.35 174.12,166.35 173.91,166.56 173.91,167.48 173.98,167.55 174.37,167.84 174.48,168.32 174.48,168.38 174.49,168.38 174.49,168.43 174.71,168.65 175.64,168.65
+MBATT on TOP (solid shape): 243.49,79.36 244.46,79.36 244.75,79.07 244.75,76.38 244.51,76.14 242.72,76.14 241.92,76.94 240.47,76.94 240.41,76.87 240.41,76.42 240.38,76.39 240.2,76.39 240.17,76.43 240.17,76.9 240.13,76.94 239.64,76.94 239.61,76.9 239.61,76.42 239.58,76.39 239.39,76.39 239.37,76.42 239.37,76.89 239.31,76.94 238.91,76.94 238.54,77.3 238.54,79.18 238.91,79.55 240.89,79.55 241.51,80.17 242.68,80.17
+MBATT_C on TOP (solid shape): 238.78,76.8 239.16,76.8 239.21,76.75 239.21,76.33 239.29,76.25 239.73,76.25 239.76,76.28 239.76,76.75 239.8,76.78 239.97,76.78 240.01,76.75 240.01,76.31 240.08,76.25 240.51,76.25 240.56,76.3 240.56,76.76 240.6,76.8 240.93,76.8 241.03,76.7 241.03,71.67 240.97,71.6 239.91,71.6 239.81,71.7 239.81,72.4 239.63,72.58 238.88,72.58 238.67,72.8 238.67,73.05 238.39,73.33 237.6,73.33 237.27,73.66 237.27,74.7 237.83,75.27 237.83,76.98 238.08,77.23 238.35,77.23
+MBATT_C on BOTTOM (solid shape): outline of 175 points within 232.2,63.92 241.87,77.36
+MBATT_C2 on TOP (solid shape): 162.43,172.1 162.46,172.08 162.48,172.05 162.48,170.38 162.99,169.87 162.99,168.99 162.92,168.92 162.35,168.92 162.29,168.99 162.29,172.05 162.3,172.08 162.34,172.1
+MPBATT_IN_SS on TOP (solid shape): outline of 116 points within 247.85,74.27 252.69,91.64
+PBATT on TOP (solid shape): 136.89,184.8 136.89,181.5 136.63,181.24 132.06,181.24 131.94,181.37 131.94,185.05 132.06,185.18 136.51,185.18
+PBATT on BOTTOM (solid shape): 136.73,184.83 136.73,184.8 136.77,184.17 136.89,183.54 136.89,183.54 136.89,180.86 136.51,180.48 128.89,180.48 128.38,180.99 127.87,180.99 127.74,181.11 127.74,185.56 127.87,185.69 135.87,185.69
+PBATT_C on TOP (solid shape): 127.16,189.59 127.16,185.22 127.21,185.17 127.21,185.1 127.28,185.1 127.54,184.84 127.54,181.89 127.36,181.71 125.8,181.71 125.27,182.24 125.27,183.86 125,184.12 125,186.99 123.5,188.49 123.5,189.75 123.9,190.14 126.6,190.14
+PBATT_C on BOTTOM (solid shape): 127.24,190 127.24,181.37 126.86,180.99 123.89,180.99 123.76,181.12 123.76,187.9 123.43,188.24 123.43,189.88 123.68,190.13 127.11,190.13
+PBATT_C2 on TOP (solid shape): 162.05,172.1 162.08,172.08 162.1,172.05 162.1,170.57 161.97,170.45 161.97,168.99 161.91,168.92 161.4,168.92 161.34,168.99 161.34,170.19 161.91,170.76 161.91,172.05 161.92,172.08 161.96,172.1
+PBATT_IN_SS on TOP (solid shape): 130.84,186.58 130.92,186.54 130.95,186.47 131.09,186.16 131.42,186.11 131.51,186.1 131.55,186.02 131.55,181.5 132.06,180.99 134.73,180.99 135.11,180.61 135.11,175.4 134.98,175.27 132.44,175.27 131.68,176.03 127.24,176.03 126.86,176.42 126.86,180.99 127.69,181.82 127.69,184.91 127.31,185.28 127.31,185.74 127.39,185.81 128,185.81 128.76,186.58
+PBATT_IN_SS on BOTTOM (solid shape): 133.64,180.35 133.66,180.35 133.68,180.33 133.71,180.3 133.98,180.03 133.98,176.55 133.84,176.42 129.26,176.42 129.09,176.58 129.09,180.23 129.22,180.35
+PCH_USB_DCPSUS3 on TOP (solid shape): outline of 320 points within 204.73,77.85 207.74,82.69
+PCH_VCCCLK on BOTTOM (solid shape): 209.47,76.05 209.47,75.78 209.56,75.69 209.67,75.69 209.69,75.7 209.88,75.7 209.94,75.64 209.94,75.49 209.81,75.36 209.47,75.36 209.41,75.3 209.41,74.94 209.28,74.82 209.11,74.82 209.06,74.87 209.06,75.06 209.09,75.08 209.09,75.22 209.02,75.29 208.66,75.29 208.58,75.36 208.58,75.5 208.67,75.59 209.01,75.59 209.14,75.72 209.14,76.07 209.23,76.16 209.36,76.16
+PCH_VCCCLK on IN1 (solid shape): outline of 91 points within 209.41,73.55 211.18,75.58
+PCH_VCCCLK on IN3 (solid shape): 217.53,83.59 217.53,82.77 217.33,82.57 217.31,82.57 217.23,82.58 217.14,82.56 216.91,82.56 216.38,82.03 216.38,81.76 215.95,81.33 215.5,81.33 215.2,81.64 215.2,82.21 215.23,82.22 215.43,82.45 215.38,82.75 215.37,82.83 215.41,82.9 215.58,83.22 215.38,83.52 215.32,83.59 215.35,83.68 215.5,83.83 217.29,83.83
+PCH_VCCCLK3_3 on TOP (solid shape): 212.62,73.93 212.69,73.89 212.72,73.81 212.88,73.47 213.25,73.46 213.28,73.48 213.47,73.29 213.45,73.25 213.42,73.16 213.41,73.07 213.41,72.91 212.96,72.47 212.79,72.47 212.53,72.58 212.27,72.47 212.27,72.47 211.88,72.47 211.76,72.59 211.76,72.81 211.84,72.9 211.88,72.95 211.92,73.01 211.95,73.04 211.95,73.16 211.95,73.29 211.86,73.39 211.82,73.43 211.82,73.61 212.14,73.93
+PCH_VCCCLK3_3 on TOP (solid shape): outline of 101 points within 222.23,57.53 226.97,62.71
+PCH_VCCCLK3_3 on BOTTOM (solid shape): 212.33,73.37 212.33,72.81 212.3,72.78 212.3,72.53 212.23,72.45 211.9,72.45 211.79,72.55 211.79,72.83 211.92,72.96 211.92,73.02 211.93,73.03 211.95,73.16 211.93,73.28 211.92,73.31 211.84,73.41 211.74,73.48 211.72,73.5 211.62,73.51 211.54,73.51 211.51,73.5 211.47,73.54 211.48,73.57 211.48,73.65 211.46,73.74 211.46,73.8 211.54,73.88 211.82,73.88
+PCH_VCCDSW3_3 on TOP (solid shape): 138.92,65.52 138.92,64.15 138.79,64.02 138.29,64.02 137.9,64.4 136.38,64.4 136.13,64.66 136.13,65.52 136.3,65.7 138.74,65.7
+PWR_SRC on TOP (solid shape): 294.47,174.03 294.47,172.38 294.34,172.25 293.58,172.25 293.58,171.74 293.2,171.74 293.2,172.25 292.44,172.25 292.44,171.74 292.06,171.74 292.06,172.25 290.79,172.25 290.66,172.38 290.66,174.15 290.79,174.28 294.22,174.28
+PWR_SRC on TOP (solid shape): 124.77,5.69 124.77,4.52 124.42,4.17 122.5,4.17 122.39,4.28 121.95,4.28 121.95,4.84 121.39,4.84 121.39,4.28 121.15,4.28 121.15,4.84 120.61,4.84 120.61,4.28 120.18,4.28 120.01,4.44 120.01,5.35 120.2,5.54 123.62,5.54 123.92,5.84 124.62,5.84
+PWR_SRC on TOP (solid shape): 112.12,177.43 112.12,176.67 112,176.54 110.6,176.54 110.35,176.29 110.35,175.78 110.47,175.65 112.12,175.65 112.25,175.53 112.25,173.75 112.12,173.62 108.57,173.62 108.31,173.37 108.31,171.59 108.06,171.34 102.08,171.34 101.8,171.61 101.8,177.34 102.01,177.56 112,177.56
+PWR_SRC on TOP (solid shape): 176.89,10.29 176.89,9.58 176.86,9.54 176.86,5.99 176.56,5.7 171.06,5.7 170.7,6.07 170.7,6.71 170.15,6.71 170.15,7.14 170.7,7.14 170.7,7.9 170.14,7.9 170.14,8.34 170.68,8.34 170.68,8.78 170.82,8.91 173.5,8.91 173.73,9.14 173.73,10.76 173.95,10.97 176.21,10.97
+PWR_SRC on TOP (solid shape): 144.5,165.13 144.92,165.13 145.23,165.44 145.72,165.44 145.79,165.37 145.79,165.09 146.54,164.34 146.54,159.4 146.79,159.14 146.79,156.74 146.45,156.4 145.56,156.4 145.56,155.87 145.12,155.87 145.12,156.41 144.36,156.41 144.36,155.85 143.91,155.85 143.91,156.43 142.96,156.43 142.59,156.79 142.59,160.62 142.48,160.74 142.48,162.19 141.84,162.83 141.84,165.34 141.93,165.43 142.11,165.43 142.12,165.44 142.22,165.44 142.23,165.44 142.35,165.42 142.47,165.44 142.48,165.44 144.18,165.44
+PWR_SRC on TOP (solid shape): outline of 556 points within 197.59,10.55 247.29,31.2
+PWR_SRC on BOTTOM (solid shape): 109.71,177.05 109.71,175.93 110.69,174.95 113.36,174.95 113.65,174.66 113.65,173.85 113.36,173.56 109.89,173.56 109.71,173.38 109.71,173.37 107.55,171.21 102.46,171.21 102.1,171.56 102.1,177.23 102.43,177.56 109.2,177.56
+PWR_SRC on BOTTOM (solid shape): 179.95,146.76 179.95,145.95 179.81,145.81 178.27,145.81 177.97,145.52 177.97,143.89 177.78,143.7 177.44,143.7 177.24,143.9 177.24,146.41 177.73,146.9 178.7,146.9 178.76,146.96 179.75,146.96
+PWR_SRC on IN4 (solid shape): outline of 468 points within 171.81,8.64 203.32,25.03
+PWR_SRC on IN4 (solid shape): outline of 1026 points within 171.92,145.68 179.85,172.58
+PWR_SRC on VCC: outline of 91 points within 102.47,26.81 293.73,192.53 ; 1 cut-out
+PWR_SRC_AC on TOP (solid shape): 103.03,189.57 103.03,185.57 102.27,184.82 98.39,184.82 97.77,185.43 97.77,186.19 97.26,186.19 97.26,186.58 97.77,186.58 97.77,187.34 97.26,187.34 97.26,187.72 97.77,187.72 97.77,189.62 97.9,189.75 102.85,189.75
+PWR_SRC_AC on TOP (solid shape): 131.94,175.4 131.94,172.61 130.92,171.59 128.25,171.59 128,171.84 128,173.32 128.01,173.35 128.05,173.37 129.52,173.37 129.65,173.49 129.65,174 129.52,174.13 127.85,174.13 127.74,174.23 127.74,174.66 127.49,174.92 127.49,175.4 127.62,175.53 131.81,175.53
+PWR_SRC_AC on TOP (solid shape): 154.75,191 154.75,187.45 152.75,185.46 152.75,183.39 152.18,182.82 150.15,182.82 149.87,183.1 147.79,183.1 147.56,183.32 147.56,188.75 147.57,188.85 147.56,188.95 147.56,189.37 147.58,189.39 147.58,191.12 147.95,191.49 154.25,191.49
+PWR_SRC_AC on VCC: 127.47,172.35 126.86,172.96 126.86,176.01 124.68,178.19 98.26,178.19 97.65,178.81 97.65,192.08 98.95,192.08 99.58,191.08 100.66,190.6 100.67,190.59 100.82,190.59 100.89,190.59 109.2,190.59 109.2,190.3 109.27,188.41 111.16,188.35 111.51,188.35 112.71,188.2 113.5,189.12 113.52,189.14 113.52,189.24 113.53,189.4 113.52,189.55 113.52,190.15 113.96,190.59 135.62,190.59 135.68,190.59 135.83,190.59 135.84,190.6 136.93,191.08 137.56,192.08 156.57,192.08 156.57,182.24 152.53,178.19 138.43,178.19 132.59,172.35
+PWR_SRC_S on TOP (solid shape): 121,4.13 121.56,4.13 121.56,4.67 121.8,4.67 121.8,4.13 122.28,4.13 122.77,3.64 125.54,3.64 125.81,3.37 125.81,1.96 125.48,1.63 123.5,1.63 122.28,2.84 120.2,2.84 120.09,2.96 120.09,4.1 120.12,4.14 120.73,4.14 120.76,4.17 120.76,4.69 121,4.69
+SA_DIMM_VREFDQ on IN2 (solid shape): 135.24,88.79 135.24,88.02 135.11,87.9 134.22,87.9 133.97,88.15 133.97,88.79 134.09,88.91 135.11,88.91
+SDC_IN on TOP (solid shape): 126.91,175.02 126.91,174.26 126.78,174.13 125.2,174.13 125.08,174 125.08,173.49 125.2,173.37 126.73,173.37 127.62,172.48 127.62,171.97 128,171.59 128,169.3 127.87,169.18 124.19,169.18 123.93,169.43 123.93,172.22 123.68,172.48 123.05,172.48 122.92,172.61 122.92,175.02 123.05,175.15 126.79,175.15
+SDC_IN on BOTTOM (solid shape): 126.86,174.51 126.86,172.99 128,171.84 128,169.3 127.74,169.05 124.06,169.05 123.93,169.18 123.93,170.45 122.92,171.46 122.92,174.76 123.05,174.89 126.47,174.89
+SW_LX on TOP (solid shape): 175.12,135.58 175.12,135.44 175.12,135.43 175.12,134.57 175.15,134.53 175.15,133.88 176,133.03 176,131.62 175.75,131.37 174.19,131.37 174.01,131.55 174.01,132.79 174.14,132.92 174.54,132.92 174.8,133.17 174.8,134.44 174.93,134.57 174.93,135.56 174.98,135.61 175.09,135.61
+SWR_V12 on TOP (solid shape): 175.5,130.44 175.5,128.54 175.12,128.16 173.08,128.16 172.96,128.28 172.96,130.31 173.34,130.7 175.24,130.7
+SWR_V12 on BOTTOM (solid shape): outline of 171 points within 169.78,128.09 175.43,136.41
+V_DDR_REF on TOP (solid shape): 210.93,12.74 210.93,11.95 211.01,11.87 211.02,11.86 211.06,11.8 211.12,11.76 211.13,11.75 211.31,11.57 211.31,9.98 211.25,9.92 210.61,9.92 210.55,9.98 210.55,11 210.74,11.19 210.74,12.75 210.76,12.78 210.89,12.78
+VCHGR on TOP (solid shape): 114.92,183.53 114.92,177.81 115.17,177.56 117.33,177.56 117.46,177.43 117.46,173.62 117.33,173.49 112.76,173.49 112.63,173.62 112.63,175.11 113.01,175.27 113.14,175.65 114.79,175.65 114.92,175.78 114.92,176.29 114.79,176.42 112.89,176.42 112.85,176.45 112.85,176.46 112.77,176.56 112.68,176.63 112.67,176.63 112.38,176.92 112.38,178.07 111.74,178.7 110.21,178.7 109.95,178.96 109.95,183.57 110.04,183.65 114.79,183.65
+VCHGR on BOTTOM (solid shape): outline of 93 points within 110.09,174.26 117.33,183.65
+VCHGR_C2 on TOP (solid shape): 161.72,172.1 161.72,170.83 161.02,170.13 161.02,168.99 160.96,168.92 160.38,168.92 160.32,168.99 160.32,169.94 160.17,170.09 160.17,170.43 160.62,170.89 161.26,170.89 161.46,171.09 161.46,172.1 161.53,172.16 161.65,172.16
+VDISPLAY_VCC on TOP (solid shape): 15.46,208.72 16.42,208.72 16.7,209 19.19,209 19.5,208.69 19.5,208.04 19.29,207.82 18.59,207.82 18.42,207.99 14.55,207.99 13.85,208.69 11.81,208.69 11.44,209.05 11.44,209.6 11.78,209.94 14.25,209.94
+VGA_B+ on TOP (solid shape): 293.07,171.55 293.82,171.55 293.82,172.08 295.42,172.08 295.77,171.73 295.77,170.17 295.97,169.96 298.16,169.96 298.81,169.3 298.81,165.77 298.67,165.54 298.73,165.27 298.75,165.19 298.71,165.13 298.57,164.8 298.78,164.52 298.81,164.51 298.81,155.97 298.43,155.59 298.43,147.84 297.67,147.08 292.15,147.08 291.32,147.9 291.32,168.29 291.31,168.29 291.31,172.05 291.35,172.09 291.85,172.09 291.86,172.07 291.86,171.54 292.62,171.54 292.62,172.09 293.07,172.09
+VGA_COREP on BOTTOM (solid shape): outline of 96 points within 267.6,150.76 285.35,165.75
+VGA_PCIE on TOP (solid shape): 193.53,100.01 193.53,98.87 193.48,98.82 190.61,98.82 190.61,98.31 190.42,98.31 190.42,98.82 189.78,98.82 189.78,98.31 189.59,98.31 189.59,98.82 189.02,98.82 188.9,98.95 188.9,100.15 188.96,100.21 192.82,100.21 193.33,100.22
+VGA_PCIE on TOP (solid shape): outline of 287 points within 208.26,122.69 213.27,126.38
+VGA_PCIE on IN3 (solid shape): outline of 1881 points within 210.55,115.07 224.75,126.16
+VGA_PCIE on IN4 (solid shape): outline of 2359 points within 207.75,106.44 225.28,126
+VGA_PCIE on VCC: 188.94,98.69 188.58,99.05 188.58,107.35 188.94,107.71 190.12,107.71 190.76,107.07 195.29,107.07 195.8,107.58 199.35,107.58 204.18,112.41 207.1,112.41 207.63,112.94 207.63,114.84 212.83,120.05 212.83,124.49 213.58,125.23 214.21,125.23 215.86,126.89 233.68,126.89 234.17,126.4 234.17,120.77 233.81,120.41 230.72,120.41 228.43,122.69 224.67,122.69 224.14,122.16 224.14,113.66 220.96,110.48 220.96,103.11 220.35,102.5 195.08,102.5 194.42,101.84 194.42,100.07 193.04,98.69
+VGA_PCIEP on TOP (solid shape): 189.34,98.06 189.97,98.06 189.97,98.56 190.17,98.56 190.17,98.06 190.8,98.06 190.8,98.56 192.51,98.56 192.77,98.31 192.77,89.23 192.58,89.04 188.75,89.04 188.42,89.37 188.42,96.5 188.26,96.66 188.26,98.44 188.39,98.56 189.34,98.56
