# Allegro board LA-9411P R10-0403.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
MSATA_PTX_WANRX_P4_RP: length 2.6
  TOP w0.102: U7.15 321.61,133.3 321.76,133.45 321.76,133.66 321.66,133.76 321.4,133.76 321.12,134.05 321.12,134.35 C403.2
MSATA_PTX_WANRX_P4_RP_C: length 91.4
  TOP w0.102: C403.1 321.19,135.65 321.26,135.72 321.26,136.31 v2(320.95,136.62)
  IN4 w0.114: v2(342.03,209.44) 341.69,209.1 341.69,207.96 341.44,207.71 340.7,207.71 340.57,207.58 340.57,207.26 340.7,207.14 341.44,207.14 341.69,206.89 341.69,206.36 341.44,206.11 340.72,206.11 340.6,205.98 340.6,205.66 340.72,205.54 341.44,205.54 341.69,205.29 341.69,203.45 337.03,198.8 337.03,193.74 336.29,193 336.29,184.97 336.65,184.61 336.65,176.38 335.75,175.48 335.75,169.07 335.47,168.8 335.47,167.45 335.31,167.3 335.31,166.95 331.99,163.62 331.99,158.54 325.56,152.11 325.56,149.3 320.1,143.83 320.1,136.43 320.5,136.03 321.1,136.03 321.27,136.2 321.27,136.3 v2(320.95,136.62)
  BOTTOM w0.102: JMINI1.33 342.15,210.23 341.84,209.91 341.84,209.63 v2(342.03,209.44)
MSCLK: length 184.1
  TOP w0.102: U51.B43 283.58,113.91 v2(283.66,113.99)
  IN2 w0.127: v2(267.75,175.49) 268.09,175.83 274.94,175.83 275.69,175.08 v2(275.69,174.76) 276.14,174.31 276.14,173.98 278.56,171.56 284.01,171.56 289.28,176.83 294.88,176.83 297.1,174.61 309.66,174.61 310.1,174.17 319.98,174.17 320.75,173.41 320.75,172.02 319.9,171.16 319.9,168.59 322.01,166.47 322.01,165.7 322.22,165.49 322.3,165.49 v2(322.31,165.51) ; v2(271.78,141.73) 271.78,141.45 272.6,140.63 276,140.63 277.05,141.67 v2(279,141.67)
  IN3 w0.127: v2(271.78,141.73) 271.7,141.73 271.31,142.13 271.31,142.62 267.41,146.52 267.41,150.1 268.03,150.72 268.03,165.1 267.01,166.12 267.01,173 266.9,173.11 266.9,174.64 v2(267.75,175.49) ; v2(277.68,178.18) 277.68,178.64 270.37,185.95 270.37,187.15 268.93,188.58 268.93,190.12 268,191.05 262.25,191.05 v2(261.69,190.48)
  IN4 w0.102: v2(325.89,162.61) 325.52,162.61 324.95,162.04 323.55,162.04 322.96,162.64 322.96,164.86 v2(322.31,165.51)
  BOTTOM w0.102: v2(275.69,174.76) 275.69,176 276.83,177.14 276.83,177.28 277.68,178.13 v2(277.68,178.18) ; v2(261.69,190.48) 261.45,190.25 JMINI2.19 ; v2(283.66,113.99) 283.57,113.99 282.27,115.3 282.27,119.18 280.14,121.3 280.14,125.67 278.85,126.97 278.85,132.8 278.49,133.16 278.46,133.16 278.32,133.31 278.32,141.02 278.96,141.67 v2(279,141.67) ; R847.2 325.8,162.7 v2(325.89,162.61) 325.98,162.7 326.47,162.7 326.73,162.96 JDEG2.6
MSDATA: length 169.7
  TOP w0.102: v2(256.31,177.52) 256.57,177.25 265.11,177.25 v1(266.58,175.78) 267.34,175.02 267.8,175.02 268.34,174.48 v2(268.71,174.48) ; U51.A40 281.69,114.16 281.49,113.97 280.89,113.97 280.72,114.13 v2(280.72,114.35) 280.72,114.37 280.54,114.19 R869.2
  IN2 w0.127: v2(279.03,142.28) 277.2,142.28 275.93,141.01 273.16,141.01 v2(271.76,142.4) ; v2(322.32,164.81) 321.76,165.37 321.76,166.36 319.64,168.48 319.64,171.27 320.41,172.04 320.41,173.31 319.83,173.9 309.84,173.9 309.51,174.23 297.07,174.23 294.76,176.54 289.37,176.54 284.09,171.27 278.46,171.27 275.26,174.47 275.26,175.03 274.72,175.56 268.7,175.56 268.28,175.15 268.28,174.99 268.71,174.56 v2(268.71,174.48)
  IN3 w0.127: v2(271.76,142.4) 271.76,142.52 267.66,146.62 267.66,149.99 268.28,150.61 268.28,165.21 267.27,166.22 267.27,173.04 v2(268.71,174.48)
  IN4 w0.102: v2(325.86,162.03) 325.26,162.03 325.05,161.81 323.46,161.81 322.73,162.54 322.73,164.4 v2(322.32,164.81)
  BOTTOM w0.102: R706.2 269.86,175.25 269.09,174.48 v2(268.71,174.48) ; v2(280.72,114.35) 280.72,114.37 280.07,115.03 280.07,121.05 279.92,121.2 279.92,125.58 278.62,126.87 278.62,132.71 278.39,132.94 278.37,132.94 278.09,133.22 278.09,141.38 278.99,142.28 v2(279.03,142.28) ; R850.2 325.27,161.68 325.61,162.03 v2(325.86,162.03) 326.14,162.03 326.58,162.46 JDEG2.7 ; v2(256.31,177.52) 256.25,177.58 JMINI2.14
MULTIO_0: length 3.8
  TOP w0.102: R1701.1 R1700.2 v1(246.59,45.1) 246.85,44.84 247.63,44.84 247.83,45.04 U38.18
NB_LAN_TX0+: length 10.6
  TOP w0.267: JLOM1.1 301.62,226.46 301.62,225.63 v4(300.99,224.99) 299.9,223.91 299.9,223.23 298.29,221.61 298.29,220.76 298.12,220.59 297.58,220.59 297.42,220.43 T156.24
NB_LAN_TX0-: length 10.7
  TOP w0.267: T156.23 298.69,221.45 v4(299.63,222.39) 300.3,223.06 300.3,223.75 302.01,225.46 302.01,228.19 JLOM1.2
NB_LAN_TX1+: length 10.6
  TOP w0.267: v2(302.84,221.16) 302.94,221.06 302.94,220.22 302.5,219.79 T156.20
  IN1 w0.191: v2(302.84,221.16) 302.84,221.21 303.09,221.46 303.09,222.64 305.06,224.61 305.06,225.7 303.61,227.16 JLOM1.3
NB_LAN_TX1-: length 10.6
  TOP w0.267: v2(303.42,221.16) 303.33,221.06 303.33,220.38 303.77,219.94 T156.19
  IN1 w0.191: JLOM1.6 306.03,227.88 306.01,227.86 306.01,226.48 305.39,225.87 305.39,224.47 303.42,222.5 v2(303.42,221.16)
NB_LAN_TX2+: length 9.8
  TOP w0.267: JLOM1.4 303.89,228.16 303.89,225.06 305.04,223.91 v4(305.04,221.09) T156.18
NB_LAN_TX2-: length 9.8
  TOP w0.267: JLOM1.5 304.6,227.16 304.29,226.85 304.29,225.22 305.43,224.08 v4(305.43,223.2) 305.43,220.67 305.63,220.47 306,220.47 306.31,220.17 T156.17
NB_LAN_TX3+: length 11.9
  TOP w0.267: 310.12,218.94 310.12,219.87 310.28,220.04 310.83,220.04 310.99,220.21 310.99,220.44 310.39,221.04 v4(309.99,221.04) 309.64,221.04 308.74,221.94 308.2,222.48 306.74,223.94 306.74,225.55 306.27,226.02 306.27,226.8 306.63,227.16 JLOM1.7
NB_LAN_TX3-: length 11.9
  TOP w0.267: T156.13 311.39,220.6 310.56,221.43 309.81,221.43 309.02,222.22 307.13,224.1 v4(307.13,224.57) 307.13,225.46 308.05,226.38 308.05,228.24 JLOM1.8
NB_PSID: length 18.2
  TOP w0.254: v4(144.1,176.42) 144.09,176.4 144.09,174.02 144.58,173.53 v1(145.96,173.53) 146.1,173.53 146.41,173.22 146.41,172.87 v2(148.17,171.12)
  BOTTOM w0.254: PL4.2 150.13,171.26 149.6,171.79 149.08,171.79 148.6,171.32 148.36,171.32 v2(148.17,171.12) ; v4(144.1,176.42) 143.44,175.76 PJPDC1.5
NB_PSID_TS5A63157: length 3.3
  BOTTOM w0.254: PU1.3 155.26,175 v1(155.38,174.88) 155.49,174.76 155.49,174.14 PR11.1 PR12.2
NTC: length 60.2
  TOP w0.102: v4(116.59,155.51) v1(115.73,155.51)
  TOP w0.254: v2(135.49,138.57) 134.6,139.46 PR528.1 PH500.1
  IN1 w0.254: v2(135.49,138.57) 135.49,135.14 134.35,134 134.35,130.7 132.29,128.64 132.29,128.59 130.84,127.14 123.81,127.14 122.22,128.73 v2(122.09,128.73)
  IN2 w0.254: v2(122.09,128.73) 121.52,129.3 121.27,129.3 118.98,131.58 118.98,140.86 121.52,143.4 121.52,149.17 120.19,150.51 118,150.51 117.31,151.2 117.31,154.8 v4(116.59,155.51)
  BOTTOM w0.203: PU500.6 117.57,155.43 117.43,155.56 116.65,155.56 v4(116.59,155.51)
OZ_LDO_EN: length 2.8
  TOP w0.102: U38.14 247.74,46.64 247.43,46.96 v1(246.74,46.96) 245.85,46.96 R894.2
OZ_PE_REXT: length 4.2
  TOP w0.102: v1(253.06,51.76) 252.39,51.1 R677.2 252.32,49.78 252.32,49.46 252.32,49.46 252.32,49.12 252.32,49.12 U38.4
P1_SW: length 44.6
  IN1 w0.254: v4(141.59,134.12) 142.16,133.55 145.84,133.55 146.92,134.63 146.92,135.1 147.96,136.14 147.96,138.16 147.49,138.63 147.49,151.09 145.61,152.97 144.72,152.97 142.01,155.68 136.83,155.68 v4(136.36,155.21)
  BOTTOM w0.127: v1(135.43,157.75) 134.92,157.24 PR552.2
  BOTTOM w0.254: PR553.1 PR552.2 136,156.35 136.36,155.99 v4(136.36,155.21) ; PL503.3 v4(141.59,134.12)
P2_SW: length 24.2
  IN4 w0.254: v4(128.38,134.12) 128.25,134 120.92,134 118.47,136.44 118.47,143.14 v4(118.85,143.52)
  BOTTOM w0.127: v4(118.85,143.52) v1(118.85,142.76)
  BOTTOM w0.254: v4(118.85,143.52) PR538.1 PR536.2 ; PL502.3 v4(128.38,134.12)
P3_SW: length 47.7
  IN2 w0.254: v4(134.34,158.15) 134.34,157.53 135.11,156.76 142.03,156.76 143.45,155.33 143.49,155.33 144.94,153.89 145.8,153.89 148.32,151.37 148.32,138.93 148.76,138.48 148.76,135.75 148.32,135.31 148.32,134 148.83,133.49 153.53,133.49 v4(154.41,134.38)
  BOTTOM w0.254: PR510.2 PR514.2 134.11,159.02 134.34,158.79 v1(134.34,158.76) v4(134.34,158.15) ; PL501.3 v4(154.41,134.38)
P33ALW:
  vias: v1(156.75,169.85)
P33ALW2: length 1.3
  TOP w0.102: 156.17,162.8 v1(156.17,164.12)
PANEL_BKEN_CVT: length 35.9
  TOP w0.102: v2(174.79,142.63) 174.98,142.44 174.98,141.7 175.02,141.66 U27.44 ; v2(181.76,151.33) 181.76,150.99 181.58,150.81 U54.1 181.58,150.2 181.81,149.97 181.81,149.63 181.11,148.93 R1139.1
  IN2 w0.127: v2(174.79,142.63) 175.19,142.23 175.19,141.83 175.51,141.52 179.07,141.52 179.59,142.04 181.03,142.04 181.45,142.46 183.62,142.46 186.13,139.95 v2(186.81,139.95)
  IN3 w0.127: v2(181.76,151.33) 182.55,152.12 184.77,152.12 v2(185.48,151.41)
  IN4 w0.102: v2(186.81,139.95) 186.81,140.53 186.25,141.08 186.25,150.2 185.48,150.97 v2(185.48,151.41)
  BOTTOM w0.102: v2(185.48,151.41) v1(185.48,150.81)
PANEL_BKEN_EC: length 231.4
  TOP w0.102: U46.A35 262.48,55.39 261.93,55.93 261.17,55.93 260.04,57.06 256.13,57.06 256.06,57.12 v1(252.08,57.12) 251.54,57.12 249.92,58.75 v2(249.23,58.75)
  IN3 w0.127: v2(249.23,58.75) 249.23,58.86 248.74,59.36 248.74,60.24 249.58,61.08 249.58,66.42 253.22,70.06 253.22,81.71 251.85,83.08 251.85,85.97 250.3,87.52 250.3,92.96 252.8,95.47 252.8,97.76 258.87,103.83 258.87,112 260.09,113.22 260.09,120.27 261.3,121.48 261.3,128.36 260.46,129.2 260.46,143.13 258.99,144.6 258.99,165.22 257.99,166.21 257.99,169.34 254.22,173.1 253.73,173.1 252.84,173.99 247.75,173.99 246.69,175.04 238.94,175.04 238.09,174.19 232.42,174.19 232.09,173.86 224.49,173.86 224.06,174.29 222.79,174.29 221.36,172.86 221.36,170.09 220.47,169.2 217.8,169.2 217,170 193.06,170 192.91,170.15 188.46,170.15 186.14,167.83 v2(185.78,167.83)
  IN4 w0.102: v2(183.75,157.26) 184.17,157.26 186.65,159.75 186.65,164.17 185.87,164.95 185.87,167.74 v2(185.78,167.83)
  BOTTOM w0.102: D69.2 184.6,156.42 v2(183.75,157.26)
PANEL_BKEN_PCH: length 138
  TOP w0.102: v2(184.31,151.14) 184.31,151.47 183.93,151.85 182.99,151.85 182.62,151.49 182.62,151.32 182.23,150.93 U54.2
  IN2 w0.127: v2(225.5,98.62) 225.6,98.72 225.6,100.47 227.06,101.94 v2(227.06,102.68)
  IN3 w0.089: v2(216.02,72.48) 216.02,71.79 216.78,71.03 217.15,71.03 218.27,69.91 220.51,69.91 220.56,69.96
  IN3 w0.127: v2(226.47,75.92) 226.49,75.92 226.7,75.7 226.7,72.12 224.54,69.96 220.56,69.96
  IN4 w0.102: v2(227.06,102.68) 227.06,103.49 226.29,104.26 221.24,104.26 219.94,105.55 218.29,105.55 217.83,106.01 205.87,106.01 200.36,111.51 194.79,111.51 192.46,113.84 186.05,113.84 185.1,114.79 185.1,148.9 184.32,149.68 184.32,151.16 v2(184.31,151.14)
  BOTTOM w0.089: UH1.K36 215.78,72.47 216,72.47 v2(216.02,72.48)
  BOTTOM w0.102: v2(225.5,98.62) 225.78,98.34 225.78,92.56 227.57,90.77 228.56,90.77 231.9,87.43 231.9,86.08 226.47,80.66 v1(226.47,77.74) v2(226.47,75.92)
PANEL_HDD_LED: length 237.3
  TOP w0.102: v2(280.86,190.44) v1(280.86,191.2)
  IN1 w0.102: v2(159.88,190.16) 160.99,191.27 165.92,191.27 167.19,190 175.13,190 175.43,189.7 178.42,189.7 180.03,191.31 192.62,191.31 193.19,190.74 193.19,189.79 193.43,189.55 198.2,189.55 199.69,191.03 209.27,191.03 209.8,190.5 241.44,190.5 242.06,189.88 257.04,189.88 258.1,190.93 268.04,190.93 269.6,189.37 276.08,189.37 276.74,190.03 278.44,190.03 279.1,189.37 279.84,189.37 280.86,190.39 v2(280.86,190.44)
  IN3 w0.127: v2(280.86,190.44) 280.86,190.4 281.11,190.14 287.65,190.14 288.91,191.4 293.43,191.4 295.51,193.49 295.51,206.43 297.95,208.86 313.12,208.86 317.63,213.37 321.65,213.37 322.25,213.97 323.06,213.97 v2(323.49,213.54)
  BOTTOM w0.102: v2(159.88,190.16) 159.88,189.17 159.86,189.15 159.86,182.02 166.43,175.45 166.43,169.58 168.47,167.54 172.12,167.54 173.26,166.4 173.26,160.69 174.02,159.93 174.02,152.59 175.14,151.47 JLVDS1.8 ; v2(323.49,213.54) 323.74,213.79 Q81.3
PB_PBSS_GC: length 68
  TOP w0.254: PR891.2 v2(134.5,187.27) ; PR841.2 160.18,180.57 v1(159.95,180.8) 159.22,181.53 154.8,181.53 154.34,181.99 v2(154.34,186.32)
  IN1 w0.254: v2(122.82,176.65) 122.82,178.63 124.37,180.17 124.37,184.98 125.27,185.88 130.2,185.88 131.6,187.27 v2(134.5,187.27) 135.42,187.27 138.62,190.47 151.56,190.47 154.34,187.69 v2(154.34,186.32)
  BOTTOM w0.254: PR889.2 116.92,173.85 117.58,174.51 117.58,175.63 117.51,175.7 117.51,177.39 117.81,177.7 122.21,177.7 122.82,177.08 v2(122.82,176.65)
PB_PBSS_GC_C2: length 4.5
  TOP w0.102: PR841.1 161.27,178.75 v1(162.19,178.75)
  TOP w0.203: PR841.1 161.59,178.08 161.59,176.95 161.92,176.62 161.92,176.47 162,176.39 PU808.20
PBAT_PRES#: length 412.8
  TOP w0.102: v2(264.28,54.02) 264.17,54.14 U46.B40
  TOP w0.254: v2(169.81,178.13) 169.63,177.95 169.57,177.95 168.54,176.92 PR865.2 ; v2(83.29,189.24) 83.29,188.99 83.55,188.73 84.91,188.73 v1(86.2,190.03) 86.72,190.55 98.43,190.55 98.6,190.39 103.08,190.39 103.87,189.6 105.1,189.6 105.51,189.19 105.51,187.15 106.22,186.44 112.14,186.44 PD7.1 113.93,185.41 114.83,184.51 v4(114.83,184.15) ; PU804.1 v2(50.77,188.52)
  IN3 w0.127: v2(264.28,54.02) 263.66,54.02 263.26,54.43 261.68,54.43 261.26,54.85 261.26,55.57 261.58,55.89 262.19,55.89 262.62,56.33 262.62,58.19 262.43,58.38 262.43,58.99 261.65,59.77 261.65,62.72 265.1,66.17 265.1,72.37 265.78,73.05 265.78,75.03 266.68,75.93 266.68,93.15 266.81,93.28 266.81,104.5 267.51,105.19 267.51,124.52 266.91,125.12 266.91,128.5 267.15,128.75 267.15,138.36 266.62,138.89 266.62,140.53 265.41,141.74 265.41,143.25 263.22,145.45 263.22,149.54 262.29,150.46 262.29,171.36 262.02,171.63 262.02,173.55 258.85,176.72 256.12,176.72 254.8,178.03 249.06,178.03 248.98,178.12 246.07,178.12 244.79,179.4 238.07,179.4 235.45,176.78 232.79,176.78 225.55,176.78 225.16,176.78 224.96,176.99 221.61,176.99 220.64,176.02 218.24,173.61 203.99,173.61 203.85,173.47 200.71,173.47 200.57,173.61 199.99,173.61 199.64,173.95 196.77,173.95 195.52,172.69 195.1,172.69 194.88,172.48 192.9,172.48 192.26,171.84 181.44,171.84 181.26,172.02 179.74,172.02 179.38,172.38 179.38,172.86 178.95,173.29 177.88,173.29 177.07,172.48 175.4,172.48 174.63,171.72 173.92,171.72 173.59,172.05 171.09,172.05 170.75,172.39 169.63,172.39 v2(169.19,171.95) 168.56,171.32 168.56,169.52 165.59,166.55 163.27,166.55 162.02,165.3 159.95,165.3 156.92,162.27 156.52,162.27 155.4,161.15 149.08,161.15 148.66,160.73 147.77,160.73 147.46,160.43 140.26,160.43 139.74,160.95 139.09,160.95 138.83,160.69 135.42,160.69 135.09,160.36 128.43,160.36 127.53,159.46 126.98,159.46 126.83,159.31 123.81,159.31 123.2,159.92 118.14,159.92 117.75,159.53 v2(116.23,159.53)
  IN4 w0.102: v2(169.81,178.13) 168.14,176.47 168.14,172.65 168.85,171.95 v2(169.19,171.95)
  IN4 w0.254: v4(114.83,184.15) 114.85,184.15 115.25,183.76 115.25,177.7 115.81,177.14 117.75,177.14 117.94,176.95 117.94,175.97 117.58,175.62 117.58,174.23 117.29,173.94 117.29,168.76 117.02,168.49 v2(117.02,166.43) 117.02,165.03 115.87,163.88 115.87,159.88 116.22,159.53 v2(116.23,159.53)
  BOTTOM w0.254: v2(50.77,188.52) 50.77,189.76 52.36,191.35 52.36,191.96 52.81,192.42 69.52,192.42 72.44,189.5 83.04,189.5 v2(83.29,189.24) ; PR9.2 119.96,184.68 117.22,184.68 117.18,184.72 PR6.2 115.4,184.72 v4(114.83,184.15) ; PQ812.1 120.47,166.94 120.12,166.6 117.19,166.6 v2(117.02,166.43)
PBAT_PRES#_C2: length 4.3
  TOP w0.203: PR865.1 166.96,176.92 v1(166.26,176.22) 165.86,175.82 165.86,174.75 165.53,174.42 PU808.13
PBAT_SMBCLK: length 251.2
  TOP w0.102: U51.A56 287.22,108.29 286.81,107.89 286.81,107.54 286.43,107.16 v2(286.42,107.16) 286.39,107.13 286.39,107.12 285.8,106.53 R820.2 ; v2(275.18,169.09) 275.06,169.2 274.75,169.2 274.17,168.62 272.09,168.62 270.92,167.45 261.51,167.45 259.32,169.63 252.08,169.63 249.25,172.47 243.4,172.47 242.35,173.52 242.35,174 241.9,174.45 205.97,174.45 204.1,176.32 204.1,176.64 v2(203.89,176.85)
  IN1 w0.102: v2(275.18,169.09) 275.33,169.24 275.64,169.24 275.87,169.02 275.87,168.6 274.65,167.38 274.65,151.91 273.79,151.06 273.79,148.8 274.7,147.9 274.7,146.53 277.27,143.95 277.27,137.51 277.53,137.26 277.53,133.23 278.2,132.56 278.2,126.09 277.71,125.6 277.71,123.03 278.9,121.84 278.9,115.11 280.95,113.06 281.24,113.06 281.26,113.09 281.55,113.09 283.29,111.36 285.86,111.36 286.03,111.18 286.03,109.84 286.81,109.06 286.81,107.54 286.43,107.16 v2(286.42,107.16) ; v2(203.89,176.85) 204.06,177.01 204.06,178.55 204,178.61 204,180.14 202.32,181.81 200.66,181.81 198.76,183.71 193.12,183.71 192.94,183.52 191.22,183.52 188.55,186.19 188.25,186.19 185.17,189.28 181.57,189.28 180.71,190.14 179.64,190.14 178.74,189.24 175.24,189.24 174.95,189.53 167.01,189.53 165.77,190.78 161.62,190.78 160.33,189.5 159.01,189.5 157.72,190.78 138.5,190.78 136.92,189.21 135.43,187.72 131.61,187.72 130.07,186.18 124.32,186.18 121.73,183.59 119.91,183.59 v2(119.7,183.39)
  BOTTOM w0.102: PR7.2 122.06,183.64 122.06,183.39 121.73,183.07 120.28,183.07 119.94,183.42 119.73,183.42 v2(119.7,183.39)
PBAT_SMBDAT: length 263.7
  TOP w0.102: v2(282.68,104.71) 282.68,103.16 284.41,101.43 R818.2 ; v2(287.87,110.64) 287.74,110.51 287.13,110.51 286.9,110.29 286.9,109.7 286.97,109.63 U51.B59 ; v2(275.18,169.67) 274.94,169.43 274.66,169.43 274.07,168.85 271.99,168.85 270.82,167.68 261.6,167.68 259.42,169.86 252.18,169.86 249.35,172.69 243.5,172.69 242.58,173.61 242.58,174.09 241.99,174.68 206.07,174.68 204.33,176.42 204.33,176.69 v2(204.48,176.85)
  IN1 w0.102: v2(119.7,183.97) 119.86,183.82 121.63,183.82 124.22,186.41 129.98,186.41 131.52,187.95 135.34,187.95 136.76,189.37 138.4,191.01 157.82,191.01 159.1,189.73 160.24,189.73 161.52,191.01 165.86,191.01 167.11,189.76 175.05,189.76 175.34,189.47 178.54,189.47 179.45,190.37 180.81,190.37 181.67,189.51 185.26,189.51 188.35,186.42 188.64,186.42 191.31,183.75 192.84,183.75 193.02,183.93 198.86,183.93 200.75,182.04 202.41,182.04 204.22,180.23 204.22,178.71 204.29,178.64 204.29,177.05 204.48,176.86 v2(204.48,176.85) ; v2(275.18,169.67) 275.38,169.47 275.74,169.47 276.09,169.11 276.09,168.5 274.87,167.28 274.87,151.82 274.02,150.96 274.02,148.89 274.93,147.99 274.93,146.62 277.5,144.04 277.5,137.61 277.76,137.35 277.76,133.32 278.43,132.65 278.43,126 277.94,125.5 277.94,123.13 279.13,121.93 279.13,115.2 281.01,113.32 281.64,113.32 283.38,111.58 287.33,111.58 287.87,111.04 v2(287.87,110.64) 287.65,110.64 287.53,110.51 287.14,110.51 286.9,110.27 286.9,109.29 287.65,108.54 287.65,107.3 286.56,106.21 283.74,106.21 282.68,105.16 v2(282.68,104.71)
  BOTTOM w0.102: v2(119.7,183.97) 120.38,183.3 121.64,183.3 121.81,183.48 121.81,183.72 PR8.2
PCH_ALW_ON: length 337.6
  TOP w0.102: R880.2 v2(284.27,123.28) ; v2(254.77,118.96) v1(254.77,119.88) ; U51.A23 288.22,119.92 v2(288.01,120.13) ; U103.3 248.16,143.26 248.37,143.47 248.37,144.3 v2(248.29,144.37)
  TOP w0.254: v2(129.76,4.08) 129.76,4.1 129.54,4.33 PR21.1
  IN1 w0.102: v2(186.39,80.89) 186.39,86.64 182.86,90.17 182.86,99.34 182.8,99.4 v2(182.8,100.58)
  IN2 w0.127: v2(284.27,123.28) 283.57,123.28 283.08,122.78 280.08,122.78 279.93,122.63 279.61,122.63 278.81,121.83 277.66,121.83 277.15,121.32 276.47,121.32 275.48,122.31 272.53,122.31 271.11,120.89 262.06,120.89 261.37,120.21 257.06,120.21 255.81,118.96 v2(254.77,118.96)
  IN3 w0.127: v2(129.76,4.08) 128.51,5.33 128.51,7.06 129.19,7.75 129.19,10.64 132.06,13.51 144.67,13.51 147.02,11.16 159.98,11.16 162.99,14.17 181.15,14.17 185.59,18.62 185.59,21.3 188.24,23.95 190.57,23.95 191.54,24.92 191.54,27.24 191.22,27.56 191.22,34.08 193.07,35.93 193.07,42.76 177.92,57.91 177.92,69.39 185,76.47 185,79.49 v2(186.39,80.89) ; v2(288.01,120.13) 288.37,120.13 288.63,120.38 288.63,121.12 287.92,121.83 285.72,121.83 v2(284.27,123.28) ; v2(182.8,100.58) 182.77,100.61 182.77,102.21 183.6,103.03 188.09,103.03 188.79,103.73 194.94,103.73 195.07,103.61 201.69,103.61 203.06,102.23 215.85,102.23 223,95.08 237.58,95.08 246.15,103.65 246.15,104.85 249.09,107.79 249.09,109.64 249.84,110.39 249.84,114.03 v2(254.77,118.96) 254.77,119.18 254.32,119.63 254.32,123.28 253.46,124.14 253.46,130.85 253.67,131.05 253.67,135.45 254.86,136.64 254.86,145.71 254.57,146 252.29,146 250.67,144.37 v2(248.29,144.37)
PCH_AZ_BITCLK: length 13.8
  BOTTOM w0.089: 215.99,65.42 215.06,66.35 215.06,66.47 UH1.B25
  BOTTOM w0.102: 215.99,65.42 216.53,64.87 217.21,64.87 217.33,64.74 217.33,64.57 217.21,64.44 216.85,64.44 216.72,64.31 216.72,64.06 216.85,63.93 217.29,63.93 217.5,64.13 217.65,64.13 217.75,64.03 218.04,64.03 218.17,64.16 218.17,64.34 218.31,64.48 218.56,64.48 218.67,64.36 218.67,63.65 218.82,63.5 219.12,63.5 219.22,63.6 219.22,64.19 219.33,64.29 v1(219.69,64.29) 220.14,64.29 220.39,64.04 220.39,63.88 220.24,63.73 219.73,63.73 219.64,63.64 219.64,63.39 219.31,63.06 219.31,62.91 RH65.2 220.3,63.06 220.4,63.06
PCH_AZ_CODEC_BITCLK: length 233.5
  TOP w0.102: CH9.1 R1076.1 332.67,171.59 333.1,172.02 v2(333.38,172.02) 333.48,172.12 335.17,172.12 335.71,171.59 U74.6
  IN1 w0.102: v2(328.23,171.49) 328.48,171.49 328.81,171.16 329.12,171.16 329.36,171.4 332.48,171.4 333.1,172.02 v2(333.38,172.02) ; v2(268.52,172.92) 268.37,172.92 267.35,171.9 267.35,170.1 266.83,169.58 266.83,166.03 267.71,165.16 267.71,154.54 267.9,154.34 267.9,150.65 267.01,149.76 267.01,144.96 268.69,143.28 268.69,140.44 268.98,140.15 268.98,139.67 269.77,138.87 269.77,138.52 269.2,137.95 269.2,135.27 268.94,135 268.94,128.36 268.46,127.88 268.46,108.23 269.09,107.6 269.09,101.01 268.37,100.29 268.37,99.78 261.29,92.7 261.29,90.45 256.56,85.72 256.56,74.33 255.96,73.73 255.96,69.55 252.49,66.08 236.61,66.08 235.93,65.4 231.79,65.4 230.82,64.44 230.82,62.83 226.3,58.31 v2(223.78,58.31)
  IN4 w0.102: v2(328.23,171.49) 328.23,171.72 327.76,172.19 327.76,172.45 327.2,173.01 325.92,173.01 324.56,174.37 318.51,174.37 317.73,173.58 314.13,173.58 313.41,172.86 303.26,172.86 302.23,173.89 296.05,173.89 293.89,176.05 292.32,176.05 291.95,176.42 287.55,176.42 287.25,176.11 283.57,176.11 282.94,176.74 273.04,176.74 271.71,175.42 271.71,175.06 269.67,173.02 268.63,173.02 v2(268.52,172.92)
  BOTTOM w0.102: RH65.1 221.26,60.97 221.26,59.84 221.79,59.31 221.79,59.03 222.51,58.31 v2(223.78,58.31)
PCH_AZ_CODEC_RST#: length 272.9
  TOP w0.102: v2(335.8,163.74) 335.8,161.68 339.03,158.44 346.85,158.44 352.05,163.65 R39.1 ; v2(336.52,168.51) 337.09,169.09 U74.11
  IN1 w0.102: v2(335.8,163.74) 335.06,164.48 335.06,168.62 335.38,168.94 336.1,168.94 v2(336.52,168.51) 336.81,168.81 336.81,169.25 335.15,170.92 335.15,171.22 333.9,172.47 327.48,172.47 327.25,172.23 327.25,171.78 327.01,171.54 v2(326.89,171.54) ; v2(218.56,58.94) 218.56,58.22 219.54,57.24 219.54,56.73 221.33,54.94 230.06,54.94 231,54 234.12,54 234.73,54.62 234.73,56.27 235.83,57.37 243.63,65.17 252.87,65.17 255.01,67.31 255.01,67.31 260.03,72.33 260.03,87.89 262.23,90.09 262.23,90.34 265.62,93.73 265.62,95.73 269.29,99.4 269.29,99.89 270.24,100.84 270.24,118.7 269.98,118.95 269.98,124.52 270.79,125.32 270.79,127.65 270.79,128.24 269.85,129.18 269.85,134.62 270.12,134.89 270.12,137.57 270.68,138.14 270.68,138.89 270.68,138.99 270.9,139.2 270.9,139.73 270.57,140.06 270.06,140.06 269.81,140.31 269.81,142.97 267.56,145.22 267.56,149.63 268.37,150.44 268.37,154.55 268.16,154.76 268.16,165.37 267.29,166.24 267.29,169.39 267.85,169.95 267.85,170.35 v2(268,170.51)
  IN4 w0.102: v2(268,170.51) 268.07,170.51 268.5,170.94 270.29,170.94 271.95,172.61 271.95,173.48 273.79,175.31 277.18,175.31 277.92,176.06 282.66,176.06 283.32,175.39 288.11,175.39 288.43,175.7 291.69,175.7 292.03,175.36 293.52,175.36 296.01,172.87 300.96,172.87 301.67,172.16 304.26,172.16 305.27,171.14 306.49,171.14 307.22,171.88 309.61,171.88 310.24,171.25 311.03,171.25 311.92,172.14 313.65,172.14 314.42,172.9 318.01,172.9 318.8,173.68 324.14,173.68 326.28,171.54 v2(326.89,171.54)
  BOTTOM w0.102: RH63.1 218.47,59.61 218.56,59.52 v2(218.56,58.94)
PCH_AZ_CODEC_SDIN0: length 250.7
  TOP w0.102: v2(333.36,171.4) 334.17,170.59 R1096.1 ; v2(268.5,172.34) v1(268.5,171.75)
  IN1 w0.089: 213.58,61.46 211.73,63.31 211.73,66.83 210.66,67.89 v2(210.66,68.58)
  IN1 w0.102: v2(327.62,171.51) 327.62,171.49 328.2,170.9 329.19,170.9 329.46,171.17 333.13,171.17 v2(333.36,171.4) ; 213.58,61.46 214.15,61.46 217.43,58.18 217.43,57.32 218.54,56.21 219.42,56.21 221.15,54.48 229.87,54.48 230.81,53.54 234.31,53.54 235.19,54.43 235.19,56.08 236.29,57.18 243.82,64.71 253.06,64.71 255.15,66.81 260.49,72.14 260.49,87.7 262.68,89.9 262.68,90.15 266.08,93.54 266.08,95.54 269.14,98.61 269.95,98.61 271.56,100.22 271.56,101.43 270.7,102.3 270.7,118.99 270.55,119.13 270.55,123.8 271.24,124.48 271.24,127.46 271.24,128.52 270.31,129.46 270.31,134.43 270.58,134.7 270.58,137.38 271.14,137.95 271.14,138.76 271.36,138.98 271.36,140.02 270.04,141.34 270.04,143.14 267.81,145.36 267.81,149.54 268.6,150.33 268.6,154.69 268.4,154.89 268.4,165.46 267.51,166.34 267.51,169.3 268.44,170.22 268.44,172.28 v2(268.5,172.34)
  IN4 w0.102: v2(327.62,171.51) 327.48,171.65 327.48,172.41 327.15,172.73 325.83,172.73 324.42,174.14 318.61,174.14 317.82,173.35 314.23,173.35 313.51,172.63 303.14,172.63 302.12,173.66 295.94,173.66 293.78,175.82 292.22,175.82 291.85,176.19 287.78,176.19 287.48,175.89 283.47,175.89 282.85,176.51 277.57,176.51 276.86,175.81 272.43,175.81 271.94,175.32 271.94,174.97 269.41,172.44 268.6,172.44 v2(268.5,172.34)
  BOTTOM w0.089: UH1.L22 211.05,68.58 v2(210.66,68.58)
PCH_AZ_CODEC_SDOUT: length 231.9
  TOP w0.102: U74.5 v2(336.61,172.09) 336.15,172.09 v1(336.02,172.22) 335.63,172.61 R1077.1
  IN1 w0.102: v2(336.61,172.09) 335.02,172.09 334.3,172.81 327.5,172.81 326.87,172.18 v2(326.84,172.18) ; v2(267.95,171.21) 267.58,170.83 267.58,170.01 267.06,169.49 267.06,166.15 267.93,165.27 267.93,154.64 268.14,154.44 268.14,150.55 267.25,149.67 267.25,145.13 269.58,142.81 269.58,139.74 270.23,139.09 270.23,138.7 270.23,138.33 269.66,137.76 269.66,135.08 269.39,134.81 269.39,128.96 270.33,128.03 270.33,125.51 269.53,124.71 269.53,118.76 269.78,118.51 269.78,101.05 269.09,100.36 269.09,100.34 268.83,100.08 268.83,99.59 265.16,95.92 265.16,93.92 261.77,90.53 261.77,90.28 259.57,88.08 259.57,72.52 254.82,67.77 252.68,65.63 243.44,65.63 233.82,56 231.82,56 231.58,55.77 222.04,55.77 v2(221.85,55.57)
  IN4 w0.102: v2(326.84,172.18) 326.83,172.19 325.99,172.19 324.26,173.91 318.7,173.91 317.92,173.13 314.32,173.13 313.59,172.39 307.41,172.39 306.39,171.37 305.37,171.37 304.35,172.39 301.9,172.39 301.17,173.12 296.14,173.12 293.67,175.59 292.13,175.59 291.76,175.96 288.13,175.96 287.83,175.66 283.38,175.66 282.75,176.28 277.66,176.28 276.96,175.58 273.73,175.58 269.67,171.51 268.26,171.51 v2(267.95,171.21)
  BOTTOM w0.102: RH59.1 221.85,56.02 v2(221.85,55.57)
PCH_AZ_CODEC_SYNC: length 298.6
  TOP w0.102: v2(335.9,168.53) 335.91,168.53 v1(336.55,169.16) 336.97,169.59 U74.10
  IN1 w0.102: v2(335.9,168.53) 336.37,168.06 336.65,168.06 337.42,168.83 337.42,172.12 337,172.54 334.89,172.54 334.39,173.04 327.24,173.04 v2(326.86,173.42)
  IN4 w0.102: v2(326.86,173.42) 326.82,173.46 325.85,173.46 323.53,175.78 322.02,175.78 320.84,174.6 318.42,174.6 317.63,173.81 314.04,173.81 313.32,173.09 303.54,173.09 302.51,174.12 296.53,174.12 295.93,174.71 295.93,175.42 295.72,175.64 294.71,175.64 294.08,176.28 292.41,176.28 292.03,176.66 288.24,176.66 287.51,177.39 279.73,177.39 279.3,176.97 271.9,176.97 267.53,172.61 267.53,167.26 268.59,166.2 268.59,150.34 268.22,149.97 268.22,146.22 267.55,145.55 267.55,139 267.97,138.59 267.97,129.9 268.22,129.64 268.22,118.34 268.56,117.99 268.56,113.22 268.22,112.88 268.22,104.29 266.52,102.59 266.52,100.76 265.9,100.14 265.9,99.4 263.41,96.91 263.41,96.48 262.88,95.95 262.88,95.95 259.44,92.51 259.44,91.1 258.4,90.06 258.4,79.27 259.14,78.54 259.14,63.3 259.93,62.52 259.93,61.07 259.55,60.69 259.55,55.44 259.77,55.21 259.77,54.59 259.77,53.62 259.72,53.57 259.72,46.04 258.91,45.23 258.91,42.24 255.52,38.85 252.92,38.85 252.66,38.6 249.69,38.6 249.41,38.87 244.03,38.87 239.52,43.38 239.52,48.47 239.07,48.93 238.03,48.93 237.54,49.42 234.36,49.42 232.32,47.37 219.68,47.37 217.48,45.17 205.38,45.17 202.43,48.12 199.63,48.12 v2(198.73,49.02)
  BOTTOM w0.102: RH61.1 202.49,50.32 201.14,48.97 198.78,48.97 v2(198.73,49.02)
PCH_AZ_MDC_BITCLK: length 141.5
  TOP w0.102: v2(269.36,138.68) v1(269.36,139.78)
  IN1 w0.102: v2(223.31,58.88) 226.55,58.88 230.6,62.92 230.6,64.53 231.69,65.63 235.83,65.63 236.51,66.31 252.39,66.31 255.73,69.65 255.73,73.85 256.29,74.42 256.29,85.77 261.06,90.54 261.06,92.79 268.12,99.85 268.12,101.66 268.71,102.26 268.71,107.65 268.06,108.31 268.06,112.27 268.08,112.29 268.08,127.83 268.44,128.18 268.71,128.45 268.71,135.1 268.98,135.36 268.98,138.3 v2(269.36,138.68)
  IN2 w0.127: v2(260.9,134.65) 260.9,134.67 261.81,135.57 266.64,135.57 269.36,138.29 v2(269.36,138.68)
  BOTTOM w0.102: R753.2 251.03,135.8 JMDC1.12 257.98,135.8 258.44,135.33 258.62,135.33 258.97,134.98 260.4,134.98 260.73,134.65 v2(260.9,134.65) ; RH64.1 221.38,63.38 221.38,63.36 CH8.1 222.48,63.07 222.94,62.61 222.94,59.25 v2(223.31,58.88)
PCH_AZ_MDC_RST1#: length 4.4
  BOTTOM w0.102: JMDC1.11 260.36,135.8 260.73,135.43 v2(260.93,135.43) 261.06,135.43 Q44.3 262.05,136.43 262.05,137.28 R751.1
PCH_AZ_MDC_RST#: length 135.2
  IN1 w0.102: v2(270.49,139.48) 270.49,139.39 270.45,139.36 270.45,138.8 270.46,138.8 270.46,138.23 269.89,137.67 269.89,134.98 269.62,134.72 269.62,129.08 270.56,128.15 270.56,127.74 270.56,127.74 270.56,125.41 269.76,124.61 269.76,118.85 270.01,118.6 270.01,100.95 269.32,100.26 269.32,100.24 269.06,99.98 269.06,99.49 265.39,95.83 265.39,93.82 262,90.43 262,90.18 259.8,87.98 259.8,72.42 254.91,67.54 252.77,65.4 243.53,65.4 234.51,56.37 234.51,54.71 234.02,54.23 231.09,54.23 230.15,55.17 221.43,55.17 219.81,56.79 219.81,57.61 v2(219.01,58.41)
  IN2 w0.127: v2(264.46,135.08) 264.7,135.32 266.75,135.32 270.45,139.03 270.45,139.36 270.49,139.39 v2(270.49,139.48)
  BOTTOM w0.102: RH62.1 219.1,58.5 v2(219.01,58.41) ; Q44.1 264.02,135.52 v2(264.46,135.08)
PCH_AZ_MDC_SDIN1: length 152.7
  TOP w0.102: v2(264.45,138.11) v1(263.84,138.11)
  IN1 w0.089: 213.81,61.7 213.64,61.7 211.93,63.4 211.93,65.56 212.86,66.48 212.86,67.09 211.8,68.15 v2(211.08,68.15)
  IN1 w0.102: v2(270.29,140.5) 270.37,140.42 270.53,140.42 271.13,139.83 271.13,139.09 270.91,138.87 270.91,138.04 270.35,137.48 270.35,134.8 270.08,134.53 270.08,129.36 271.01,128.42 271.01,128.31 271.01,128.31 271.01,127.55 271.01,125.22 270.33,124.53 270.33,118.93 270.47,118.79 270.47,102.15 271.28,101.33 271.28,100.29 269.86,98.87 269.08,98.87 265.85,95.64 265.85,93.63 262.45,90.24 262.45,89.99 260.26,87.79 260.26,72.23 255.1,67.08 252.96,64.94 243.72,64.94 236,57.22 234.96,56.18 234.96,54.52 234.21,53.77 230.9,53.77 229.96,54.71 221.24,54.71 219.51,56.44 218.64,56.44 217.78,57.3 217.78,58.31 214.38,61.7 213.81,61.7
  IN2 w0.127: v2(264.45,138.11) 264.69,138.11 267.08,140.5 v2(270.29,140.5)
  BOTTOM w0.089: UH1.K22 211.47,68.15 v2(211.08,68.15)
  BOTTOM w0.102: RH362.1 264.24,138.32 v2(264.45,138.11)
PCH_AZ_MDC_SDOUT: length 135.6
  TOP w0.102: v1(264.96,139.74) 264.64,140.06 v2(264.17,140.06)
  IN1 w0.102: v2(269.1,142.07) 269.35,141.82 269.35,139.64 270,138.99 270,138.42 269.43,137.86 269.43,135.17 269.17,134.91 269.17,128.87 270.1,127.93 270.1,125.6 269.3,124.8 269.3,118.66 269.55,118.41 269.55,101.14 268.6,100.19 268.6,99.68 264.93,96.02 264.93,94.01 261.54,90.62 261.54,90.37 257.4,86.23 257.4,80.74 257.44,80.7 257.44,80.36 257.4,80.32 257.4,74.68 256.32,73.6 256.32,69.59 252.58,65.85 243.35,65.85 233.72,56.23 232.47,56.23 231.57,57.14 230.39,57.14 229.24,55.99 222.33,55.99 221.89,56.44 v2(220.85,56.44)
  IN2 w0.127: v2(269.1,142.07) 269.07,142.05 266.21,142.05 264.22,140.06 v2(264.17,140.06)
  BOTTOM w0.102: RH58.1 219.69,56.71 219.96,56.44 v2(220.85,56.44) ; v2(264.17,140.06) 264.17,140 263.17,139 262.62,139 R754.2 261.45,139 260.22,139 260.21,139 JMDC1.3
PCH_AZ_MDC_SYNC: length 166.9
  TOP w0.102: v1(262.24,138.8) 263.77,138.8 v2(264.17,139.19)
  IN1 w0.102: v2(202.48,49.71) 202.48,49.07 206.03,45.52 211.27,45.52 212.25,46.49 214.44,46.49 214.98,47.04 217.2,47.04 222.04,51.88 226.37,51.88 226.61,51.64 229.48,51.64 230.43,52.58 234.71,52.58 236.16,54.03 236.16,55.17 239.12,58.13 239.81,58.13 240.83,59.15 240.83,59.84 242.94,61.95 244.88,61.95 246.63,63.7 253.41,63.7 255.28,65.57 261.45,71.74 261.45,81.98 262.03,82.56 262.64,82.56 262.91,82.83 262.91,90.05 266.3,93.44 266.3,95.45 269.23,98.37 270.06,98.37 271.83,100.14 271.83,101.51 270.92,102.41 270.92,119.08 270.78,119.22 270.78,123.7 271.47,124.39 271.47,128.82 270.54,129.75 270.54,134.34 270.8,134.61 270.8,137.27 271.37,137.83 271.37,138.54 271.6,138.77 271.6,140.11 270.49,141.21 v2(270.49,142.01)
  IN2 w0.127: v2(264.17,139.19) 264.17,139.32 266.35,141.5 266.64,141.5 266.66,141.52 269.79,141.52 270.29,142.01 v2(270.49,142.01)
  BOTTOM w0.102: v2(202.48,49.71) 202.75,49.71 RH60.1 ; JMDC1.7 259.81,137.4 261.18,138.77 263.75,138.77 v2(264.17,139.19)
PCH_AZ_RST#: length 13.6
  BOTTOM w0.089: UH1.C24 214.35,66.81 214.45,66.71 214.45,66.04 214.89,65.6
  BOTTOM w0.102: 214.89,65.6 215.23,65.6 216.25,64.58 216.25,63.97 215.84,63.56 215.73,63.56 215.64,63.47 215.64,63.22 215.73,63.13 216.02,63.13 216.12,63.02 216.12,62.87 216.02,62.76 215.88,62.76 215.77,62.65 215.77,62.49 215.88,62.38 216.12,62.38 216.26,62.52 216.43,62.52 216.67,62.28 216.67,62.09 216.58,62 215.98,62 215.87,61.89 215.87,61.73 215.98,61.62 v1(216.42,61.62) 216.75,61.62 216.83,61.54 216.83,61.15 216.95,61.04 217.13,61.04 217.24,61.15 217.24,61.43 217.32,61.5 217.76,61.5 217.85,61.41 217.85,61.29 217.56,61 217.56,60.85 RH63.2 218.45,61.21 218.46,61.21
PCH_AZ_SDIN0_R: length 2.6
  TOP w0.102: R1096.2 336.38,170.57 v1(336.39,170.59) U74.8
PCH_AZ_SDOUT: length 20
  BOTTOM w0.089: UH1.A24 214.93,66.17 215.92,65.18
  BOTTOM w0.102: 215.92,65.18 216.49,64.61 216.49,63.89 216.18,63.57 216.18,63.37 216.29,63.26 216.43,63.26 216.73,63.55 216.84,63.55 216.92,63.46 216.92,63.12 217.06,62.98 217.36,62.98 217.48,63.11 217.48,63.28 217.31,63.46 217.31,63.63 217.45,63.77 217.6,63.77 217.74,63.63 217.93,63.63 218.12,63.82 218.3,63.82 218.44,63.67 218.44,63.49 218.2,63.25 218.2,62.9 218.12,62.81 217.77,62.81 217.64,62.68 217.64,62.52 217.76,62.39 217.85,62.39 217.98,62.26 217.98,61.82 218.11,61.69 218.32,61.69 218.44,61.81 218.44,62.55 218.57,62.68 218.98,62.68 219.1,62.55 219.1,61.21 219.66,60.66 219.66,60.31 219.47,60.12 219.47,59.84 219.6,59.72 v1(219.82,59.72) 219.95,59.59 219.95,59.22 219.82,59.09 219.6,59.09 219.47,58.97 219.47,58.4 RH59.2 ; RH58.2 RH59.2 ; RH59.2 RH45.2
PCH_AZ_SYNC: length 50.1
  TOP w0.102: RH41.2 215.93,65 215.52,64.6 v2(215.3,64.6) ; v2(225.04,56.9) 224.38,56.24 v1(224.38,54.33) 224.38,52.15 225.87,50.66 v2(225.87,50.48)
  IN1 w0.102: v2(225.04,56.9) 224.39,57.54 223.69,57.54 222.99,58.24 222.17,58.24 221.72,58.69 221.72,59.35 221.3,59.78 221.29,59.78 216.47,64.6 v2(215.3,64.6)
  IN4 w0.102: v2(225.87,50.48) 225.9,50.44 225.9,50.43 225.24,49.77 219.17,49.77 218.26,50.69 214.61,50.69 212.69,48.76 210.42,48.76 v2(210.31,48.87)
  BOTTOM w0.089: UH1.A22 214.18,65.18 214.69,64.67 215.24,64.67 215.25,64.66
  BOTTOM w0.102: v2(215.3,64.6) 215.25,64.65 215.25,64.66 ; RH60.2 RH61.2 203.41,51.63 203.77,51.63 204.2,52.06 205.42,52.06 207.77,49.71 209.47,49.71 v2(210.31,48.87)
PCH_BATLOW#: length 17.6
  TOP w0.089: v2(207.2,63.75) 206.91,63.75 v1(206.7,63.96)
  TOP w0.102: RH112.2 201.89,52.61 202.46,52.04 v2(203.42,52.04)
  IN1 w0.089: v2(207.2,63.75) 206.66,63.75 205.89,62.98 205.89,60.53 205.35,59.99 205.35,59.82
  IN1 w0.102: v2(203.42,52.04) 203.81,52.43 203.81,55.69 205.65,57.53 205.65,59.04 205.35,59.33 205.35,59.82
  BOTTOM w0.089: v2(207.2,63.75) 207.01,63.75 UH1.K7
PCH_CL_CLK1: length 280.8
  TOP w0.102: v2(270.21,169.24) 270.35,169.38 270.42,169.38 270.99,169.95 v1(271.48,169.95) 271.65,170.12 272.94,170.12 273.19,170.36 273.19,171.37 273.62,171.81 274.13,171.81 274.71,172.39 274.71,173.14 276.09,174.52 276.09,174.93 276.08,174.95 276.08,180.76 272.8,184.04 272.8,184.45 v2(272.52,184.73)
  IN4 w0.089: v2(202.83,69.92) 202.83,69.07 201.95,68.19 201.95,67.57 201.33,66.95 200.81,66.95 198.37,64.52
  IN4 w0.102: v2(270.21,169.24) 270.05,169.24 269.71,168.9 269.71,168.48 270.09,168.1 270.09,149.47 269.76,149.14 269.76,145.68 269.52,145.44 269.52,141.76 269.39,141.63 269.39,139.26 269.79,138.85 269.79,138.53 269.41,138.15 269.41,130.5 269.67,130.24 269.67,129.18 270.61,128.24 270.61,126.49 269.71,125.59 269.71,119.3 270.61,118.4 270.61,113.22 270.14,112.75 270.14,102.45 269.45,101.76 269.45,101.08 268.83,100.46 268.83,99.76 268.41,99.34 268.41,98.86 265.9,96.34 265.9,94.68 263.5,92.28 263.5,90.23 262.91,89.64 262.91,77.3 262.72,77.11 262.72,70.43 262.91,70.24 262.91,65.7 262.67,65.46 262.67,58.48 263.44,57.71 263.44,48.34 263.7,48.08 263.7,47.56 263.22,47.08 263.22,46.06 262.61,45.45 262.61,43.28 261.97,42.65 261.97,33.3 251.75,23.08 245.07,23.08 244.52,22.53 234.01,22.53 232.12,24.42 222.23,24.42 220.94,25.72 216.73,25.72 213.36,29.1 211.69,29.1 208.01,32.78 208.01,36.08 202.02,42.07 202.02,43.83 200.57,45.29 198.85,45.29 192.65,51.48 192.65,53.56 192.31,53.9 192.31,55.59 191.87,56.03 191.87,59.18 192.85,60.16 194.9,60.16 196.54,61.8 196.54,62.84 197.95,64.25 198.05,64.25 198.31,64.51 198.37,64.51 198.37,64.52
  BOTTOM w0.089: v2(202.83,69.92) 202.9,69.84 UH1.AF11
  BOTTOM w0.102: JMINI2.45 271.85,185.41 v2(272.52,184.73)
PCH_CL_DATA1: length 282
  TOP w0.102: v2(270.21,168.63) 271,169.42 271.59,169.42 271.88,169.71 273.07,169.71 273.59,170.23 273.59,171.27 273.77,171.45 274.38,171.45 275.12,172.19 275.12,172.92 277.27,175.08 v1(277.27,175.59) 277.27,180.09 273.34,184.02 273.34,184.73 v2(273.16,184.91)
  IN4 w0.089: v2(202.43,69.5) 202.43,68.94 201.75,68.26 201.75,67.64 201.43,67.32 200.85,67.32
  IN4 w0.102: v2(270.21,168.63) 270.26,168.63 270.57,168.33 270.57,150.36 270.85,150.08 270.85,149.72 270.12,149 270.12,145.08 270.04,145 270.04,141.36 269.83,141.16 269.83,139.43 270.19,139.08 270.19,138.38 269.86,138.05 269.86,130.86 270.19,130.53 270.19,129.16 271,128.35 271,126.24 270.07,125.31 270.07,119.56 271,118.63 271,113.03 270.51,112.53 270.51,102.31 269.88,101.69 269.88,100.98 269.22,100.32 269.22,99.16 266.28,96.21 266.28,94.54 264,92.27 264,90.12 263.28,89.4 263.28,77.09 263.08,76.89 263.08,70.74 263.43,70.38 263.43,65.58 263.03,65.18 263.03,58.63 263.81,57.84 263.81,48.53 264.05,48.29 264.05,47.41 263.66,47.02 263.66,45.9 263.01,45.25 263.01,43.13 262.36,42.48 262.36,33.18 251.85,22.67 245.23,22.67 244.72,22.16 233.78,22.16 231.97,23.96 222.12,23.96 220.8,25.29 216.26,25.29 212.83,28.71 211.44,28.71 207.63,32.52 207.63,35.78 201.66,41.74 201.66,43.66 200.48,44.84 198.79,44.84 192.29,51.35 192.29,53.39 191.96,53.72 191.96,55.3 191.51,55.74 191.51,59.35 192.76,60.59 193.97,60.59 196.11,62.73 196.11,62.98 197.85,64.73 197.95,64.73 198.03,64.81 198.33,64.81 200.85,67.32
  BOTTOM w0.089: UH1.AF10 202.5,69.42 v2(202.43,69.5)
  BOTTOM w0.102: v2(273.16,184.91) 273.1,184.98 273.1,185.29 272.65,185.74 JMINI2.47
PCH_CL_RST1#: length 286.9
  TOP w0.102: R707.1 272.14,187.69 278.42,181.42 278.42,175.72 276.56,173.87 v1(276.56,171.46) 276.56,169.28 275.46,168.17 272.26,168.17 271.52,167.44 v2(271.52,167.22)
  IN4 w0.089: 197.8,65.08 198.24,65.08 199.98,66.83 199.98,68.06 200.85,68.92 201.33,68.92 201.49,69.08 v2(202.02,69.08)
  IN4 w0.102: 197.8,65.08 197.69,65.08 195.51,62.9 194.93,62.9 193.52,61.49 193.01,61.49 191.14,59.63 191.14,51.99 198.79,44.34 200.48,44.34 201.2,43.62 201.2,41.51 207.25,35.46 207.25,32.4 211.31,28.33 211.95,28.33 212.45,27.83 212.45,27.06 213.24,26.28 213.24,26.26 215.97,23.53 231.91,23.53 233.63,21.81 244.87,21.81 245.38,22.31 252.28,22.31 263.31,33.34 263.31,42.84 263.77,43.3 263.77,44.3 264.19,44.73 264.19,46.99 264.77,47.56 264.77,49.69 264.88,49.81 265.15,49.81 265.73,50.39 265.73,55.14 265.14,55.74 265.14,56.42 264.35,57.21 264.35,57.81 263.38,58.78 263.38,65.02 263.86,65.51 263.86,70.74 263.43,71.17 263.43,76.3 263.63,76.5 263.63,89.13 264.55,90.04 264.55,92.23 266.63,94.31 266.63,96.07 269.59,99.03 269.59,100.18 270.26,100.86 270.26,101.56 270.86,102.16 270.86,112.2 271.36,112.69 271.36,118.78 270.57,119.57 270.57,124.93 271.36,125.72 271.36,128.49 270.54,129.31 270.54,130.68 270.21,131.01 270.21,137.9 270.9,138.58 270.9,146.89 271.46,147.45 271.46,150.48 271.01,150.93 271.01,166.71 v2(271.52,167.22)
  BOTTOM w0.089: v2(202.02,69.08) 202.02,68.74 UH1.AF7
PCH_CLK_BIASREF: length 5.3
  BOTTOM w0.089: UH1.AN44 211.76,82.12 211.76,82.28
  BOTTOM w0.102: 211.76,82.28 212.08,82.61 v1(212.08,85.36) 212.08,86.25 RH165.1
PCH_CRT_BLU: length 217.2
  TOP w0.102: v2(183.8,170.48) 183.87,170.55 183.87,171.51 U6.5
  IN1 w0.102: v2(221.04,76.83) 222.93,76.83 223.83,77.74 224.55,77.74 226.25,79.44 226.25,79.82 233.88,87.45 233.88,89.99 v2(233.87,90)
  IN4 w0.102: v2(233.87,90) 233.87,90.32 233.66,90.52 233.66,91.2 233.79,91.33 233.79,92.44 234.83,93.48 240.02,93.48 240.93,93.48 252.87,105.42 252.87,112.32 252.93,112.38 252.93,114.57 254.11,115.76 254.11,123.68 254.21,123.79 255.15,123.79 255.25,123.89 255.25,124.09 255.15,124.19 254.21,124.19 254.11,124.29 254.11,124.5 254.21,124.6 255.15,124.6 255.25,124.7 255.25,124.96 255.12,125.08 254.31,125.08 254.18,125.21 254.18,131.19 253.59,131.78 253.59,136.92 254.44,137.77 254.44,138.67 254.34,138.78 254.15,138.78 254.05,138.88 254.05,139.08 254.15,139.18 254.34,139.18 254.44,139.28 254.44,139.49 254.34,139.59 254.15,139.59 254.05,139.69 254.05,139.89 254.15,139.99 254.34,139.99 254.44,140.1 254.44,140.3 254.34,140.4 254.15,140.4 254.05,140.5 254.05,140.71 254.15,140.81 254.34,140.81 254.44,140.91 254.44,141.11 254.34,141.21 254.15,141.21 254.05,141.32 254.05,141.52 254.15,141.62 254.34,141.62 254.44,141.72 254.44,141.92 254.34,142.03 254.15,142.03 254.05,142.13 254.05,142.33 254.15,142.43 254.34,142.43 254.44,142.53 254.44,143.8 254.34,143.9 254.15,143.9 254.05,144 254.05,144.21 254.15,144.31 254.34,144.31 254.44,144.41 254.44,144.61 254.34,144.71 254.15,144.71 254.05,144.82 254.05,145.02 254.15,145.12 254.34,145.12 254.44,145.22 254.44,145.43 254.34,145.53 254.15,145.53 254.05,145.63 254.05,145.83 254.15,145.93 254.34,145.93 254.44,146.04 254.44,146.41 255.84,147.81 255.84,157.89 255.15,158.59 255.15,161.75 254.95,161.94 254.95,172.35 255.24,172.63 255.24,177.55 255.01,177.77 254.41,177.77 251.9,180.28 241.63,180.28 241.12,179.77 240.43,179.08 240.43,178.88 237.21,175.67 217.34,175.67 216.96,175.29 209.67,175.29 208.36,173.97 201.02,173.97 200.68,173.63 197.83,173.63 197.47,173.99 196.12,173.99 195.84,173.71 193.54,173.71 192.99,174.26 190.77,174.26 190.37,173.86 188.92,173.86 188.2,173.14 188.2,170.71 186.9,169.42 185.38,169.42 184.31,170.48 v2(183.8,170.48)
  BOTTOM w0.178: RH115.2 221.31,77.06 221.27,77.06 221.04,76.84 v2(221.04,76.83) 221.01,76.8 221.01,76.22 220.4,75.62 219.96,75.62 218.81,76.77 218.16,76.77 217.81,77.12 216.55,77.12 UH1.T45
PCH_CRT_DDC_CLK: length 215.2
  TOP w0.102: U6.10 185.86,171.07 v2(186.43,170.5)
  IN1 w0.102: v2(221.74,74.36) 224.33,74.36 228.51,78.54 228.51,78.87 236.65,87.01 236.65,90.93 236.46,91.12 235.21,91.12 v2(235.17,91.16)
  IN4 w0.102: v2(235.17,91.16) 236.27,92.26 239.51,92.26 241.43,92.26 254.09,104.92 254.09,111.72 256.47,114.1 256.47,130.62 255.08,132.01 255.08,132.02 254.83,132.28 254.83,135.76 255.82,136.75 255.82,145.92 257.06,147.16 257.06,158.76 256.61,159.21 256.61,162.04 256.37,162.28 256.37,162.33 256.36,162.34 256.36,162.78 256.74,163.16 256.74,163.98 256.83,164.07 256.83,166.83 256.47,167.18 256.47,175.26 256.74,175.53 256.74,178.02 253.06,181.7 252.04,181.7 251.21,181.7 251.08,181.57 249.83,181.57 249.8,181.5 241.36,181.5 240.86,181.5 236.26,176.9 216.8,176.9 216.42,176.52 208.82,176.52 207.49,175.2 200.19,175.2 199.91,174.92 198.28,174.92 197.93,175.26 194.11,175.26 193.88,175.5 190.73,175.5 190.51,175.72 188.51,175.72 186.9,174.1 186.9,172.19 186.43,171.72 v2(186.43,170.5)
  BOTTOM w0.089: 216.99,75.25 217.32,75.58 217.88,75.58 217.93,75.64 218.39,75.64 218.6,75.84 219.08,75.84 220.81,74.11
  BOTTOM w0.102: RH88.2 222.58,75.94 222.32,75.68 222.32,75.12 221.74,74.54 v2(221.74,74.36) 221.47,74.36 221.22,74.11 220.81,74.11
PCH_CRT_DDC_DAT: length 213.3
  TOP w0.102: U6.9 185.46,170.82 v2(185.83,170.45)
  IN1 w0.102: v2(221.31,74.77) 224.19,74.77 228.07,78.65 228.07,79.06 235.97,86.96 v2(235.97,90.69)
  IN4 w0.102: v2(185.83,170.45) 185.83,171.73 186.38,172.28 186.38,174.09 188.37,176.09 190.65,176.09 190.86,175.87 194.04,175.87 194.25,175.65 198.09,175.65 198.32,175.42 199.8,175.42 200.08,175.7 207.46,175.7 208.64,176.89 216.24,176.89 216.63,177.28 236.11,177.28 237.27,178.43 237.27,178.45 240.75,181.93 250.9,181.93 251.07,182.11 253.21,182.11 257.12,178.19 257.12,175.39 256.83,175.09 256.83,167.49 257.21,167.11 257.21,164.67 257.56,164.31 257.56,162.09 257.02,161.54 257.02,159.4 257.56,158.85 257.56,146.81 256.62,145.87 256.62,136.85 255.35,135.58 255.35,132.35 256.89,130.81 256.89,113.91 254.47,111.48 254.47,104.75 254.02,104.3 254.02,104.3 253.01,103.29 253.01,103.29 241.59,91.87 236.88,91.87 235.97,90.97 v2(235.97,90.69)
  BOTTOM w0.089: 221.28,74.62 221.05,74.4 220.87,74.4 219.22,76.05 218.55,76.05 218.33,75.83 217.69,75.83 UH1.M45
  BOTTOM w0.102: RH89.2 222.25,76.17 221.92,75.84 221.92,75.29 221.4,74.77 v2(221.31,74.77) 221.31,74.66 221.28,74.62
PCH_CRT_GRN: length 220.4
  TOP w0.102: v2(182.75,170.5) 182.66,170.59 U6.2
  IN1 w0.102: v2(220.44,76.81) 220.44,76.5 220.76,76.19 223.86,76.19 226.86,79.18 226.86,79.56 234.7,87.41 234.7,89.79 v2(234.49,90)
  IN4 w0.102: v2(182.75,170.5) 183.42,171.17 184.49,171.17 185.63,170.03 186.65,170.03 187.59,170.97 187.59,173.47 188.59,174.47 190.12,174.47 190.52,174.87 193.31,174.87 193.53,174.65 197.67,174.65 198.09,174.24 200.29,174.24 200.64,174.58 208.06,174.58 209.39,175.91 216.67,175.91 217.04,176.28 236.5,176.28 241.11,180.89 252.34,180.89 252.43,180.99 252.78,180.99 253.48,180.29 253.48,180.14 253.3,179.97 253.3,179.82 253.44,179.68 253.58,179.68 253.76,179.86 253.91,179.86 254.05,179.71 254.05,179.57 253.87,179.39 253.87,179.25 254.02,179.1 254.16,179.1 254.34,179.28 254.48,179.28 254.63,179.14 254.63,178.99 254.45,178.82 254.45,178.67 254.59,178.53 254.73,178.53 254.91,178.71 255.06,178.71 255.85,177.91 255.85,172.28 255.58,172 255.58,166.67 255.68,166.56 255.95,166.56 256.05,166.46 256.05,166.26 255.95,166.16 255.68,166.16 255.58,166.06 255.58,165.48 255.68,165.38 256,165.38 256.11,165.28 256.11,165.07 256,164.97 255.68,164.97 255.58,164.87 255.58,164.67 255.68,164.56 256,164.56 256.11,164.46 256.11,164.26 256,164.16 255.68,164.16 255.58,164.06 255.58,163.85 255.68,163.75 256,163.75 256.11,163.65 256.11,163.45 256,163.35 255.68,163.35 255.58,163.24 255.58,163.04 255.75,162.86 255.75,162.08 255.76,162.08 255.76,158.84 256.45,158.15 256.45,147.56 255.05,146.15 255.05,138.02 255.05,136.85 254.22,136.02 254.22,132.03 254.47,131.77 254.47,131.76 255.86,130.37 255.86,114.44 253.48,112.07 253.48,105.17 241.18,92.87 239.76,92.87 239.76,92.87 236.02,92.87 235.84,92.69 235.73,92.69 235.56,92.87 235.38,92.87 235.25,92.74 235.25,92.57 235.4,92.42 235.4,92.25 235.28,92.13 235.12,92.13 234.81,92.43 234.65,92.43 234.53,92.32 234.53,92.15 234.84,91.83 234.84,91.71 234.46,91.33 234.46,91.16 234.59,91.03 234.59,90.84 234.49,90.74 v2(234.49,90)
  BOTTOM w0.178: 215.86,77.02 216.22,77.38 217.92,77.38 218.23,77.08 218.96,77.08 219.45,76.58 220.21,76.58 v2(220.44,76.81) 220.44,77.72 RH116.2
PCH_CRT_HSYNC: length 265.7
  TOP w0.089: 221.84,76.61 221.6,76.61 221.37,76.38 220.87,76.38 220.29,75.79 219.96,75.79 RH94.1
  TOP w0.102: v2(268.92,69.99) 268.66,69.74 258.3,69.74 257.25,68.68 251.44,68.68 250.21,67.45 247.12,67.45 246.62,66.94 235.69,66.94 234.37,68.26 231.64,68.26 230.41,69.49 230.41,69.89 228.63,71.67 227.79,71.67 225.79,73.67 225.79,74.56 v1(224.58,75.76) 223.74,76.61 223.44,76.61 221.84,76.61 ; U6.6 184.26,171.15 184.3,171.11 184.3,170.25 183.96,169.9 183.96,168.16 v2(183.76,167.97)
  IN2 w0.127: v2(183.76,167.97) 184.69,168.9 185.66,168.9 187.36,170.6 189.47,170.6 190.18,169.89 190.18,167.92 191.46,166.64 196.32,166.64 200.45,170.76 205.6,170.76 207.36,172.53 214.68,172.53 214.93,172.78 221.95,172.78 222.55,172.19 230.15,172.19 232.69,169.65 254.43,169.65 255.38,168.69 261.27,168.69 262.4,169.82 268.29,169.82 268.65,170.18 273.17,170.18 273.91,169.44 v2(273.91,169.43)
  IN4 w0.102: v2(273.91,169.43) 273.91,168.71 274.82,167.79 274.82,165.43 272.82,163.42 272.82,151.71 273.24,151.29 273.24,148.45 275.13,146.56 275.13,146.06 275.85,145.33 275.85,141.27 274.04,139.46 274.04,137.87 274.66,137.25 274.66,112.37 273.98,111.69 273.98,107.44 273.85,107.3 273.85,97.33 272.63,96.12 270.72,96.12 269.98,95.39 269.98,92.53 269.01,91.56 269.01,86.79 268.58,86.37 268.58,75.87 269.08,75.37 269.08,72.22 269.25,72.06 269.25,70.84 268.92,70.51 v2(268.92,69.99)
PCH_CRT_RED: length 220.8
  TOP w0.102: v2(182.14,170.36) 182.26,170.48 U6.1 ; v2(235.34,89.98) v1(235.34,89.32)
  IN1 w0.102: v2(235.34,89.98) 235.31,89.95 235.31,87.16 227.47,79.31 227.47,78.9 223.99,75.43 221.51,75.43 221.47,75.39 220.77,75.39 219.69,76.47 v2(219.69,77.03)
  IN4 w0.102: v2(182.14,170.36) 182.14,170.85 183.58,172.29 183.58,173.01 187.32,176.75 190.6,176.75 191.14,177.29 195.07,177.29 195.66,176.69 196.52,176.69 196.9,176.31 198.53,176.31 198.69,176.47 201.96,176.47 201.99,176.44 207.12,176.44 208.17,177.49 215.84,177.49 216.26,177.91 235.85,177.91 241.4,183.46 248.99,183.46 249.89,184.36 251.83,184.36 257.73,178.46 257.73,175.13 257.46,174.87 257.46,167.77 257.84,167.4 257.84,165.17 258.17,164.83 258.17,161.76 257.67,161.25 257.67,159.63 258.17,159.12 258.17,153.27 258.45,152.99 258.45,146.16 257.23,144.93 257.23,136.53 256.31,135.62 256.31,132.73 257.5,131.55 257.5,113.58 255.08,111.15 255.08,104.5 254.63,104.05 254.63,104.05 253.26,102.68 253.26,102.68 241.84,91.26 241.34,91.26 237.35,91.26 236.3,90.22 235.58,90.22 v2(235.34,89.98)
  BOTTOM w0.178: UH1.V45 215.94,77.65 218.03,77.65 218.26,77.42 219.3,77.42 v2(219.69,77.03)
  BOTTOM w0.254: RH117.2 220,77.34 v2(219.69,77.03)
PCH_CRT_VSYNC: length 273.1
  TOP w0.089: 222.02,76.25 221.66,76.25 221.59,76.17 221.08,76.17 220.65,75.74 220.65,75.62 219.53,74.51 RH95.1
  TOP w0.102: v2(268.28,68.72) 268.28,68.77 267.76,69.29 258.36,69.29 257.4,68.33 251.59,68.33 250.36,67.09 247.27,67.09 246.76,66.59 235.55,66.59 234.23,67.91 231.49,67.91 230.05,69.35 230.05,69.75 228.49,71.31 227.64,71.31 225.41,73.54 225.41,74.43 223.59,76.25 222.02,76.25 ; v2(184.45,168.01) 184.31,168.15 184.31,169.74 184.66,170.08 U6.7
  IN2 w0.127: v2(184.45,168.01) 184.96,168.52 185.81,168.52 187.52,170.22 189.31,170.22 189.8,169.73 189.8,167.76 191.3,166.26 196.48,166.26 200.61,170.38 201.44,170.38 201.47,170.36 205.88,170.36 207.65,172.14 214.82,172.14 215.09,172.4 221.8,172.4 222.39,171.81 227.29,171.81 227.91,171.18 230.61,171.18 232.53,169.27 251.23,169.27 252.46,168.03 261.37,168.03 262.63,169.29 268.38,169.29 268.88,169.79 270.95,169.79 271.89,168.85 274.16,168.85 274.73,169.42 274.73,170.83 274.53,171.03 v2(274.02,171.03)
  IN4 w0.102: v2(268.28,68.72) 268.28,68.77 267.62,69.43 267.62,73.93 267.17,74.38 267.17,83.85 267.32,83.99 267.32,87.3 267.51,87.49 267.51,90.69 267.48,90.71 267.48,91.73 268.27,92.52 268.85,92.52 269.63,93.29 269.63,95.59 270.63,96.58 271.62,96.58 272.88,97.84 272.88,99.48 273.49,100.09 273.49,103.61 273.07,104.03 273.07,111.28 273.68,111.89 273.68,124.45 274.25,125.02 274.25,136.71 273.45,137.5 273.45,140.33 274.19,141.07 274.19,142.56 275.5,143.87 275.5,145.18 274.77,145.91 274.77,146.41 272.88,148.3 272.88,151.15 272.46,151.56 272.46,163.6 274.33,165.47 274.33,167.73 273.39,168.67 273.39,170.41 274.01,171.03 v2(274.02,171.03)
