# Allegro board LA-9411P R10-0403.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
TS_FDO: length 8.9
  TOP w0.102: RV111.2 RV84.1 230.58,115.06 v1(230.58,115.8) 230.58,121.13 v2(231.06,121.61)
  BOTTOM w0.102: UV1.AK32 230.68,122 v2(231.06,121.61)
UG_3V: length 6.5
  TOP w0.102: v4(148.89,7.7) 148.89,7.06 v1(148.83,7)
  IN1 w1.016: 147.18,7.44 146.48,7.44 143.62,4.58 142.6,4.58
  vias: v4(142.35,3.57) v4(142.35,2.93) v4(148.26,7.7)
UG_5V: length 12.4
  TOP w0.102: v4(152.38,7.7) v1(152.38,7)
  IN1 w1.016: 154.03,7.38 155.18,7.38 157.59,4.97 162.8,4.97 164.19,3.57
  vias: v4(153.02,7.7) v4(165.06,3.59) v4(165.08,2.93)
UG_+1.05VSP: length 4.9
  IN1 w1.016: 233.66,11.19 237.35,11.19
  BOTTOM w0.102: v4(238.36,11.57) v1(238.36,12.83)
  vias: v4(231.69,11.19) v4(232.33,11.19) v4(238.36,10.93)
UGATE1: length 41.5
  IN1 w1.016: 125.33,155.97 126.47,154.83 129.01,154.83 131.05,152.79 142.54,152.79 142.92,152.41 142.92,152.41 143.62,151.71 143.62,140.98 140.83,138.19 140.83,136.79 140.95,136.66 146.16,136.66
  vias: v1(140.9,135.93) v4(123.49,155.65) v4(124.13,155.65) v4(140.44,135.52) v4(140.44,134.76) v4(147.05,137.55) v4(147.05,136.79)
UGATE1_VGA: length 31.4
  IN2 w1.016: 290.05,146.91 290.05,151.52 289.16,152.41 ; 307.58,158.89 307.2,158.51 307.2,153.17 306.69,152.67 306.69,150.46 302.93,146.7 291.52,146.7
  vias: v1(288.88,152.84) v4(287.64,152.67) v4(288.27,152.67) v4(289.99,146.16) v4(290.62,146.16) v4(307.32,159.71) v4(307.96,159.91)
UGATE2: length 22.5
  TOP w0.102: v4(121.78,151.27) v1(121.78,150.63)
  IN1 w1.016: 132.95,137.17 128.38,137.17 127.62,136.41
  IN4 w1.016: 127.24,136.54 123.43,140.35 123.43,145.94 121.52,147.84 121.52,150.38
  vias: v4(121.39,151.9) v4(127.36,135.52) v4(127.36,134.76) v4(133.84,137.55) v4(133.84,136.79)
UGATE2_VGA: length 26.2
  TOP w0.102: v1(305.05,165.54) 305.54,165.05 v4(306.05,165.05)
  IN1 w1.016: 305.16,165.62 304.91,165.87 304.91,166.76 303.13,168.54 296.4,168.54 293.07,165.21 289.45,165.21 289.44,165.2
  IN4 w1.016: 290.41,159.03 290.43,159.05 290.43,162.42 288.46,164.39
  vias: v2(289.95,158.55) v2(290.66,158.56) v4(287.8,165.33) v4(288.44,165.33) v4(306.69,165.05)
UGATE3: length 21
  TOP w0.102: v1(160.63,137.77) 160.28,137.43 v4(159.75,137.43)
  IN1 w1.016: 158.48,137.05 154.8,137.05 153.91,136.16
  IN2 w1.016: 159.24,138.32 159.24,144.03 162.16,146.95 162.16,152.15
  vias: v4(153.4,135.39) v4(153.4,134.63) v4(159.67,136.69) v4(161.02,153.14) v4(161.65,153.16)
UIM_CLK: length 109.1
  TOP w0.102: v2(249.66,178.47) 249.85,178.29 JSIM1.3 249.85,176.49 250.27,176.07 250.27,174.81 C630.1 250.05,174.56 250.81,173.8 250.81,173.29 251.52,172.58 v1(251.57,172.58)
  IN1 w0.102: v2(322.51,208.2) 322.41,208.31 319.88,208.31 319.13,207.56 317.1,207.56 314.33,204.79 309.41,204.79 307.92,203.3 298.78,203.3 298.18,202.7 298.18,201.85 296.27,199.95 296.27,192.38 293.71,189.81 292.93,189.81 291.78,188.66 282.25,188.66 281.01,187.41 280.91,187.41 280.85,187.35 259.75,187.35 259.65,187.25 258.09,187.25 256.73,185.89 256.73,185.25 253.75,182.27 252.58,182.27 249.66,179.36 v2(249.66,178.47)
  BOTTOM w0.102: JMINI1.12 330.55,203.99 330.26,204.28 329.83,204.28 328.48,205.63 325.31,205.63 323.88,207.05 323.17,207.05 322.92,207.3 322.92,207.8 v2(322.51,208.2)
UIM_DATA: length 105.3
  TOP w0.102: v2(250.39,178.46) 250.55,178.3 JSIM1.7 250.55,176.3 250.62,176.22 250.62,175.38 C629.1 251.11,174.41 v1(251.63,173.89)
  IN1 w0.102: v2(250.39,178.46) 250.39,179.58 252.73,181.91 253.9,181.91 257.08,185.1 257.08,185.74 258.24,186.89 259.79,186.89 259.9,186.99 281.12,186.99 282.43,188.3 291.93,188.3 292.83,189.2 293.63,189.2 296.64,192.21 296.64,199.76 298.56,201.68 298.56,202.45 299.03,202.92 308.1,202.92 309.58,204.41 314.46,204.41 317.25,207.2 319.39,207.2 320.1,207.91 322.14,207.91 v2(322.51,207.54)
  BOTTOM w0.102: v2(322.51,207.54) 322.51,207.21 323.03,206.69 323.74,206.69 325.16,205.27 328.33,205.27 329.75,203.85 JMINI1.10
UIM_RESET: length 119.7
  TOP w0.102: v2(249.92,188.13) 249.9,188.13 248.45,186.68 248.45,177.01 JSIM1.2 ; v2(259.22,188.29) 259.99,187.52 v1(259.99,187.08) 259.99,185.85 258.22,184.08 C631.1
  IN1 w0.102: v2(323.32,207.53) 323.73,207.94 323.73,208.33 322.81,209.26 308.03,209.26 305.71,206.93 296.95,206.93 295.4,205.38 295.4,192.77 293.65,191.02 292.72,191.02 291.4,189.7 281.85,189.7 280.46,188.32 259.24,188.32 v2(259.22,188.29) 258.94,188.57 250.36,188.57 v2(249.92,188.13)
  BOTTOM w0.102: JMINI1.14 331.35,204.08 330.79,204.63 329.99,204.63 326.41,208.22 324.01,208.22 v2(323.32,207.53)
USB3RN1: length 270
  TOP w0.102: R27.1 344.03,219.4 344.61,219.4 v2(344.66,219.34)
  IN1 w0.089: 211.26,84.65 211.26,84.64 211.25,84.62 211.25,84.33 211.27,84.31 211.27,80.42 210.98,80.13 210.83,80.13 207.59,76.9 206.83,76.9 206.21,77.52 205.82,77.52 205.72,77.42 v2(205.43,77.42)
  IN1 w0.114: v2(344.66,219.34) 345.14,219.34 345.36,219.56 345.36,220.34 344.91,220.79 344.03,220.79 340.01,216.78 340.01,213.62 339.56,213.17 333.24,213.17 330.09,210.03 330.09,208.21 328.9,207.02 328.9,198.49 327.16,196.75 327.16,190.99 325.16,188.99 321.03,188.99 320.48,188.44 319.56,188.44 318.82,187.71 315.71,187.71 313.72,189.69 313.72,191.63 313.23,192.13 311.91,192.13 311.2,191.41 309.22,191.41 307.3,189.5 306.56,189.5 305.62,188.56 301.23,188.56 298.82,186.14 287.12,186.14 286.29,185.32 283.94,185.32 283.14,184.51 274.72,184.51 273.67,183.46 270.98,183.46 270.53,183.01 262.83,183.01 261.74,181.91 260.63,181.91 259.89,181.18 259.89,180.26 259.89,180.26 259.89,180.16 258.53,178.8 258.53,174.51 258.31,174.3 258.31,160.93 257.37,159.98 257.37,145.12 257.01,144.76 257.01,133.12 257.78,132.35 257.78,129.57 258.19,129.17 258.19,106.6 256.8,105.21 256.8,102.56 246.23,91.99 232.08,91.99 231.17,92.9 229.54,92.9 228.96,92.32 228.96,91.84 228.15,91.02 223.38,91.02 219,86.64 216.77,86.64 216.17,87.24 215.1,87.24 214.51,86.64 212.86,86.64 211.26,85.04 211.26,84.65
  BOTTOM w0.089: v2(205.43,77.42) 205.26,77.26 UH1.AR26
  BOTTOM w0.102: R27.1 344.15,219.52 344.48,219.52 v2(344.66,219.34)
USB3RN1_C: length 3
  BOTTOM w0.102: C1531.2 342.45,219.45 342.35,219.45 342.12,219.21 342.12,218.96 341.78,218.62 341.37,218.62 341.21,218.46 U92.23
USB3RN1_CO: length 9.3
  TOP w0.102: R27.2 342.45,219.45 342.31,219.45 342.02,219.16 v4(341.3,219.16) 339.8,219.16 339.78,219.14 339.23,219.14 339.21,219.16 337.92,219.16 337.23,218.47 334.6,218.47 R22.1
USB3RN1_D-: length 10.6
  BOTTOM w0.102: R1605.2 327.85,219.12 L95.2 327.85,219.56 328.17,219.88 328.17,220.23 v4(328.47,220.52) 328.68,220.74 328.68,221.73 328.55,221.87 D78.5 D78.6 328.55,224.13 328.05,224.62 328.05,224.65 327.08,225.62 327.08,226.01 326.41,226.68 326.41,227.28 326.18,227.51 JUSB1.5
USB3RN1_R: length 2.7
  BOTTOM w0.102: U92.8 336.06,218.46 335.91,218.62 335.26,218.62 335.11,218.47 334.6,218.47 R3712.2
USB3RN1_RP: length 9.4
  TOP w0.102: R22.2 332.91,218.44 332.78,218.44 v2(332.61,218.27)
  BOTTOM w0.102: R1605.1 327.85,218.04 L95.1 327.85,217.25 328.07,217.03 328.07,216.67 328.37,216.37 329.28,216.37 329.3,216.36 329.85,216.36 329.86,216.37 331.27,216.37 v4(331.77,216.87) 332.17,217.27 332.17,218.23 332.22,218.27 v2(332.61,218.27) 332.79,218.45 332.9,218.45 R22.2
USB3RN2: length 236.6
  TOP w0.102: v2(328.28,184.04) 328.5,184.26 328.5,184.49 328.14,184.85 R10.1
  IN1 w0.089: v2(204.05,78.8) 204.9,78.8 205.16,78.55 205.36,78.55 205.57,78.75 206.33,78.75 207.11,77.98 207.44,77.98 207.68,78.21 207.68,78.4 208.19,78.91 208.19,80.29 210.23,82.33 210.23,84.95 210.22,84.96 210.22,85.14 210.27,85.19 210.26,85.19 210.26,85.21 210.27,85.21
  IN1 w0.114: 210.27,85.21 212.51,87.45 214.02,87.45 215.17,88.59 215.9,88.59 217.04,87.45 218.79,87.45 222.49,91.16 222.49,91.25 223.14,91.9 225.73,91.9 226.58,92.75 227.13,92.75 228,93.62 231.5,93.62 232.41,92.72 245.91,92.72 256.01,102.82 256.01,109.5 257.44,110.93 257.44,128.61 257.04,129 257.04,132.05 256.13,132.97 256.13,145.01 256.64,145.52 256.64,160.3 257.56,161.22 257.56,166.28 257.22,166.62 257.22,174.23 257.81,174.81 257.81,179.29 258.72,180.2 258.72,181.15 261.36,183.79 267.99,183.79 268.51,184.31 273.37,184.31 274.29,185.24 282.79,185.24 283.66,186.11 285.71,186.11 286.49,186.88 296.58,186.88 300.19,190.49 305.83,190.49 307.01,191.67 308.41,191.67 310.53,193.79 312.62,193.79 314.46,191.95 314.46,190.89 316.23,189.12 319.23,189.12 320.42,190.31 321.04,190.31 321.28,190.06 v2(321.28,189.5)
  BOTTOM w0.089: v2(204.05,78.8) 203.99,78.75 UH1.AW26
  BOTTOM w0.102: R10.1 328.45,184.42 328.45,184.21 v2(328.28,184.04) 328.35,184.04 328.56,183.83 328.56,183.61 328.18,183.23 323.96,183.23 323.5,182.77 322.44,182.77 322.31,182.89 322.31,187.56 v4(321.79,188.08) 321.28,188.59 v2(321.28,189.5)
USB3RN2_C: length 2.5
  BOTTOM w0.102: U90.23 328.54,187.34 328.66,187.22 328.66,187.08 328.45,186.87 328.45,186.19 C1516.2
USB3RN2_CO: length 8.6
  TOP w0.102: R2.1 328.43,193.59 v4(328.43,192.27) 328.43,190.73 328.41,190.71 328.41,190.16 328.43,190.14 328.43,186.17 R10.2
USB3RN2_D-: length 12.6
  BOTTOM w0.102: R3696.2 349.14,219.64 L108.2 350.1,219.64 350.29,219.45 350.74,219.45 350.99,219.71 D88.10 D88.1 353.06,219.71 353.23,219.53 v4(353.75,219.53) 354.71,219.53 355.16,219.98 355.16,220.13 355.15,220.15 355.15,220.71 355.16,220.73 355.16,221.38 356.13,222.35 356.89,222.35 357.08,222.54 357.52,222.54 358.71,223.72 JUSB2.5
USB3RN2_R: length 2.5
  BOTTOM w0.102: R3680.2 328.42,193.59 328.42,193.05 328.68,192.79 328.68,192.58 328.54,192.45 U90.8
USB3RN2_RP: length 40
  TOP w0.102: v2(328.28,195.86) 328.45,195.69 328.45,195.33 R2.2
  IN1 w0.114: v2(346.68,219.6) 346.54,219.46 346.27,219.46 344.76,217.95 343.84,217.95 343.65,217.95 340.85,215.15 340.85,214.96 340.85,212.99 340.09,212.23 333.57,212.23 331.48,210.14 331.48,199.68 328.41,196.61 328.41,195.99 v2(328.28,195.86)
  BOTTOM w0.102: R2.2 328.44,195.33 328.44,195.69 v2(328.28,195.86) ; v2(346.68,219.6) 346.81,219.47 347.28,219.47 347.45,219.64 L108.1 348.06,219.64 R3696.1
USB3RN3: length 211.9
  IN1 w0.089: 209.17,86.26 209.16,86.25 209.15,86.25 209.14,86.25 209.02,86.13 209.02,85.93 205.49,82.39 205.49,81 206.12,80.37 206.12,80.14 205.84,79.86 v2(205.84,79.78)
  IN1 w0.114: v2(188.53,187.19) 188.53,188.69 188.79,188.95 190.34,188.95 190.6,188.69 190.6,187.98 190.83,187.74 192.38,187.74 193.06,187.06 197.96,187.06 201.12,183.91 202.97,183.91 209.44,177.44 216.32,177.44 217.26,178.38 239.42,178.38 240.31,177.49 244.36,177.49 246.97,174.89 252.38,174.89 255.58,171.7 255.58,164.86 255.93,164.51 255.93,163.06 255.58,162.71 255.58,161.1 255.41,160.93 255.41,146.37 254.81,145.77 254.81,142.95 254,142.14 254,136.04 254.81,135.23 254.81,131.21 255.77,130.24 255.77,127.62 256.1,127.29 256.1,122.1 256.09,122.08 256.09,111.57 254.76,110.24 254.76,103.47 247.93,96.63 247.09,96.63 244.39,93.94 233.01,93.94 232.09,94.86 217.77,94.86 209.17,86.26
  BOTTOM w0.089: UH1.AW31 205.61,79.55 v2(205.84,79.78)
  BOTTOM w0.102: v2(188.53,187.19) 188.91,187.57 188.91,187.85 188.75,188.02 JDOCK1.84
USB3RN5: length 248.9
  TOP w0.102: R34.1 340.47,186.19 340.79,185.88 340.79,185.38 v2(340.57,185.16)
  IN1 w0.089: v2(204.74,79.5) 205.59,79.5 205.68,79.4 206,79.4 206.27,79.67 206.27,79.73 206.94,80.4 206.94,81.24 207.47,81.76 207.69,81.76 208.12,82.19 209.35,82.19 209.58,82.43 209.58,85.97 210.2,86.58
  IN1 w0.114: 210.2,86.58 217.98,94.36 225.81,94.36 225.83,94.35 231.85,94.35 232.76,93.44 245.58,93.44 255.27,103.13 255.27,109.94 256.69,111.36 256.69,128.26 256.32,128.63 256.32,130.96 255.3,131.97 255.3,145.52 255.91,146.13 255.91,160.67 256.42,161.18 256.42,164.95 256.83,165.36 256.83,165.98 256.48,166.33 256.48,174.52 257.08,175.11 257.08,179.32 256.88,179.52 256.88,180.71 260.78,184.61 266.86,184.61 267.53,185.28 271.77,185.28 272.84,186.35 281.36,186.35 282.7,187.68 296.17,187.68 299.7,191.22 305.52,191.22 306.86,192.56 308.28,192.56 310.23,194.51 313.18,194.51 315.22,192.47 315.22,191.32 316.4,190.14 318.65,190.14 318.89,190.39 318.89,190.7 v2(318.68,190.92)
  IN2 w0.127: v2(318.68,190.92) 318.79,190.8 318.79,190.15 316.28,187.63 316.28,186.6 317.24,185.64 335.96,185.64 336.19,185.41 339.18,185.41 339.46,185.69 340.58,185.69 340.74,185.53 340.74,185.33 v2(340.57,185.16)
  BOTTOM w0.089: 204.68,78.86 204.68,79.44 v2(204.74,79.5)
  BOTTOM w0.102: v2(340.57,185.16) 340.79,185.38 340.79,185.88 340.48,186.19 R34.1
USB3RN5_C: length 2.1
  BOTTOM w0.102: C1555.2 340.73,187.48 340.73,187.89 340.84,188.01 340.84,188.34 340.72,188.46 U95.23
USB3RN5_CO: length 8.4
  TOP w0.102: R34.2 340.79,187.55 340.79,188.98 340.77,188.99 340.77,189.54 340.79,189.56 340.79,190.06 340.58,190.26 340.58,192.01 340.79,192.22 v4(340.79,193.41) 340.79,194.52 R32.1
USB3RN5_D-: length 11.1
  BOTTOM w0.102: R3722.2 349.9,196.91 L111.2 350.64,196.91 351.33,196.21 D91.10 D91.1 353.4,196.21 353.53,196.08 353.69,196.08 v4(354.11,196.5) 354.91,197.3 354.91,197.34 355.28,197.71 355.32,197.71 356.55,198.95 357.4,198.95 357.79,199.33 357.9,199.33 358.71,200.14 JUSB3.5
USB3RN5_R: length 2.4
  BOTTOM w0.102: R3770.2 340.7,194.61 340.7,194.08 340.86,193.92 340.86,193.54 340.72,193.41 U95.8
USB3RN5_RP: length 14
  TOP w0.102: v2(340.6,196.86) 340.69,196.77 340.69,196.2 R32.2
  IN2 w0.127: v2(340.6,196.86) 340.79,197.05 340.79,197.92 341.62,198.75 345.27,198.75 345.77,198.26 345.77,196.76 345.92,196.61 346.12,196.61 v2(346.29,196.77)
  BOTTOM w0.102: R32.2 340.69,196.2 340.69,196.77 340.6,196.86 v2(340.6,196.86) ; R3722.1 348.82,196.91 L111.1 348.03,196.91 347.71,196.58 346.48,196.58 v2(346.29,196.77)
USB3RN6: length 400.5
  TOP w0.102: R18.1 40.95,183.45 41.08,183.58 41.41,183.58 v2(41.78,183.21)
  IN1 w0.089: v2(206.14,78.12) 206.14,77.99 206.07,77.91 205.81,77.91 205.6,78.12 205.19,78.12 204.96,77.89 204.36,77.89 202.43,79.82 200.99,79.82 200.92,79.88 200.81,79.88 200.41,80.28 200.41,80.3
  IN1 w0.114: v2(41.78,183.21) 41.42,183.57 41.26,183.57 41.17,183.47 41.17,183.16 42.25,182.08 42.25,180.78 48.68,174.35 59.88,174.35 60.73,175.19 68.4,175.19 69.21,174.38 81.59,174.38 90.48,165.49 93.59,165.49 95.42,163.66 97.51,163.66 97.7,163.86 105.64,163.86 106.71,164.92 116.63,164.92 116.81,165.1 132.57,165.1 133.09,164.58 135.96,164.58 136.24,164.58 136.43,164.58 136.57,164.45 137.94,163.07 140.65,163.07 141.05,162.67 146.4,162.67 148.61,164.88 154.47,164.88 156.61,167.03 156.61,168.39 157.04,168.82 157.04,169.36 160.66,172.98 160.66,175.24 161.44,176.01 161.44,177.27 160.16,178.56 160.16,179.17 159.98,179.35 159.98,180.11 160.37,180.5 160.37,186.72 161.22,187.57 164.82,187.57 165.45,188.19 173.88,188.19 174.99,187.07 178.82,187.07 179.54,186.36 180.55,186.36 182.09,184.82 187.98,184.82 190.69,182.12 193,182.12 194.67,180.44 199.47,180.44 200.13,179.78 200.13,178.24 201.13,177.25 201.13,175.65 201.77,175.01 217.52,175.01 218.49,175.98 229.09,175.98 230.07,175.01 243.41,175.01 245.7,172.72 247.87,172.72 250.95,172.72 252.97,170.71 252.97,170.32 253.35,169.94 253.35,165.72 253.02,165.39 253.02,148.53 251.35,146.86 251.35,142.51 251.81,142.06 251.81,134.68 252.47,134.02 252.47,114.64 251.7,113.86 251.7,111.94 252.08,111.56 252.08,110.23 251.96,110.12 251.96,105.71 251.74,105.49 251.74,103.63 247.11,99 246.32,99 243.43,96.11 234.05,96.11 233.13,97.03 216.76,97.03 210.44,90.71 209.23,90.71 204.61,86.08 203.72,86.08 203.44,86.36 202.15,86.36 201.49,85.7 200.64,85.7 199.93,84.99 199.93,80.78 200.27,80.44 200.41,80.3
  BOTTOM w0.089: UH1.AR29 206.14,77.78 v2(206.14,78.12)
  BOTTOM w0.102: v2(41.78,183.21) 41.78,183.34 41.73,183.39 41.6,183.39 41.47,183.52 40.84,183.52 40.78,183.45 40.78,183.2 R18.1
USB3RN6_C: length 3.1
  BOTTOM w0.102: C1547.2 40.04,183.12 39.72,183.44 38.93,183.44 38.47,183.9 38.29,183.9 38.18,183.79 U94.23
USB3RN6_CO: length 9.7
  TOP w0.102: R18.2 39.64,183.42 38.48,183.42 38.14,183.09 v4(37.47,183.09) 35.76,183.09 35.74,183.07 35.19,183.07 35.18,183.09 33.33,183.09 32.9,183.52 31.55,183.52 R14.1
USB3RN6_D-: length 14.4
  BOTTOM w0.102: R1609.2 24.72,183.36 L98.2 24.03,183.73 23.49,183.73 23.27,183.95 22.83,183.95 22.68,183.8 D79.5 D79.6 20.01,183.8 19.92,183.88 19.44,183.88 19.42,183.87 18.87,183.87 18.86,183.88 18.19,183.88 v4(17.11,182.81) 15.2,180.89 14.9,180.89 14,179.99 13.39,179.99 13.29,179.89 JUSB4.5
USB3RN6_R: length 2.8
  BOTTOM w0.102: R3753.2 31.52,183.49 32.08,183.49 32.5,183.91 32.8,183.91 32.92,183.79 U94.8
USB3RN6_RP: length 6.1
  TOP w0.102: v2(29.29,183.26) 29.45,183.42 29.73,183.42 R14.2
  BOTTOM w0.102: R1609.1 25.8,183.36 L98.1 26.58,183.36 26.9,183.68 v4(27.29,183.68) 27.78,183.68 28.01,183.44 28.21,183.44 28.23,183.43 28.95,183.43 28.96,183.44 29.11,183.44 v2(29.29,183.26) 29.49,183.45 29.7,183.45 R14.2
USB3RP1: length 270
  TOP w0.102: v2(344.66,219.98) 344.66,219.92 344.35,219.61 343.61,219.61 343.51,219.71 343.51,219.89 R28.1
  IN1 w0.089: 211.48,84.43 211.48,80.34 211.04,79.91 210.89,79.91 207.67,76.7 206.75,76.7 206.12,77.32 205.9,77.32 205.84,77.26 v2(205.84,77.01)
  IN1 w0.114: v2(344.66,219.98) 344.66,219.93 345.02,219.57 345.05,219.57 345.13,219.65 345.13,220.25 344.82,220.56 344.12,220.56 340.24,216.68 340.24,213.52 339.66,212.94 333.33,212.94 330.32,209.93 330.32,208.11 329.13,206.92 329.13,198.4 327.39,196.66 327.39,190.89 325.26,188.76 321.12,188.76 320.57,188.21 319.65,188.21 318.92,187.48 315.62,187.48 313.5,189.6 313.5,191.54 313.13,191.9 312,191.9 311.29,191.19 309.31,191.19 307.53,189.4 307.37,189.24 306.63,189.24 305.72,188.33 301.33,188.33 298.92,185.92 287.21,185.92 286.39,185.09 284.04,185.09 283.23,184.28 274.82,184.28 273.77,183.24 271.08,183.24 270.62,182.78 262.93,182.78 261.84,181.69 260.72,181.69 260.12,181.08 260.12,180.35 260.12,180.07 258.76,178.71 258.76,174.42 258.54,174.2 258.54,160.83 257.6,159.89 257.6,145.03 257.23,144.67 257.23,133.22 258.01,132.44 258.01,129.67 258.42,129.26 258.42,106.5 257.03,105.12 257.03,102.46 246.32,91.76 231.99,91.76 231.07,92.67 229.64,92.67 229.19,92.23 229.19,91.74 228.24,90.79 223.48,90.79 219.1,86.41 216.67,86.41 216.07,87.01 215.2,87.01 214.6,86.41 212.96,86.41 211.49,84.94 211.49,84.54 211.48,84.53 211.48,84.43
  BOTTOM w0.089: UH1.AP26 205.68,76.85 v2(205.84,77.01)
  BOTTOM w0.102: v2(344.66,219.98) 344.41,219.73 344.09,219.73 R28.1
USB3RP1_C: length 3
  BOTTOM w0.102: U92.22 341.21,218.96 341.34,218.83 341.7,218.83 341.91,219.05 341.91,219.3 342.27,219.66 342.36,219.66 C1532.2
USB3RP1_CO: length 9.4
  TOP w0.102: R26.1 334.6,218.68 337.15,218.68 337.83,219.37 v4(339.5,219.37) 341,219.37 341.02,219.38 341.57,219.38 341.59,219.37 341.93,219.37 342.22,219.66 342.36,219.66 R28.2
USB3RP1_D+: length 10.6
  BOTTOM w0.102: R1604.2 328.7,219.12 L95.3 328.7,219.58 328.38,219.9 328.38,220.11 328.9,220.63 328.9,221.81 329.05,221.96 D78.4 D78.7 329.05,223.95 v4(328.47,224.53) 327.3,225.7 327.3,226.1 326.62,226.77 326.62,227.32 326.81,227.51 JUSB1.6
USB3RP1_R: length 2.7
  BOTTOM w0.102: R3713.2 334.6,218.68 335.03,218.68 335.17,218.83 335.89,218.83 336.02,218.96 U92.9
USB3RP1_RP: length 9.5
  TOP w0.102: v2(332.61,218.86) 332.82,218.66 332.89,218.66 333.28,219.05 R26.2
  BOTTOM w0.102: R26.2 333.28,219.04 332.9,218.66 332.82,218.66 332.62,218.86 v2(332.61,218.86) 332.24,218.49 332.13,218.49 331.96,218.31 331.96,217.36 331.82,217.22 331.8,217.22 331.41,216.84 331.41,216.81 331.18,216.58 v4(329.57,216.58) 328.46,216.58 328.29,216.75 328.29,216.94 328.39,217.04 328.57,217.04 328.7,217.18 L95.4 328.7,218.04 R1604.1
USB3RP2: length 236.7
  TOP w0.102: v2(328.91,184.04) 328.71,184.24 328.71,184.52 R11.1
  IN1 w0.089: v2(204.53,78.37) 204.51,78.39 204.51,78.52 204.59,78.6 204.82,78.6 205.07,78.34 205.45,78.34 205.65,78.55 206.25,78.55 207.02,77.77 207.53,77.77 207.88,78.13 207.88,78.32 208.39,78.83 208.39,80.2 210.43,82.25 210.43,85.05 210.64,85.26
  IN1 w0.114: 210.64,85.26 212.61,87.22 214.12,87.22 215.26,88.37 215.8,88.37 216.94,87.22 218.88,87.22 222.72,91.07 222.72,91.15 223.24,91.67 225.82,91.67 226.67,92.52 227.22,92.52 228.1,93.4 231.41,93.4 232.32,92.49 246,92.49 256.24,102.73 256.24,109.41 257.67,110.83 257.67,128.7 257.27,129.1 257.27,132.15 256.36,133.06 256.36,144.91 256.87,145.42 256.87,160.2 257.79,161.13 257.79,166.37 257.45,166.71 257.45,174.13 258.03,174.72 258.03,179.2 258.94,180.11 258.94,181.05 261.46,183.57 268.09,183.57 268.61,184.09 273.46,184.09 274.39,185.01 282.89,185.01 283.76,185.88 285.81,185.88 286.58,186.65 296.67,186.65 300.29,190.26 305.93,190.26 307.1,191.44 308.5,191.44 310.62,193.56 312.53,193.56 314.23,191.86 314.23,190.79 316.14,188.89 319.32,188.89 320.52,190.08 320.94,190.08 321.06,189.97 321.06,189.85 v2(320.7,189.5)
  BOTTOM w0.089: UH1.AV26 204.42,78.25 204.53,78.36 v2(204.53,78.37)
  BOTTOM w0.102: v2(320.7,189.5) 321.07,189.12 321.07,188.5 321.37,188.2 321.37,188.15 321.93,187.59 321.98,187.59 322.1,187.47 322.1,182.81 322.35,182.55 323.58,182.55 324.05,183.02 328.27,183.02 328.77,183.53 328.77,183.9 v2(328.91,184.04) 328.66,184.29 328.66,184.47 R11.1
USB3RP2_C: length 2.5
  BOTTOM w0.102: C1517.2 328.66,186.14 328.66,186.72 328.9,186.96 328.9,187.21 329.04,187.35 U90.22
USB3RP2_CO: length 8.6
  TOP w0.102: R11.2 328.64,186.17 v4(328.64,190.44) 328.64,191.97 328.66,191.99 328.66,192.54 328.64,192.56 328.64,193.59 R4.1
USB3RP2_D+: length 12.6
  BOTTOM w0.102: R3691.2 349.14,218.79 L108.3 349.82,218.79 350.27,219.24 350.9,219.24 350.94,219.21 D88.9 D88.2 353.13,219.21 353.25,219.32 353.46,219.32 353.48,219.3 354.03,219.3 354.05,219.32 354.8,219.32 355.37,219.9 v4(355.37,220.43) 355.37,221.29 356.22,222.14 356.98,222.14 357.17,222.33 357.61,222.33 357.91,222.63 358.14,222.63 358.71,222.06 JUSB2.6
USB3RP2_R: length 2.5
  BOTTOM w0.102: R3681.2 328.63,193.59 328.63,193.13 328.89,192.88 328.89,192.57 329.04,192.41 U90.9
USB3RP2_RP: length 40
  TOP w0.102: v2(328.91,195.86) 328.87,195.86 328.66,195.64 328.66,195.29 R4.2
  IN1 w0.114: v2(346.68,218.96) 346.68,219.04 346.49,219.23 346.36,219.23 344.85,217.72 343.75,217.72 341.08,215.06 341.08,212.9 340.18,212 333.66,212 331.71,210.05 331.71,199.59 328.64,196.52 328.64,196.13 v2(328.91,195.86)
  BOTTOM w0.102: R4.2 328.66,195.29 328.66,195.61 v2(328.91,195.86) ; v2(346.68,218.96) 346.93,219.21 347.07,219.21 347.5,218.79 L108.4 348.06,218.79 R3691.1
USB3RP3: length 211.9
  IN1 w0.089: v2(205.39,80.24) 205.51,80.12 205.68,80.12 205.72,80.16 205.85,80.16 205.91,80.22 205.91,80.29 205.28,80.92 205.28,82.48 208.82,86.01 208.82,86.29 208.94,86.41 208.99,86.41 209.01,86.42
  IN1 w0.114: v2(189.37,187.07) 189.28,186.98 189.04,186.98 188.95,187.07 188.95,187.35 188.76,187.54 188.76,188.59 188.88,188.72 190.24,188.72 190.37,188.59 190.37,187.88 190.74,187.51 192.29,187.51 192.97,186.84 197.87,186.84 201.02,183.68 202.88,183.68 209.34,177.22 216.42,177.22 217.36,178.16 239.32,178.16 240.21,177.27 244.27,177.27 246.74,174.8 246.87,174.66 247.06,174.66 252.29,174.66 255.35,171.6 255.35,164.76 255.7,164.41 255.7,163.16 255.35,162.81 255.35,161.19 255.18,161.02 255.18,146.47 254.58,145.87 254.58,143.04 253.77,142.23 253.77,135.94 254.58,135.13 254.58,131.11 255.55,130.14 255.55,127.53 255.88,127.2 255.88,122.19 255.86,122.18 255.86,111.66 254.53,110.33 254.53,103.56 247.83,96.86 247,96.86 244.3,94.16 233.1,94.16 232.18,95.08 217.67,95.08 209.01,86.42
  BOTTOM w0.089: UH1.AY31 205.13,79.97 v2(205.39,80.24)
  BOTTOM w0.102: JDOCK1.86 189.25,187.96 189.12,187.84 189.12,187.31 v2(189.37,187.07)
USB3RP5: length 248.9
  TOP w0.102: R35.1 341.24,186.19 341,185.95 341,185.31 v2(341.16,185.16)
  IN1 w0.089: 210.36,86.42 210.35,86.41 210.33,86.41 210.29,86.36 210.27,86.36 209.79,85.88 209.79,82.35 209.43,81.99 208.21,81.99 207.78,81.56 207.55,81.56 207.15,81.15 207.15,80.31 206.47,79.64 206.47,79.58 206.09,79.2 205.6,79.2 205.51,79.29 205.28,79.29 205.2,79.21 v2(205.2,79.04)
  IN1 w0.114: 210.36,86.42 211.46,87.52 218.07,94.13 225.72,94.13 225.73,94.12 231.76,94.12 232.67,93.21 245.67,93.21 255.49,103.03 255.49,109.84 256.92,111.26 256.92,128.36 256.55,128.73 256.55,131.05 255.53,132.07 255.53,145.42 256.14,146.03 256.14,160.57 256.65,161.08 256.65,164.85 257.06,165.27 257.06,166.07 256.71,166.42 256.71,174.42 257.31,175.02 257.31,179.41 257.11,179.62 257.11,180.61 260.87,184.38 266.96,184.38 267.63,185.05 271.86,185.05 272.93,186.12 281.46,186.12 282.79,187.45 296.26,187.45 299.8,190.99 305.61,190.99 306.96,192.33 308.37,192.33 310.32,194.28 313.08,194.28 314.99,192.37 314.99,191.22 316.3,189.92 318.74,189.92 319.12,190.3 319.12,190.76 v2(319.28,190.92)
  IN2 w0.127: v2(341.16,185.16) 340.99,185.33 340.99,185.64 340.69,185.94 339.35,185.94 339.07,185.66 336.29,185.66 336.06,185.89 317.34,185.89 316.53,186.7 316.53,187.53 319.05,190.04 319.05,190.69 v2(319.28,190.92)
  BOTTOM w0.089: UH1.AV29 205.11,78.94 v2(205.2,79.04)
  BOTTOM w0.102: v2(341.16,185.16) 341,185.31 341,185.95 341.24,186.19 R35.1
USB3RP5_C: length 2.1
  BOTTOM w0.102: C1556.2 340.94,187.54 340.94,187.81 341.05,187.92 341.05,188.28 341.22,188.45 U95.22
USB3RP5_CO: length 8.3
  TOP w0.102: R33.1 341,194.59 341,193.7 341.02,193.68 341.02,193.13 341,193.12 341,192.13 340.8,191.92 340.8,190.35 341,190.14 v4(341,189.27) 341,187.48 R35.2
USB3RP5_D+: length 11.1
  BOTTOM w0.102: R3721.2 349.9,196.06 L111.3 350.69,196.06 350.86,196.23 351.02,196.23 351.53,195.71 D91.9 D91.2 353.34,195.71 353.5,195.87 353.78,195.87 354.05,196.14 354.08,196.14 354.47,196.53 354.47,196.56 v4(355.27,197.36) 356.64,198.73 357.49,198.73 357.88,199.12 358.17,199.12 358.71,198.59 JUSB3.6
USB3RP5_R: length 2.4
  BOTTOM w0.102: R3763.2 341.33,194.96 340.91,194.54 340.91,194.17 341.07,194.01 341.07,193.52 341.22,193.37 U95.9
USB3RP5_RP: length 14.1
  TOP w0.102: v2(341.18,196.86) 340.9,196.57 340.9,196.11 341.13,195.87 R33.2
  IN2 w0.127: v2(341.18,196.86) 341.04,197 341.04,197.81 341.73,198.5 345.17,198.5 345.51,198.15 345.51,196.66 345.82,196.35 346.12,196.35 v2(346.29,196.19)
  BOTTOM w0.102: R3721.1 348.82,196.06 L111.4 348.03,196.06 347.72,196.37 346.47,196.37 v2(346.29,196.19) ; R33.2 341.13,195.87 340.9,196.11 340.9,196.57 v2(341.18,196.86)
USB3RP6: length 400
  TOP w0.102: R19.1 41.2,183.79 41.77,183.79 v2(41.78,183.79)
  IN1 w0.089: v2(206.57,77.69) 206.55,77.71 205.72,77.71 205.52,77.91 205.27,77.91 205.05,77.69 204.28,77.69 202.35,79.62 200.9,79.62 200.84,79.68 200.73,79.68 200.33,80.09 200.32,80.09 200.28,80.13 200.26,80.13 200.25,80.14
  IN1 w0.114: v2(41.78,183.79) 41.17,183.79 40.94,183.57 40.94,183.06 42.02,181.98 42.02,180.68 48.59,174.12 59.98,174.12 60.82,174.96 68.31,174.96 69.12,174.15 81.5,174.15 90.39,165.26 93.5,165.26 95.33,163.44 97.61,163.44 97.8,163.63 105.74,163.63 106.8,164.69 116.73,164.69 116.91,164.87 132.48,164.87 132.86,164.48 133,164.35 136.34,164.35 137.85,162.84 140.56,162.84 140.95,162.45 146.49,162.45 148.7,164.66 154.56,164.66 156.84,166.94 156.84,168.29 157.27,168.73 157.27,169.27 160.89,172.88 160.89,175.15 161.67,175.92 161.67,177.37 160.38,178.65 160.38,179.27 160.21,179.44 160.21,180.01 160.6,180.4 160.6,186.63 161.31,187.34 164.92,187.34 165.54,187.96 173.78,187.96 174.9,186.84 178.73,186.84 179.44,186.13 180.46,186.13 181.99,184.59 187.89,184.59 190.59,181.89 192.9,181.89 194.58,180.21 199.38,180.21 199.91,179.69 199.91,178.15 200.9,177.16 200.9,175.56 201.68,174.78 217.61,174.78 218.59,175.76 229,175.76 229.97,174.78 243.31,174.78 245.6,172.49 247.96,172.49 250.86,172.49 252.74,170.61 252.74,170.22 253.12,169.84 253.12,165.81 252.79,165.48 252.79,148.62 251.13,146.96 251.13,142.42 251.58,141.96 251.58,134.59 252.24,133.93 252.24,114.73 251.47,113.96 251.47,111.84 251.85,111.46 251.85,110.32 251.74,110.21 251.74,105.81 251.51,105.59 251.51,103.73 247.01,99.22 246.23,99.22 243.34,96.34 234.15,96.34 233.22,97.26 216.66,97.26 210.35,90.94 209.14,90.94 204.51,86.31 203.81,86.31 203.53,86.59 202.05,86.59 201.39,85.93 200.55,85.93 199.7,85.08 199.7,80.69 200.25,80.14
  BOTTOM w0.089: v2(206.57,77.69) 206.57,77.68 206.37,77.48 UH1.AP29
  BOTTOM w0.102: v2(41.78,183.79) 41.71,183.73 41.26,183.73 R19.1
USB3RP6_C: length 3.1
  BOTTOM w0.102: U94.22 38.08,184.29 38.26,184.12 38.6,184.12 v4(38.88,183.84) 39.06,183.65 39.66,183.65 C1543.2
USB3RP6_CO: length 9.6
  TOP w0.102: R19.2 39.64,183.63 38.39,183.63 38.06,183.3 37.76,183.3 37.75,183.32 37.2,183.32 37.18,183.3 v4(35.47,183.3) 33.42,183.3 32.99,183.73 31.35,183.73 R16.1
USB3RP6_D+: length 14.3
  BOTTOM w0.102: JUSB4.6 13.29,180.37 13.46,180.2 13.92,180.2 14.82,181.1 15.11,181.1 16.72,182.71 16.72,182.75 17.18,183.21 17.22,183.21 18.1,184.09 v4(19.15,184.09) 19.92,184.09 20.13,184.3 D79.7 D79.4 22.58,184.3 22.72,184.16 23.36,184.16 23.58,183.95 24.15,183.95 L98.3 24.72,184.21 R1610.2
USB3RP6_R: length 2.8
  BOTTOM w0.102: U94.9 32.83,184.29 32.66,184.12 32.36,184.12 v4(32.14,183.9) 31.95,183.71 31.38,183.71 R3756.2
USB3RP6_RP: length 6.1
  TOP w0.102: v2(29.29,183.84) 29.51,183.63 29.73,183.63 R16.2
  BOTTOM w0.102: R1610.1 25.8,184.21 L98.4 26.58,184.21 26.9,183.89 27,183.89 27.01,183.9 27.56,183.9 27.58,183.89 27.87,183.89 28.1,183.65 v4(28.61,183.65) 29.1,183.65 v2(29.29,183.84) 29.47,183.67 29.76,183.67 R16.2
USB3T_N1: length 8.7
  TOP w0.102: v2(332.35,220.34) 332.52,220.52 332.86,220.52 C1560.1
  BOTTOM w0.102: C1560.1 332.85,220.54 332.54,220.54 v2(332.35,220.34) 331.88,220.34 331.64,220.11 331.64,218.86 331.35,218.57 331.35,217.67 331.16,217.48 330.34,217.48 330.09,217.73 330.09,218.29 329.89,218.5 L96.1 329.89,219.06 R1606.1
USB3T_N2: length 41.2
  TOP w0.102: C2.1 330.28,195.14 330.28,195.68 v2(329.98,195.99)
  IN1 w0.114: v2(329.98,195.99) 329.98,197.16 332.24,199.42 332.24,209.78 333.77,211.32 343.1,211.32 343.23,211.44 343.23,212.14 343.1,212.27 342.18,212.27 341.92,212.53 341.92,213.33 342.18,213.59 343.78,213.59 343.92,213.73 343.92,215.35 346.2,217.63 346.76,217.63 v2(346.82,217.69)
  BOTTOM w0.102: R3698.1 348.06,217.73 L109.1 347.5,217.73 347.2,217.44 347.07,217.44 v2(346.82,217.69) ; v2(329.98,195.99) 330.28,195.68 330.28,195.14 C2.1
USB3T_N5: length 11.5
  TOP w0.102: v2(342.86,196.83) 343,196.69 343,196.23 C1563.1
  IN2 w0.127: v2(346.3,195.04) 346.13,194.88 345.84,194.88 344.84,195.88 344.84,197.31 344.39,197.75 343.37,197.75 343.02,197.41 343.02,197 v2(342.86,196.83)
  BOTTOM w0.102: C1563.1 343,196.23 343,196.69 v2(342.86,196.83) ; R3728.1 348.82,194.87 L112.1 348.03,194.87 347.71,194.55 347.53,194.55 347.23,194.86 346.49,194.86 v2(346.3,195.04)
USB3T_N6: length 5.9
  TOP w0.102: v2(29.35,185.55) 29.5,185.7 29.74,185.7 C420.2
  BOTTOM w0.102: C420.2 29.7,185.73 29.53,185.73 v2(29.35,185.55) 29.18,185.72 v4(28.61,185.72) 27.62,185.72 27.6,185.7 27.05,185.7 27.03,185.72 26.96,185.72 26.63,185.39 L97.1 26.02,185.31 R1612.1
USB3T_P1: length 8.7
  TOP w0.102: C1561.1 332.9,220.74 332.54,220.74 v2(332.35,220.93)
  BOTTOM w0.102: C1561.1 332.9,220.74 332.53,220.74 v2(332.35,220.93) 331.97,220.56 331.79,220.56 331.43,220.2 331.43,218.95 331.14,218.65 331.14,217.76 331.07,217.69 330.43,217.69 330.3,217.82 330.3,218.07 330.39,218.15 330.56,218.15 330.73,218.32 L96.4 330.73,219.06 R1603.1
USB3T_P2: length 41.3
  TOP w0.102: C3.1 330.5,195.48 330.5,195.87 v2(330.61,195.99)
  IN1 w0.114: v2(330.61,195.99) 330.56,195.99 330.21,196.34 330.21,197.06 332.47,199.32 332.47,209.69 333.87,211.09 343.19,211.09 343.45,211.35 343.45,212.24 343.19,212.5 342.27,212.5 342.15,212.62 342.15,213.23 342.27,213.36 343.87,213.36 344.15,213.64 344.15,215.25 346.3,217.4 346.53,217.4 346.82,217.11 v2(346.82,217.06)
  BOTTOM w0.102: v2(330.61,195.99) 330.5,195.87 330.5,195.48 C3.1 ; v2(346.82,217.06) 346.99,217.23 347.16,217.23 347.5,216.88 L109.4 348.06,216.88 R3697.1
USB3T_P5: length 11.5
  TOP w0.102: v2(343.44,196.83) 343.21,196.6 343.21,196.11 343.45,195.87 C1564.1
  IN2 w0.127: v2(343.44,196.83) 343.4,196.83 343.28,196.95 343.28,197.3 343.47,197.5 344.29,197.5 344.58,197.2 344.58,195.77 345.73,194.62 346.13,194.62 v2(346.3,194.46)
  BOTTOM w0.102: R3727.1 348.82,194.02 L112.4 348.03,194.02 347.71,194.34 347.45,194.34 347.15,194.65 346.49,194.65 v2(346.3,194.46) ; v2(343.44,196.83) 343.21,196.6 343.21,196.11 343.45,195.87 C1564.1
USB3T_P6: length 6
  TOP w0.102: v2(29.35,186.13) 29.57,185.91 29.72,185.91 C421.2
  BOTTOM w0.102: R1613.1 26.02,186.32 L97.4 26.65,186.24 26.96,185.93 v4(27.33,185.93) 28.25,185.93 28.29,185.97 28.9,185.97 28.94,185.93 29.14,185.93 v2(29.35,186.13) 29.53,185.94 29.76,185.94 C421.2
USB3TN1: length 301.8
  TOP w0.102: v2(344.66,221.37) 344.56,221.48 344.08,221.48 R31.1
  IN4 w0.114: v2(206.35,94.95) 206.7,95.3 211.93,95.3 213.71,97.08 222.99,97.08 225.45,94.62 225.45,93.3 225.64,93.11 225.64,89.74 229.42,85.95 233.22,85.95 233.88,86.61 238.67,86.61 239.22,87.16 241.01,87.16 241.54,86.63 243.44,86.63 251.09,94.28 251.09,94.78 253.04,96.74 253.04,97.29 257.74,101.99 258.18,101.99 259.53,103.34 259.53,105.76 260.63,106.86 260.63,107.05 260.63,111.04 261.44,111.85 261.44,113.58 261.25,113.77 261.25,120.24 261.59,120.59 261.59,136.32 261.72,136.44 261.72,138.29 261.46,138.54 261.46,143.33 262.75,144.61 262.75,149.32 262.23,149.84 262.23,159.77 262.31,159.85 262.31,160.81 261.93,161.19 261.93,166.36 261.54,166.75 261.54,174.61 261.68,174.75 261.68,177.46 262.76,178.54 262.76,179.94 264.05,181.24 265.4,181.24 266.75,182.59 270.67,182.59 271.17,183.08 273.71,183.08 275.47,184.85 276.38,184.85 277.31,185.78 292.83,185.78 297.31,181.29 317.09,181.29 317.38,181.58 319.4,181.58 320.23,182.41 320.71,182.41 322.72,184.42 322.72,187.55 324.76,189.59 324.76,193.45 323.54,194.67 322.45,195.76 322.45,196.44 321.29,197.59 321.29,204.59 324.15,207.45 324.15,215.02 331.83,222.69 341.12,222.69 342.19,221.63 344.41,221.63 v2(344.66,221.37)
  BOTTOM w0.089: 200.48,80.37 200.58,80.37 201.26,79.69 201.26,79.39 201.41,79.25 201.49,79.25 UH1.BE24
  BOTTOM w0.102: v2(206.35,94.95) 206.45,94.95 206.57,95.07 206.57,95.26 206.48,95.36 206.13,95.36 205.93,95.55 204.26,95.55 204.22,95.51 203.05,95.51 198.46,90.92 198.46,89.75 195.66,86.96 195.66,84.24 198.51,81.39 199.4,81.39 200.42,80.37 200.48,80.37 ; v2(344.66,221.37) 344.53,221.5 344.1,221.5 R31.1
USB3TN1_C: length 3.4
  BOTTOM w0.102: U92.20 341.21,219.96 341.42,220.17 341.61,220.17 341.82,220.39 v4(341.82,220.93) 341.82,221.16 342.08,221.42 342.51,221.42 C1533.2
USB3TN1_CO: length 9.3
  TOP w0.102: C1560.2 334.6,220.51 336.09,220.51 337.05,221.47 338.91,221.47 338.93,221.45 339.47,221.45 339.49,221.47 v4(340.84,221.47) 342.46,221.47 R31.2
USB3TN1_D-: length 11.5
  BOTTOM w0.102: JUSB1.8 331.73,227.51 332.25,226.99 332.25,226.59 331.81,226.15 331.81,224.61 331.5,224.31 331.25,224.31 331.12,224.43 331.12,225.07 330.87,225.32 330.44,225.32 330.19,225.07 330.19,224.64 330.17,224.62 v4(330.17,224.32) 330.17,223.91 330.05,223.79 D78.9 D78.2 330.05,221.54 330.23,221.36 330.23,221.04 329.89,220.69 L96.2 329.89,220.14 R1606.2
USB3TN1_RP: length 2.8
  BOTTOM w0.102: C1535.2 334.6,220.51 335.02,220.51 v4(335.21,220.31) 335.4,220.12 335.77,220.12 335.92,219.96 U92.11
USB3TN2: length 250.7
  TOP w0.102: R12.1 330.44,184.47 330.44,184.16 v2(330.31,184.04)
  IN4 w0.114: v2(323.2,181.94) 322.84,181.58 320.8,181.58 319.03,179.81 307.64,179.81 307.02,179.18 304.66,179.18 303.17,180.67 297.05,180.67 292.95,184.77 288.21,184.77 287.68,184.24 278.12,184.24 276.21,182.33 271.25,182.33 271.01,182.09 267.06,182.09 262.63,177.66 262.63,174.98 262.1,174.45 262.1,166.9 262.48,166.52 262.48,161.41 262.8,161.09 262.8,159.18 262.72,159.1 262.72,150.04 263.25,149.51 263.25,141.85 262.21,140.8 262.21,136.02 262.09,135.9 262.09,119.74 261.84,119.5 261.84,117.35 262.24,116.96 262.24,115.19 261.96,114.92 261.96,111.64 261.12,110.8 261.12,106.6 260.02,105.5 260.02,103.67 260.02,103.03 258.34,101.36 257.82,101.36 253.66,97.2 253.66,96.64 251.67,94.66 251.67,94.15 243.64,86.12 235.32,86.12 235.09,85.89 234.13,85.89 233.68,85.45 229.22,85.45 225.22,89.45 225.11,89.45 224.8,89.76 224.8,91.77 224.38,92.19 224.38,94.8 222.59,96.58 213.97,96.58 210.65,93.27 208.95,93.27 208.08,94.14 206.15,94.14 205.8,94.49 v2(205.8,94.58)
  BOTTOM w0.089: 202.18,79.29 202.1,79.21 201.99,79.21 201.9,79.3 201.9,79.46 201.42,79.94 201.42,80.15 200.9,80.67
  BOTTOM w0.102: 200.9,80.67 199.54,82.03 198.77,82.03 196.28,84.52 196.28,86.69 199.07,89.48 199.07,90.45 202.97,94.34 204.63,94.34 204.85,94.12 205.43,94.12 205.8,94.49 v2(205.8,94.58) ; v2(323.2,181.94) 323.43,181.71 324.28,181.71 324.91,182.34 328.5,182.34 329.16,183 330.43,183 330.53,183.11 330.53,183.81 v2(330.31,184.04) 330.44,184.16 330.44,184.54 330.13,184.85 R12.1
USB3TN2_C: length 2.5
  BOTTOM w0.102: C1518.2 330.43,186.14 330.43,186.85 330.26,187.02 330.04,187.23 U90.20
USB3TN2_CO: length 8.6
  TOP w0.102: R12.2 330.46,186.17 330.46,188.01 330.44,188.03 330.44,188.58 330.46,188.59 v4(330.46,192.44) 330.46,193.59 C2.2
USB3TN2_D-: length 11.4
  BOTTOM w0.102: R3698.2 349.14,217.73 L109.2 349.82,217.73 350.12,217.44 350.33,217.44 350.5,217.61 350.5,217.88 350.68,218.06 350.92,218.06 351.07,218.21 D88.7 D88.4 353.06,218.21 353.21,218.06 v4(353.83,218.06) 354.87,218.06 355.41,217.53 357.56,217.53 358.1,216.99 358.38,216.99 358.71,217.32 JUSB2.8
USB3TN2_RP: length 2.5
  BOTTOM w0.102: U90.11 330.04,192.52 330.19,192.67 330.19,192.86 330.5,193.17 330.5,193.55 C1520.2
USB3TN3: length 212.4
  IN1 w0.114: v2(202.88,84.33) 203.65,84.33 204.38,83.6 206.11,83.6 207.8,85.29 207.8,86 217.38,95.58 232.39,95.58 233.31,94.66 244.04,94.66 246.79,97.41 247.66,97.41 254.01,103.75 254.01,110.49 254.01,110.59 254.95,111.53 254.95,114.87 253.97,115.85 253.97,134.87 253.27,135.57 253.27,146.7 254.47,147.9 254.47,161.09 254.83,161.45 254.83,163.04 255.19,163.4 255.19,164.06 254.83,164.41 254.83,171.25 251.91,174.17 247.27,174.17 246.45,174.17 243.85,176.76 239.9,176.76 239.1,177.56 217.76,177.56 216.87,176.67 209.15,176.67 202.66,183.16 200.83,183.16 197.65,186.34 192.41,186.34 192.25,186.5 190.52,186.5 190.23,186.22 v2(190.23,185.6)
  BOTTOM w0.089: 202.9,82.83 203.01,82.73 203.01,82.4 203.28,82.12 203.39,82.12 203.55,82.28 203.64,82.28 203.78,82.14 203.78,82.05 203.6,81.88 203.6,81.76 203.73,81.64 UH1.BE32
  BOTTOM w0.102: v2(190.23,185.6) 190.42,185.79 190.42,187.72 190.25,187.89 JDOCK1.90 ; 202.9,82.83 202.29,83.44 202.29,83.91 202.01,84.19 202.01,84.75 202.19,84.92 202.5,84.92 202.67,84.75 202.95,84.75 203.07,84.63 203.07,84.52 v2(202.88,84.33)
USB3TN5: length 263.1
  TOP w0.102: R37.1 342.54,186.19 342.79,185.94 342.79,185.28 v2(342.63,185.12)
  IN2 w0.127: v2(342.63,185.12) 342.82,184.93 342.82,184.67 342.65,184.51 333.94,184.51 330.8,181.37 328.43,181.37 328.43,181.37 325.12,181.37 324.37,180.62 323.6,180.62 v2(323.44,180.78)
  IN4 w0.114: v2(323.44,180.78) 323.27,180.61 320.91,180.61 319.34,179.03 309.06,179.03 307.58,177.55 304.95,177.55 302.94,179.55 296.99,179.55 293.8,182.74 289.3,182.74 288.54,183.5 278.99,183.5 277.08,181.6 271.8,181.6 271.52,181.32 267.5,181.32 263.36,177.18 263.36,174.65 262.89,174.18 262.89,167.15 263.2,166.83 263.2,161.81 263.53,161.49 263.53,158.77 263.45,158.69 263.45,150.34 264.02,149.77 264.02,141.57 262.94,140.49 262.94,135.58 262.81,135.45 262.81,119.82 263,119.63 263,114.85 262.7,114.54 262.7,111.32 261.91,110.53 261.91,109.21 261.85,109.14 261.85,106.9 261.85,106.9 261.85,106.3 261.85,106.3 261.85,105.43 261.13,104.71 261.13,103.07 258.52,100.45 258.15,100.45 254.53,96.83 254.53,96.45 252.45,94.37 252.45,93.13 251.48,92.16 251.48,89.48 247.75,85.75 244.39,85.75 244.03,85.39 236.26,85.39 236.01,85.14 234.5,85.14 234.08,84.72 228.91,84.72 224.9,88.73 224.78,88.73 223.66,89.86 223.66,93.38 221.19,95.85 214.33,95.85 214.19,95.71 210.11,91.63 207.44,91.63 206.2,92.87 204.38,92.87 204.02,93.23 v2(204.02,93.38)
  BOTTOM w0.089: 201.31,81.2 201.34,81.17 201.34,80.83 201.91,80.26 201.91,80.19 201.85,80.12 201.85,80.05 201.98,79.91 UH1.BE26
  BOTTOM w0.102: 201.31,81.2 200.46,82.06 200.46,82.43 199.84,83.05 198.95,83.05 197.35,84.65 197.35,86.56 199.92,89.13 199.92,90.13 202.25,92.46 203.25,92.46 203.65,92.85 203.66,92.85 204.02,93.22 v2(204.02,93.38) ; v2(342.63,185.12) 342.8,185.29 342.8,185.94 342.55,186.19 R37.1
USB3TN5_C: length 2.2
  BOTTOM w0.102: U95.20 342.22,188.49 342.37,188.34 342.37,188.09 342.79,187.67 342.79,187.52 C1562.2
USB3TN5_CO: length 8.3
  TOP w0.102: C1563.2 343.04,194.56 v4(343.04,193.4) 343.04,189.55 343.02,189.53 343.02,188.98 343.04,188.96 343.04,188.52 342.79,188.27 342.79,187.52 R37.2
USB3TN5_D-: length 10.7
  BOTTOM w0.102: JUSB3.8 358.71,194.13 358.11,193.54 357.78,193.54 357.28,194.03 356.43,194.03 356.17,194.29 356.17,194.74 355.84,195.07 v4(355.48,195.07) 355.12,195.07 354.62,194.57 354.52,194.57 354.5,194.58 353.95,194.58 353.93,194.57 353.69,194.57 353.55,194.71 D91.4 D91.7 351.44,194.71 351.3,194.58 351.01,194.58 350.71,194.87 L112.2 349.9,194.87 R3728.2
USB3TN5_RP: length 2.6
  BOTTOM w0.102: U95.11 342.22,193.35 342.37,193.5 342.37,193.78 343.02,194.43 343.02,194.58 C1551.2
USB3TN6: length 398
  TOP w0.102: v2(41.79,185.51) 41.78,185.51 41.59,185.7 41.35,185.7 R21.1
  IN1 w0.114: v2(201.65,81.9) 201.65,81.99 201.82,82.17 201.96,82.17 202.05,82.08 202.05,81.55 201.67,81.17 201.08,81.17 200.74,81.51 200.74,82.48 201.52,83.26 201.52,84.41 202.74,85.64 203.11,85.64 203.41,85.34 204.9,85.34 207.01,87.45 208.22,87.45 217.08,96.3 232.74,96.3 233.66,95.38 243.73,95.38 246.53,98.18 247.37,98.18 253.27,104.09 253.27,111.33 253.74,111.8 253.74,113.23 253.21,113.76 253.21,134.45 252.54,135.13 252.54,142.39 252.08,142.85 252.08,146.55 253.74,148.22 253.74,164.97 254.11,165.34 254.11,170.88 251.54,173.44 247.57,173.44 246.06,173.44 243.59,175.92 231.1,175.92 230.23,176.78 218.07,176.78 217.21,175.92 202.5,175.92 202.1,176.31 202.1,177.3 201.81,177.6 201.81,180.79 201.42,181.18 199.49,181.18 197.58,183.08 193.41,183.08 193.22,182.89 190.94,182.89 188.29,185.55 182.43,185.55 180.89,187.08 180.01,187.08 178.74,188.35 175.07,188.35 174.51,188.91 166.73,188.91 165.51,190.13 161.86,190.13 159.77,188.04 159.63,187.9 159.63,180.79 159.26,180.41 159.26,179.05 159.27,179.04 159.27,178.21 159.4,178.08 159.63,177.84 159.63,173.25 154.84,168.45 154.84,166.41 154.07,165.65 148.22,165.65 146.01,163.44 141.43,163.44 141,163.87 138.17,163.87 136.8,165.24 136.73,165.3 135.85,165.3 135.66,165.3 133.42,165.3 132.8,165.93 116.12,165.93 115.98,165.79 95.62,165.79 95.09,166.32 90.71,166.32 81.91,175.12 69.61,175.12 68.82,175.91 60.13,175.91 59.32,175.11 48.95,175.11 43.07,180.98 43.07,183.71 42.08,184.7 41.89,184.7 41.3,185.29 41.3,185.81 41.35,185.86 41.43,185.86 v2(41.79,185.51)
  BOTTOM w0.089: UH1.BD27 202.74,79.91 202.74,80.06 202.34,80.46 202.25,80.46 201.72,80.99 201.72,81.61
  BOTTOM w0.102: 201.72,81.61 201.72,81.83 v2(201.65,81.9) ; v2(41.79,185.51) 41.6,185.7 41.34,185.7 R21.1
USB3TN6_C: length 3
  BOTTOM w0.102: C1546.2 39.62,185.72 39.49,185.72 39.2,185.44 39.1,185.44 39.07,185.41 38.39,185.41 38.36,185.44 38.2,185.44 38.06,185.29 U94.20
USB3TN6_CO: length 9.3
  TOP w0.102: C420.1 31.45,185.71 35.43,185.71 35.45,185.69 35.99,185.69 36.01,185.71 v4(38.06,185.71) 39.64,185.71 R21.2
USB3TN6_D-: length 14.6
  BOTTOM w0.102: R1612.2 24.72,185.39 L97.2 24.02,185.78 23.66,185.78 23.37,185.48 22.76,185.48 22.75,185.48 22.57,185.3 D79.2 D79.9 20.6,185.3 20.42,185.48 19.72,185.48 19.71,185.46 19.15,185.46 19.13,185.48 v4(18.09,185.48) 17.72,185.48 17.53,185.28 17.53,184.61 17.28,184.36 16.55,184.36 16.29,184.61 16.29,185.38 16.2,185.48 14.2,185.48 13.78,185.89 13.47,185.89 13.29,185.71 JUSB4.8
USB3TN6_RP: length 2.7
  BOTTOM w0.102: U94.11 32.88,185.29 32.59,185.58 32.49,185.58 32.45,185.53 31.73,185.53 31.68,185.58 31.49,185.58 31.49,185.58 31.33,185.58 C414.1
USB3TP1: length 301.9
  TOP w0.102: v2(344.66,222.01) 344.45,221.79 344.06,221.79 R29.1
  IN4 w0.114: v2(344.66,222.01) 344.51,221.86 342.28,221.86 341.21,222.92 331.73,222.92 323.92,215.11 323.92,207.54 321.06,204.69 321.06,197.5 322.22,196.34 322.22,195.66 323.38,194.5 324.53,193.35 324.53,189.69 322.49,187.64 322.49,184.51 320.61,182.64 320.13,182.64 319.31,181.81 317.28,181.81 316.99,181.52 297.4,181.52 292.92,186 277.22,186 276.29,185.07 275.38,185.07 273.62,183.31 271.07,183.31 270.58,182.82 266.66,182.82 265.31,181.46 263.96,181.46 262.53,180.03 262.53,178.64 261.45,177.56 261.45,174.85 261.31,174.71 261.31,166.66 261.7,166.26 261.7,161.09 262.08,160.72 262.08,159.94 262,159.86 262,149.74 262.52,149.22 262.52,144.71 261.23,143.43 261.23,138.45 261.49,138.2 261.49,136.54 261.36,136.41 261.36,120.68 261.02,120.34 261.02,113.68 261.21,113.49 261.21,111.94 260.4,111.13 260.4,106.95 259.3,105.85 259.3,103.44 258.08,102.22 257.65,102.22 252.81,97.39 252.81,96.83 250.86,94.87 250.86,94.37 243.34,86.86 241.64,86.86 241.11,87.39 239.12,87.39 238.58,86.84 233.79,86.84 233.13,86.18 229.52,86.18 225.87,89.83 225.87,93.21 225.67,93.4 225.67,94.72 223.08,97.31 213.62,97.31 211.84,95.53 206.53,95.53 v2(206.29,95.76)
  BOTTOM w0.089: 200.48,80.16 200.51,80.16 201.06,79.61 201.06,79.31 201.63,78.74 UH1.BD23
  BOTTOM w0.102: R29.1 344.1,221.75 344.41,221.75 v2(344.66,222.01) ; 200.48,80.16 200.34,80.16 199.31,81.18 198.42,81.18 195.45,84.15 195.45,87.04 198.25,89.84 198.25,91.01 202.96,95.72 204.13,95.72 204.17,95.76 v2(206.29,95.76)
USB3TP1_C: length 3.5
  BOTTOM w0.102: U92.19 341.21,220.46 341.29,220.38 341.52,220.38 341.6,220.46 341.6,221.23 341.99,221.63 342.3,221.63 C1534.2
USB3TP1_CO: length 9.4
  TOP w0.102: C1561.2 334.6,220.72 336,220.72 336.96,221.68 v4(339.2,221.68) 340.55,221.68 340.56,221.7 341.11,221.7 341.13,221.68 342.35,221.68 R29.2
USB3TP1_D+: length 11.5
  BOTTOM w0.102: JUSB1.9 333.3,227.51 332.46,226.67 332.46,226.5 332.02,226.07 332.02,224.5 v4(331.82,224.3) 331.62,224.1 331.16,224.1 330.91,224.35 330.91,224.98 330.78,225.11 330.53,225.11 330.4,224.98 330.4,223.93 330.55,223.79 D78.10 D78.1 330.55,221.48 330.44,221.38 330.44,220.98 330.73,220.69 L96.3 330.73,220.14 R1603.2
USB3TP1_RP: length 2.8
  BOTTOM w0.102: C1536.2 334.6,220.72 335.13,220.72 335.52,220.33 335.87,220.33 336,220.46 U92.12
USB3TP2: length 250.8
  TOP w0.102: v2(330.94,184.04) 330.69,184.29 330.69,184.47 R13.1
  IN4 w0.114: v2(323.2,181.35) 320.9,181.35 319.12,179.58 307.74,179.58 307.11,178.96 304.56,178.96 303.08,180.44 296.95,180.44 292.85,184.54 288.3,184.54 287.77,184.01 278.21,184.01 276.31,182.11 271.35,182.11 271.11,181.86 267.16,181.86 262.86,177.57 262.86,174.89 262.33,174.35 262.33,166.99 262.71,166.61 262.71,161.51 263.03,161.18 263.03,159.09 262.95,159 262.95,150.14 263.48,149.61 263.48,141.75 262.44,140.71 262.44,135.93 262.31,135.8 262.31,119.65 262.07,119.41 262.07,117.45 262.49,117.03 262.49,115.13 262.19,114.82 262.19,111.54 261.35,110.71 261.35,106.69 261.35,106.5 260.25,105.4 260.25,103.57 260.25,102.94 258.44,101.13 257.91,101.13 253.88,97.1 253.88,96.55 251.9,94.56 251.9,94.06 243.73,85.89 235.42,85.89 235.19,85.66 234.22,85.66 233.78,85.22 229.13,85.22 225.12,89.22 225.01,89.22 224.57,89.67 224.57,91.68 224.15,92.09 224.15,94.7 222.5,96.35 214.06,96.35 210.75,93.04 208.85,93.04 207.99,93.91 v2(205.8,93.91)
  BOTTOM w0.089: 200.99,80.88 201.62,80.25 201.62,80.02 202.04,79.6 202.29,79.6 202.48,79.41 202.48,78.96 202.23,78.7 UH1.BC24
  BOTTOM w0.102: v2(323.2,181.35) 323.34,181.5 324.36,181.5 325,182.13 328.58,182.13 329.24,182.79 330.51,182.79 330.74,183.02 330.74,183.83 v2(330.94,184.04) 330.69,184.29 330.69,184.47 R13.1 ; 200.99,80.88 199.63,82.24 198.86,82.24 196.49,84.61 196.49,86.6 199.28,89.39 199.28,90.36 203.05,94.13 204.54,94.13 204.77,93.91 v2(205.8,93.91)
USB3TP2_C: length 2.5
  BOTTOM w0.102: U90.19 330.54,187.41 330.42,187.29 330.42,187.15 330.69,186.88 330.69,186.14 C1519.2
USB3TP2_CO: length 8.6
  TOP w0.102: R13.2 330.67,186.17 v4(330.67,188.3) 330.67,192.15 330.69,192.17 330.69,192.72 330.67,192.73 330.67,193.59 C3.2
USB3TP2_D+: length 11.5
  BOTTOM w0.102: JUSB2.9 358.71,216.22 358.15,216.78 358.01,216.78 357.48,217.31 355.29,217.31 v4(355.07,217.53) 354.76,217.85 354.12,217.85 354.1,217.83 353.56,217.83 353.54,217.85 353.22,217.85 353.07,217.71 D88.5 D88.6 351.06,217.71 350.92,217.85 350.77,217.85 350.71,217.79 350.71,217.53 350.41,217.23 350.17,217.23 349.82,216.88 L109.3 349.14,216.88 R3697.2
USB3TP2_RP: length 2.5
  BOTTOM w0.102: U90.12 330.54,192.52 330.4,192.67 330.4,192.77 330.71,193.08 330.71,193.63 C1521.2
USB3TP3: length 212.6
  IN1 w0.114: v2(202.9,85.15) 202.73,85.15 202.59,85.01 202.59,84.85 202.7,84.74 203.32,84.74 203.49,84.57 203.73,84.57 204.47,83.83 206.02,83.83 207.57,85.38 207.57,86.09 217.29,95.81 232.49,95.81 233.41,94.89 243.94,94.89 246.69,97.64 247.57,97.64 253.78,103.85 253.78,110.4 253.78,110.68 254.34,111.24 254.72,111.62 254.72,114.78 253.74,115.75 253.74,134.78 253.04,135.48 253.04,146.8 254.24,147.99 254.24,161.18 254.61,161.55 254.61,163.14 254.96,163.49 254.96,163.96 254.61,164.32 254.61,171.15 251.82,173.94 247.36,173.94 246.35,173.94 243.76,176.53 239.8,176.53 239,177.33 217.85,177.33 216.96,176.44 209.06,176.44 202.57,182.93 200.74,182.93 197.56,186.11 192.32,186.11 192.16,186.27 190.61,186.27 190.46,186.12 190.46,185.96 190.82,185.61 v2(190.82,185.6)
  BOTTOM w0.089: UH1.BC32 204.49,81 204.16,81.33 203.75,81.33 203.23,81.86 203.23,81.9 202.81,82.32 202.81,82.63 202.8,82.63
  BOTTOM w0.102: v2(190.82,185.6) 190.63,185.79 190.63,187.78 190.75,187.9 JDOCK1.92 ; 202.8,82.63 202.08,83.35 202.08,83.82 201.8,84.1 201.8,84.87 202.09,85.15 v2(202.9,85.15)
USB3TP5: length 263.2
  TOP w0.102: v2(343.21,185.12) 343.01,185.32 343.01,185.93 343.28,186.19 R36.1
  IN2 w0.127: v2(343.21,185.12) 343.07,184.98 343.07,184.57 342.76,184.25 334.04,184.25 330.91,181.11 328.53,181.11 325.23,181.11 324.48,180.36 323.6,180.36 v2(323.44,180.2)
  IN4 w0.114: v2(323.44,180.2) 323.26,180.38 321.01,180.38 319.43,178.8 309.16,178.8 307.67,177.32 304.85,177.32 302.85,179.32 296.89,179.32 293.7,182.51 289.21,182.51 288.44,183.27 279.08,183.27 277.18,181.37 271.9,181.37 271.62,181.09 267.59,181.09 263.58,177.08 263.58,174.56 263.11,174.09 263.11,167.25 263.43,166.93 263.43,161.91 263.76,161.58 263.76,158.68 263.67,158.6 263.67,150.44 264.24,149.87 264.24,141.47 263.17,140.39 263.17,135.48 263.04,135.36 263.04,119.91 263.23,119.72 263.23,114.75 262.92,114.45 262.92,111.22 262.14,110.44 262.14,109.11 262.08,109.05 262.08,106.99 262.08,106.2 262.08,106.2 262.08,105.33 261.36,104.62 261.36,102.97 258.61,100.22 258.24,100.22 254.76,96.74 254.76,96.35 252.67,94.27 252.67,93.03 251.71,92.07 251.71,89.38 247.85,85.52 244.48,85.52 244.13,85.17 236.36,85.17 236.1,84.91 234.59,84.91 234.17,84.49 228.82,84.49 224.81,88.51 224.69,88.51 223.43,89.77 223.43,93.29 221.1,95.62 214.42,95.62 210.21,91.4 207.35,91.4 206.11,92.64 v2(204.02,92.64)
  BOTTOM w0.089: 201.46,81.35 201.47,81.34 201.47,81.33 201.52,81.29 201.52,81.28 201.54,81.25 201.54,80.92 202.26,80.2 202.3,80.2 202.46,80.04 202.46,79.76 202.79,79.42 202.8,79.41 UH1.BC26
  BOTTOM w0.102: v2(343.21,185.12) 343.01,185.32 343.01,185.94 343.26,186.19 R36.1 ; v2(204.02,92.64) 203.73,92.64 203.33,92.24 202.34,92.24 200.13,90.04 200.13,89.05 197.56,86.47 197.56,84.73 199.04,83.26 199.93,83.26 200.67,82.52 200.67,82.14 201.46,81.35
