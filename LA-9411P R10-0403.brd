# Allegro board LA-9411P R10-0403.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
CSA0#_0: length 31.9
  TOP w0.102: v2(192.25,116.29) UV5.L12
  IN4 w0.127: v2(192.25,116.29) 192.66,116.7 192.66,118.86 193.39,119.6 199.21,119.6 199.42,119.38 204.73,119.38 205.06,119.71 206.37,119.71 209.66,123 209.66,124.03 210.55,124.92 210.55,125.12 211.28,125.85 211.28,126.54 211.77,127.04 213.15,127.04 213.62,127.51 213.62,127.65 214.47,128.49 v2(214.47,128.74)
  BOTTOM w0.102: v2(214.47,128.74) 214.25,128.52 UV1.K24 ; v2(192.25,116.29) UV5.L12
CSA1#_0: length 33.2
  TOP w0.102: v2(195.45,142.5) UV3.L12
  IN1 w0.102: 207.12,145.08 207.75,145.08 211.04,141.8 211.9,141.8 212.06,141.63 212.88,141.63 212.93,141.58 213.24,141.58 214.28,140.53 214.28,139.5 214.69,139.09 214.69,135.81 v2(213.86,134.97)
  IN1 w0.127: 207.12,145.08 202.09,145.08 200.7,143.69 196.09,143.69 195.84,143.45 195.84,143.13 195.45,142.74 v2(195.45,142.5)
  BOTTOM w0.102: v2(213.86,134.97) 213.86,135.54 214.09,135.78 215.34,135.78 215.59,136.03 215.59,136.74 UV1.M13 ; v2(195.45,142.5) UV3.L12
CSB0#_0: length 30.9
  TOP w0.102: v2(205.11,157.29) UV7.L12
  IN1 w0.102: 213.51,146.84 213.76,146.59 213.76,146.01 215.69,144.08 215.69,143.28 216.67,142.3 216.67,141.33 217.08,140.92 v2(217.08,140.9)
  IN1 w0.127: v2(205.11,157.29) 205.38,157.02 205.38,154.28 208.44,151.22 208.44,150.96 207.96,150.49 207.96,150.31 208.27,150 208.45,150 209.1,150.65 209.28,150.65 209.55,150.38 209.55,150.2 208.9,149.55 208.9,149.37 209.13,149.14 209.3,149.14 209.8,149.64 209.98,149.64 210.16,149.46 210.16,149.28 209.66,148.78 209.66,148.61 209.84,148.43 210.02,148.43 210.52,148.92 210.7,148.92 210.88,148.74 210.88,148.56 210.38,148.07 210.38,147.89 210.59,147.68 210.77,147.68 211.22,148.13 211.5,148.13 211.96,147.66 212.69,147.66 213.51,146.84
  BOTTOM w0.102: v2(217.08,140.9) 217.08,140.86 217.65,140.28 UV1.P10 ; v2(205.11,157.29) UV7.L12
CSB1#_0: length 26.2
  TOP w0.102: UV9.L12 225.71,157.68 v2(226.1,157.29)
  IN1 w0.102: 224,144.84 223.7,144.55 223.7,141.85 224.06,141.49 224.45,141.49 224.69,141.24 224.69,141.2 225.28,140.62 v2(225.43,140.62)
  IN1 w0.127: 224,144.84 224.24,145.08 224.24,147.27 224.11,147.39 223.58,147.39 223.45,147.52 223.45,147.77 223.58,147.9 224.11,147.9 224.24,148.03 224.24,148.28 224.11,148.41 223.58,148.41 223.45,148.54 223.45,148.79 223.58,148.92 224.11,148.92 224.24,149.04 224.24,149.3 224.11,149.43 223.58,149.43 223.45,149.55 223.45,149.81 223.58,149.93 224.11,149.93 224.24,150.06 224.24,150.31 224.11,150.44 223.58,150.44 223.45,150.57 223.45,150.82 223.58,150.95 224.11,150.95 224.24,151.08 224.24,153.7 224.4,153.87 225.13,153.87 225.33,154.07 225.33,156.53 v2(226.1,157.29)
  BOTTOM w0.102: UV1.AD10 226.05,140 v2(225.43,140.62) ; v2(226.1,157.29) 225.71,157.68 UV9.L12
CSS_GC: length 56.8
  TOP w0.102: v2(117.46,163.92) v1(117.46,164.73)
  TOP w0.254: v4(155.84,164.86) 155.84,165.22 155.53,165.53 PU800.10 ; v4(112.25,164.02) 111.74,164.53 PR702.1
  IN2 w0.254: v4(112.25,164.02) 112.25,163.58 112.5,163.32 114.85,163.32 115.21,162.97 116.89,162.97 117.36,163.44 117.36,163.8 117.46,163.91 v2(117.46,163.92)
  BOTTOM w0.254: v2(117.46,163.92) 117.46,164.03 117.95,164.53 121.22,164.53 121.89,163.86 128.3,163.86 130.6,161.56 141.34,161.56 144.27,158.62 155.13,158.62 155.75,159.25 155.75,164.77 v4(155.84,164.86)
CSSN_1: length 102.1
  TOP w0.254: PQ703.2 113.14,161.04 113.33,161.23 113.6,161.23 v4(114.11,161.73) ; PR703.1 PR707.1 114.16,167.07 PQ701.3 113.03,166.55 v2(113.03,166.43) ; PR744.2 104.1,159.65 v2(104.08,159.66) ; PU703.5 109.08,162.25 108.71,161.89 107.77,161.89 v2(107.29,161.4) ; PR705.2 81.63,189.88 83.55,189.88 83.93,189.5 v2(83.93,189.24)
  IN4 w0.254: v2(83.93,189.24) 83.93,189.53 83.5,189.95 73.89,189.95 70.76,186.82 70.76,178.87 71.29,178.33 76,178.33 77.38,176.95 77.38,175.82 81.1,172.09 83.96,172.09 87.71,168.34 87.71,164.99 89.31,163.4 93.63,163.4 93.65,163.39 93.66,163.39 96.88,160.16 103.23,160.16 103.73,159.66 v2(104.08,159.66) 105.53,159.66 107.27,161.4 v2(107.29,161.4) 108.38,161.4 109.33,162.35 109.33,163.81 109.33,164.13 110.44,165.24 113.31,165.24 113.79,164.76 113.79,162.2 114.11,161.89 v4(114.11,161.73)
  BOTTOM w0.102: v2(104.08,159.66) v1(104.75,159.66)
  BOTTOM w0.254: v2(113.03,166.43) 113.03,165.26 113.83,164.46 113.83,162.2 114.11,161.92 v4(114.11,161.73)
CSSP_1: length 103.1
  TOP w0.254: v2(84.56,189.24) 84.56,189.62 v1(83.8,190.39) PR704.2 ; PR736.1 104.15,158.64 v2(103.77,159.02) ; v2(110.97,166.46) 110.97,166.62 110.09,167.5 PQ702.3 109.79,166.27 109.33,165.81 PR706.1 ; PR703.2 113.2,164.53 113.41,164.33 113.41,163.69 113.14,163.42 PQ703.5 113.14,162.23 113.41,161.96 v4(113.41,161.77)
  IN4 w0.254: v2(84.56,189.24) 84.56,189.64 83.87,190.33 73.67,190.33 70.38,187.05 70.38,178.68 71.1,177.95 75.84,177.95 77,176.8 77,175.66 80.95,171.71 83.74,171.71 87.33,168.12 87.33,164.83 89.16,163 93.5,163 96.73,159.78 103.01,159.78 v2(103.77,159.02) 104.38,159.02 104.64,159.28 105.79,159.28 107.42,160.92 108.44,160.92 109.71,162.19 109.71,163.97 110.6,164.86 113.15,164.86 113.41,164.6 v4(113.41,161.77)
  BOTTOM w0.254: v4(113.41,161.77) 113.44,161.81 113.44,164.27 111.25,166.46 v2(110.97,166.46)
CVT_LVDS_A0+: length 28.4
  TOP w0.089: U27.41 176.22,141.59 176.12,141.69 176.12,141.96 v2(176.28,142.13)
  IN1 w0.089: v2(176.28,142.13) 176.17,142.13 176.08,142.21 176.08,142.33 175.95,142.46 175.95,143.4 175.7,143.65 174.63,143.65 174.51,143.78 174.51,144.14 174.63,144.27 175.7,144.27 175.95,144.52 175.95,145.99 175.52,146.42 175.52,147.68 175.87,148.02 175.87,151.31 174.8,152.37 174.8,162.39 174.25,162.94 174.25,163.79 174.31,163.84 174.37,163.84 v2(174.7,163.51)
  BOTTOM w0.089: v2(174.7,163.51) 174.78,163.6 174.78,163.59 175.27,163.59 175.39,163.47 JLVDS1.32
CVT_LVDS_A0-: length 28.5
  TOP w0.089: v2(175.69,142.13) 175.82,142 U27.42
  IN1 w0.089: v2(174.7,164.1) 174.2,164.1 174,163.89 174,162.83 174.54,162.29 174.54,152.27 175.61,151.2 175.61,148.12 175.27,147.78 175.27,146.31 175.69,145.89 175.69,144.62 175.59,144.53 174.53,144.53 174.25,144.25 174.25,143.67 174.53,143.4 175.59,143.4 175.69,143.3 v2(175.69,142.13)
  BOTTOM w0.089: v2(174.7,164.1) 174.9,163.89 175.25,163.89 175.33,163.97 JLVDS1.33
CVT_LVDS_A1+: length 26.4
  TOP w0.089: v2(177.22,142.65) 177.07,142.5 177.07,142.05 176.97,141.95 176.97,141.63 177.02,141.58 U27.39
  IN1 w0.089: v2(177.37,162.83) 177.04,163.16 176.44,163.16 175.69,162.41 175.69,152.53 176.59,151.63 176.59,148.02 177,147.61 177,145.46 177.3,145.15 177.3,143.47 176.89,143.06 176.89,142.98 177.02,142.84 177.02,142.73 177.11,142.65 v2(177.22,142.65)
  BOTTOM w0.089: JLVDS1.30 176.47,162.47 177,163 177.19,163 v2(177.37,162.83)
CVT_LVDS_A1-: length 26.4
  TOP w0.089: U27.40 176.62,141.58 176.68,141.63 176.68,142.07 176.78,142.17 176.78,142.5 v2(176.63,142.65)
  IN1 w0.089: v2(177.37,163.41) 176.33,163.41 175.43,162.51 175.43,152.43 176.34,151.52 176.34,147.91 176.74,147.51 176.74,145.35 177.05,145.05 177.05,143.58 176.63,143.17 v2(176.63,142.65)
  BOTTOM w0.089: v2(177.37,163.41) 177.24,163.29 176.87,163.29 176.55,162.97 JLVDS1.31
CVT_LVDS_A2+: length 31.1
  TOP w0.089: U27.37 177.82,141.6 178.11,141.89 178.11,142.15 v2(178.33,142.37)
  IN1 w0.089: v2(177.34,161.62) 177.01,161.95 176.83,161.95 176.44,161.56 176.44,152.98 177.31,152.1 177.31,148.34 177.76,147.89 177.76,145.74 178.11,145.39 178.11,144.78 178.18,144.72 179.48,144.72 179.73,144.47 179.73,141.68 179.45,141.4 179.05,141.4 178.77,141.68 178.77,143.29 178.65,143.42 178.24,143.42 178,143.18 178,142.7 178.14,142.56 178.14,142.44 178.21,142.37 v2(178.33,142.37)
  BOTTOM w0.089: v2(177.34,161.62) 177.18,161.78 176.71,161.78 176.4,161.47 JLVDS1.28
CVT_LVDS_A2-: length 31.1
  TOP w0.089: U27.38 177.42,141.6 177.53,141.71 177.53,141.73 177.82,142.02 177.82,142.29 v2(177.74,142.37)
  IN1 w0.089: v2(177.74,142.37) 177.74,143.28 178.13,143.67 178.75,143.67 179.03,143.4 179.03,141.78 179.15,141.66 179.35,141.66 179.47,141.78 179.47,144.37 179.38,144.46 178.08,144.46 177.86,144.68 177.86,145.28 177.5,145.64 177.5,147.79 177.06,148.23 177.06,151.99 176.18,152.87 176.18,161.66 176.72,162.2 v2(177.34,162.2)
  BOTTOM w0.089: v2(177.34,162.2) 177.21,162.07 176.59,162.07 176.49,161.97 JLVDS1.29
CVT_LVDS_ACLK+: length 30
  TOP w0.089: U27.35 179.11,139.86 179.22,139.97 179.35,139.97 179.48,139.84 v2(179.48,139.77)
  IN1 w0.089: v2(177.35,160.29) 177.16,160.1 177.16,156.94 177.54,156.56 177.54,155.87 177.63,155.78 177.76,155.78 178.04,155.5 178.04,148.68 178.52,148.2 178.52,146.08 178.94,145.66 179.86,145.66 179.94,145.74 179.94,145.9 180.21,146.16 180.54,146.16 180.79,145.91 180.79,145.22 180.54,144.97 180.54,144.78 180.79,144.53 180.79,144.16 180.54,143.9 180.54,143.75 180.81,143.49 180.81,142.76 180.55,142.51 180.55,142.25 180.79,142.01 180.79,141.54 180.41,141.16 180.41,141.05 180.79,140.67 180.79,140.03 180.58,139.81 180.13,139.81 179.89,140.06 179.78,140.06 179.66,139.94 179.56,139.94 179.48,139.86 v2(179.48,139.77)
  BOTTOM w0.089: JLVDS1.25 176.63,159.97 176.79,160.13 177.2,160.13 v2(177.35,160.29) 177.5,160.44 177.71,160.44 177.99,160.16 C49.1
CVT_LVDS_ACLK-: length 29.8
  TOP w0.089: v2(179.48,140.35) 179.3,140.17 179.2,140.17 179.11,140.26 U27.36
  IN1 w0.089: v2(177.35,160.87) 176.91,160.43 176.91,156.83 177.29,156.45 177.29,155.77 177.53,155.52 177.66,155.52 177.78,155.4 177.78,148.57 178.27,148.09 178.27,145.97 178.84,145.4 179.97,145.4 180.2,145.63 180.2,145.79 180.31,145.91 180.43,145.91 180.54,145.8 180.54,145.33 180.28,145.07 180.28,144.67 180.54,144.42 180.54,144.26 180.28,144.01 180.28,143.65 180.55,143.38 180.55,142.87 180.3,142.61 180.3,142.15 180.54,141.91 180.54,141.65 180.16,141.27 180.16,140.94 180.54,140.56 180.54,140.14 180.47,140.07 180.23,140.07 179.99,140.31 179.53,140.31 v2(179.48,140.35)
  BOTTOM w0.089: JLVDS1.26 176.63,160.47 176.67,160.43 176.91,160.43 v2(177.35,160.87) 177.51,160.72 177.81,160.72 C43.1
CVT_LVDS_B0+: length 33.3
  TOP w0.089: U27.31 179.26,138.26 179.83,138.84 180.23,138.84 v2(180.34,138.73)
  IN1 w0.089: v2(180.34,138.73) 180.45,138.85 181.26,138.85 181.52,139.1 181.52,139.4 181.4,139.51 181.4,139.61 181.52,139.73 181.52,140.18 181.6,140.26 181.84,140.26 182.11,140.53 182.11,141.1 181.84,141.38 181.58,141.38 181.52,141.44 181.52,142.16 181.58,142.23 181.86,142.23 182.11,142.48 182.11,142.83 181.86,143.08 181.61,143.08 181.53,143.16 181.53,143.75 181.62,143.84 181.84,143.84 182.11,144.12 182.11,144.5 181.84,144.78 181.57,144.78 181.52,144.83 181.52,145.36 181.78,145.63 181.78,145.96 181.52,146.23 181.52,147.27 181.26,147.52 180.87,147.52 180.62,147.27 180.62,146.96 180.55,146.89 180.33,146.89 180.27,146.94 180.27,147.37 180.02,147.62 179.6,147.62 179.54,147.69 179.54,148.22 178.78,148.98 178.78,156.98 178.32,157.44 178.32,158.63 178.52,158.84 178.93,158.84 v2(179.15,158.62)
  BOTTOM w0.089: v2(179.15,158.62) 179.02,158.75 178.54,158.75 178.26,158.47 177.35,158.47 177.25,158.57 176.92,158.57 176.91,158.56 176.89,158.56
  BOTTOM w0.102: 176.89,158.56 176.83,158.56 176.82,158.57 176.73,158.57 176.63,158.47 JLVDS1.22
CVT_LVDS_B0-: length 33.3
  TOP w0.089: U27.32 179.25,138.66 179.71,139.13 180.11,139.13 v2(180.32,139.34)
  IN1 w0.089: v2(180.32,139.34) 180.34,139.34 180.58,139.1 181.16,139.1 181.26,139.21 181.26,139.29 181.15,139.41 181.15,139.72 181.26,139.83 181.26,140.28 181.49,140.51 181.73,140.51 181.86,140.64 181.86,141 181.73,141.12 181.48,141.12 181.26,141.34 181.26,142.27 181.48,142.48 181.76,142.48 181.86,142.58 181.86,142.72 181.76,142.82 181.5,142.82 181.28,143.05 181.28,143.85 181.52,144.09 181.73,144.09 181.86,144.22 181.86,144.4 181.73,144.53 181.47,144.53 181.26,144.73 181.26,145.47 181.53,145.74 181.53,145.86 181.26,146.12 181.26,147.16 181.16,147.27 180.97,147.27 180.87,147.16 180.87,146.85 180.65,146.63 180.22,146.63 180.02,146.84 180.02,147.27 179.91,147.37 179.5,147.37 179.28,147.59 179.28,148.12 178.53,148.87 178.53,156.87 178.06,157.34 178.06,158.74 178.42,159.09 179.05,159.09 v2(179.15,159.2)
  BOTTOM w0.089: 176.83,158.87 176.73,158.87 176.63,158.97 JLVDS1.23 ; 176.89,158.87 176.92,158.87 176.92,158.86 177.37,158.86 177.47,158.76 178.14,158.76 178.42,159.04 179,159.04 v2(179.15,159.2)
  BOTTOM w0.102: 176.83,158.87 176.89,158.87
CVT_LVDS_B1+: length 32.5
  TOP w0.089: v2(180.35,137.48) 180.26,137.57 180.26,137.57 179.88,137.57 179.83,137.52 179.27,137.52 179.21,137.46 U27.29
  IN1 w0.089: v2(180.35,137.48) 180.51,137.64 181.1,137.64 181.72,138.26 182.35,138.26 182.63,138.54 182.63,139.32 182.84,139.52 182.84,147.23 181.8,148.27 181.43,148.27 181.07,148.63 180.21,148.63 179.5,149.33 179.5,157.58 180.12,158.2 180.12,158.46 180.3,158.64 180.36,158.64 v2(180.51,158.48)
  BOTTOM w0.089: JLVDS1.20 176.63,157.47 176.73,157.57 179.44,157.57 179.85,157.99 179.86,157.99 180.35,158.48 v2(180.51,158.48)
CVT_LVDS_B1-: length 32.7
  TOP w0.089: v2(180.35,138.07) 180.14,137.86 179.92,137.86 179.87,137.81 179.23,137.81 179.18,137.86 U27.30
  IN1 w0.089: v2(180.35,138.07) 180.52,137.9 181,137.9 181.62,138.52 182.25,138.52 182.38,138.65 182.38,139.42 182.58,139.63 182.58,147.13 181.69,148.02 181.32,148.02 180.97,148.37 180.1,148.37 179.25,149.23 179.25,157.69 179.87,158.31 179.87,158.56 180.19,158.89 180.34,158.89 v2(180.51,159.06)
  BOTTOM w0.089: JLVDS1.21 176.63,157.97 176.73,157.87 179.32,157.87 179.73,158.28 179.74,158.28 180.32,158.86 180.32,158.86 v2(180.51,159.06)
CVT_LVDS_B2+: length 34.6
  TOP w0.089: U27.27 179.08,136.66 179.13,136.72 179.54,136.72 v2(179.73,136.53)
  IN1 w0.089: v2(179.73,136.53) 179.95,136.75 181.3,136.75 181.66,137.11 182.47,137.11 183.36,138 183.36,138.98 183.56,139.18 183.56,147.74 181.92,149.38 180.51,149.38 180.23,149.66 180.23,157.07 180.76,157.6 180.76,157.77 181.03,158.04 181.08,158.04 v2(181.34,157.78)
  BOTTOM w0.089: v2(181.34,157.78) 181.19,157.94 181.08,157.94 179.81,156.67 v4(178.99,156.67) 177.77,156.67 177.68,156.57 176.73,156.57 176.63,156.47 JLVDS1.18
CVT_LVDS_B2-: length 34.5
  TOP w0.089: v2(179.73,137.12) 179.62,137.01 179.21,137.01 179.16,137.06 U27.28
  IN1 w0.089: v2(181.34,158.37) 181.26,158.29 180.92,158.29 180.5,157.88 180.5,157.7 179.97,157.17 179.97,149.56 180.41,149.12 181.82,149.12 183.31,147.63 183.31,139.28 183.1,139.08 183.1,138.1 182.36,137.36 181.55,137.36 181.2,137.01 179.84,137.01 v2(179.73,137.12)
  BOTTOM w0.089: v2(181.34,158.37) 181.2,158.23 180.96,158.23 179.69,156.96 177.65,156.96 177.56,156.87 176.73,156.87 176.63,156.97 JLVDS1.19
CVT_LVDS_BCLK+: length 38.1
  TOP w0.089: U27.25 179.29,135.86 179.33,135.81 180.05,135.81 180.14,135.9 180.24,135.9 v2(180.37,135.77) ; C40.1 180.32,156.7 181.82,156.7 v2(181.87,156.65)
  IN1 w0.089: v2(181.87,156.65) 181.69,156.83 181.11,156.83 180.95,156.67 180.95,156.01 181.49,155.47 181.49,152.89 183.15,151.23 183.15,150.37 182.72,149.94 182.72,149.76 182.98,149.5 183.16,149.5 183.33,149.68 183.72,149.68 184.01,149.39 184.01,149 183.74,148.73 183.74,148.61 184.29,148.06 184.29,138.79 184.11,138.62 184.11,137.68 182.79,136.36 181.94,136.36 181.5,135.93 180.53,135.93 v2(180.37,135.77)
  BOTTOM w0.089: JLVDS1.15 176.63,154.97 176.73,155.07 177.85,155.07 178.56,155.78 180.27,155.78 181.26,156.77 181.75,156.77 v2(181.87,156.65)
CVT_LVDS_BCLK-: length 38.2
  TOP w0.089: v2(180.37,136.35) 180.21,136.19 180.02,136.19 179.93,136.11 179.46,136.11 179.3,136.26 U27.26 ; v2(181.87,157.23) 181.63,156.99 180.16,156.99 C41.1
  IN1 w0.089: v2(180.37,136.35) 180.54,136.18 181.4,136.18 181.83,136.61 182.69,136.61 183.85,137.78 183.85,138.72 184.03,138.9 184.03,147.96 183.48,148.5 183.48,148.84 183.75,149.11 183.75,149.29 183.62,149.42 183.44,149.42 183.26,149.25 182.87,149.25 182.47,149.65 182.47,150.04 182.9,150.47 182.9,151.12 181.24,152.78 181.24,155.37 180.7,155.91 180.7,156.77 181.01,157.09 181.73,157.09 v2(181.87,157.23)
  BOTTOM w0.089: v2(181.87,157.23) 181.7,157.06 181.14,157.06 180.15,156.07 178.44,156.07 177.73,155.37 176.73,155.37 176.63,155.47 JLVDS1.16
D_CLKRUN#: length 240.3
  TOP w0.102: U46.A19 270.94,59.2 270.92,59.21 270.92,59.59 270.23,60.29 v2(269.92,60.29) 269.92,60.31 269.4,60.83 R777.2 ; v2(275.59,190.51) 275.59,188.3 275.83,188.06 275.83,186.82 281.48,181.17 281.48,173.81 280.55,172.89 280.55,172.88 280.32,172.64 280.31,172.64 v1(279.27,171.6) 278.96,171.3 v2(278.96,170.57)
  IN1 w0.102: v2(278.96,170.57) 278.96,170.15 278.34,169.53 278.34,167.79 277.5,166.95 277.5,155.42 277.81,155.11 277.81,147.8 278.23,147.38 278.23,146.92 280.12,145.03 v2(280.12,144.96)
  IN2 w0.127: v2(277.99,61.09) 277.91,61.09 277.71,61.29 275.62,61.29 275.56,61.23 270.44,61.23 269.9,60.68 269.9,60.31 v2(269.92,60.29)
  IN4 w0.102: v2(275.59,190.51) 274.7,189.62 274.11,189.62 271.85,187.36 270.38,187.36 269.9,186.88 260.4,186.88 259.76,187.52 250.5,187.52 249.43,186.44 241.79,186.44 236.26,180.91 212.49,180.91 210.9,179.32 206.89,179.32 205.88,178.31 199.26,178.31 197.63,179.93 197.02,179.93 196.53,179.44 196.53,179.41 v2(196.51,179.39)
  BOTTOM w0.102: JDOCK1.111 196.75,179.63 v2(196.51,179.39) ; v2(277.99,61.09) 277.99,61.1 278.11,61.23 278.13,61.23 278.54,61.65 278.54,62.62 277.88,63.28 277.88,74.27 278.25,74.63 278.25,95.8 277.05,97 277.05,104.77 275.19,106.64 275.19,108.06 274.18,109.07 274.18,117.74 275.06,118.63 275.06,122.77 276.77,124.47 276.77,126.55 278.14,127.91 278.14,132.46 277.88,132.71 277.88,132.74 277.6,133.02 277.6,142.75 279.81,144.96 v2(280.12,144.96)
D_DLDRQ1#: length 218.9
  TOP w0.102: v2(275.56,56.65) 275.56,56.63 276.17,56.02 R782.2 ; v2(269.52,55.89) 269.36,55.89 269.02,56.23 269.02,56.67 269.19,56.84 U46.B24
  IN3 w0.127: v2(199.39,176.06) 200.05,176.06 200.73,175.39 213.48,175.39 213.71,175.62 217.73,175.62 218.87,176.75 221.12,179.01 224.75,179.01 224.75,179.01 225.84,179.01 226.29,178.56 233.26,178.56 233.53,178.56 234.15,178.56 237.03,181.44 247.95,181.44 248.55,180.84 251.97,180.84 252.13,181 252.98,181 253.67,180.31 256.78,180.31 257.36,180.9 259.29,180.9 262.47,177.72 263.1,177.72 264.97,175.86 264.97,173.96 264.57,173.56 264.57,157.09 264.93,156.73 265.86,156.73 266.28,156.31 266.28,155.93 264.32,153.97 264.32,151.31 265.25,150.38 265.25,146.29 267.44,144.09 267.44,142.58 268.65,141.38 268.65,140.35 269.78,139.22 269.78,137.73 269.6,137.55 269.6,128.7 270.34,127.96 270.34,126.45 269.54,125.65 269.54,119.19 270.34,118.4 270.34,102.59 272.42,100.51 272.42,92.55 271.2,91.33 271.2,76.12 269.15,74.06 269.15,73.18 267.39,71.42 267.39,65.23 266.84,64.67 266.84,62.21 266.18,61.55 266.18,57.98 266.7,57.47 268.32,57.47 269.1,56.69 269.1,56.3 v2(269.52,55.89)
  BOTTOM w0.102: v2(269.52,55.89) 269.48,55.85 269.48,55.13 269.85,54.76 v1(270.37,54.76) 270.98,54.76 271.15,54.93 271.93,54.93 271.95,54.95 272.42,54.95 274.05,56.58 275.48,56.58 v2(275.56,56.65) ; JDOCK1.117 198.25,178.72 198.26,178.72 198.26,177.53 198.66,177.13 198.66,176.78 199.38,176.06 v2(199.39,176.06)
D_LAD0: length 210
  TOP w0.102: v1(192.39,177.18) 192.84,176.73 v2(192.93,176.73) ; v2(266.87,56.58) 266.69,56.77 U46.B29
  IN3 w0.127: v2(266.87,56.58) 266.57,56.88 265.83,56.88 264.85,57.86 264.85,60.95 266.2,62.29 266.2,64.76 266.88,65.44 266.88,71.63 268.64,73.39 268.64,74.27 270.7,76.33 270.7,91.54 271.88,92.73 271.88,96.28 269.65,98.51 269.65,100.56 269.83,100.74 269.83,118.19 269.04,118.98 269.04,125.42 268.44,126.02 268.44,127.65 268.68,127.89 268.68,138.99 268.14,139.52 268.14,141.17 266.94,142.37 266.94,143.88 264.74,146.08 264.74,150.17 263.81,151.1 263.81,174.07 263.62,174.26 263.62,176.02 262.68,176.96 262.1,176.96 259.29,179.77 252.3,179.77 251.74,180.33 248.29,180.33 247.79,180.84 237.36,180.84 234.58,178.05 233.32,178.05 233.05,178.05 226.08,178.05 225.63,178.5 225.42,178.5 225.42,178.5 225.38,178.5 225.38,178.5 224.96,178.5 224.96,178.5 221.33,178.5 219.37,176.54 217.82,174.99 213.97,174.99 213.85,174.88 200.51,174.88 200.17,175.22 194.62,175.22 194,175.84 193.4,175.84 193.38,175.87 193.14,175.87 192.87,176.14 192.87,176.63 192.93,176.69 v2(192.93,176.73)
  BOTTOM w0.102: v2(192.93,176.73) 192.93,176.73 192.72,176.94 192.72,179.43 193.25,179.96 JDOCK1.97
D_LAD1: length 212.6
  TOP w0.102: U46.B28 267.19,56.91 267.31,56.79 267.31,56.3 v2(267.72,55.89)
  IN3 w0.127: v2(267.72,55.89) 267.29,56.31 267.29,56.77 266.92,57.14 265.94,57.14 265.11,57.97 265.11,60.84 266.45,62.19 266.45,64.65 267.13,65.33 267.13,71.52 268.89,73.28 268.89,74.16 270.95,76.22 270.95,91.44 272.14,92.63 272.14,100.37 270.09,102.43 270.09,118.29 269.29,119.09 269.29,125.76 270.09,126.56 270.09,127.84 268.93,128.99 268.93,139.09 268.4,139.63 268.4,141.27 267.19,142.48 267.19,143.99 264.99,146.19 264.99,150.27 264.07,151.2 264.07,173.77 264.46,174.17 264.46,175.54 262.79,177.22 262.21,177.22 259.36,180.06 252.42,180.06 251.89,180.59 248.44,180.59 247.93,181.1 237.19,181.1 234.4,178.31 233.42,178.31 233.16,178.31 226.18,178.31 225.74,178.75 224.85,178.75 224.85,178.75 221.22,178.75 219.12,176.65 217.83,175.36 213.82,175.36 213.59,175.13 200.62,175.13 200.28,175.48 194.75,175.48 194.69,175.54 194.67,175.54 194.11,176.1 193.51,176.1 v2(193.32,176.29)
  BOTTOM w0.102: v2(267.72,55.89) v1(267.72,55.1) ; JDOCK1.99 193.75,179.92 193.05,179.22 193.05,178 193.48,177.57 193.48,176.45 v2(193.32,176.29)
D_LAD2: length 212.4
  TOP w0.102: U46.A25 267.94,58.84 v2(267.89,58.89)
  IN3 w0.127: v2(267.89,58.89) 267.79,58.89 267.44,59.23 267.44,59.74 267.78,60.07 267.78,61.54 268.34,62.11 268.34,63.86 269.46,64.99 269.46,69.65 269.46,69.86 271.71,72.11 271.71,90.27 272.26,90.82 272.63,90.82 272.88,91.07 272.88,92.04 272.96,92.11 272.96,100.73 270.85,102.84 270.85,118.61 270.05,119.4 270.05,125.44 270.85,126.24 270.85,128.28 270.11,129.02 270.11,137.34 270.91,138.14 270.91,140.47 270.46,140.92 270.15,140.92 269.52,141.56 269.52,142.74 266.38,145.88 266.38,149.42 265.76,150.04 265.76,150.59 264.83,151.52 264.83,153.76 266.81,155.74 266.81,156.5 265.92,157.39 265.41,157.39 265.08,157.72 265.08,173.35 265.48,173.75 265.48,176.16 263.3,178.34 262.57,178.34 258.94,181.97 252.38,181.97 251.76,181.35 248.77,181.35 248.02,182.11 236.58,182.11 233.55,179.07 233.48,179.07 226.5,179.07 226.04,179.53 220.92,179.53 218.36,176.97 217.61,176.22 213.34,176.22 213.01,175.89 200.95,175.89 200.11,176.73 199,176.73 198.31,176.04 196.95,176.04 196.49,176.5 195.41,176.5 195,176.1 194.81,176.1 v2(194.78,176.06)
  BOTTOM w0.102: JDOCK1.103 194.72,180.78 194.72,179.88 194.49,179.65 194.27,179.65 193.35,178.73 193.35,178.02 193.71,177.66 193.71,176.39 194.08,176.02 194.7,176.02 194.74,176.06 v2(194.78,176.06) ; v2(267.89,58.89) v1(267.35,58.89)
D_LAD3: length 209.8
  TOP w0.102: U46.A24 268.44,58.45 268.33,58.55 268.33,59.05 v2(268.73,59.45)
  IN3 w0.127: v2(194.83,176.89) 194.93,176.78 196.57,176.78 197.06,176.3 198.2,176.3 198.91,177.01 200.58,177.01 201.44,176.15 212.91,176.15 213.23,176.48 217.51,176.48 218.1,177.07 218.1,177.07 220.81,179.78 225.94,179.78 226.32,179.78 226.78,179.32 232.98,179.32 236.14,182.49 248,182.49 248.88,181.6 251.66,181.6 252.31,182.26 259.95,182.26 265.73,176.47 265.73,173.16 265.34,172.77 265.34,166.33 267.15,164.52 267.15,150.96 266.63,150.44 266.63,145.99 269.77,142.85 269.77,141.66 270.26,141.17 270.68,141.17 271.17,140.69 271.17,138.03 270.37,137.23 270.37,129.13 271.1,128.4 271.1,126.13 270.31,125.34 270.31,119.51 271.1,118.71 271.1,103 273.28,100.82 273.28,91.88 273.17,91.77 273.17,73.9 271.97,72.69 271.97,72 269.72,69.76 269.72,64.88 268.59,63.76 268.59,62 268.03,61.44 268.03,59.9 268.45,59.48 268.7,59.48 v2(268.73,59.45)
  BOTTOM w0.102: v2(268.73,59.45) 268.73,59.59 v1(269.21,60.07) ; JDOCK1.105 195.25,179.95 194.41,179.11 194.41,178.36 194.65,178.12 194.65,177.06 v2(194.83,176.89)
D_LFRAME#: length 212.3
  TOP w0.102: v2(269.52,56.52) 269.52,56.88 269.69,57.05 U46.B23 ; v2(198.82,175.91) v1(198.82,175.32)
  IN3 w0.127: v2(198.82,175.91) 198.83,175.91 198.83,176.09 199.21,176.48 199.99,176.48 200.83,175.64 213.12,175.64 213.44,175.97 217.72,175.97 218.61,176.86 221.01,179.26 224.64,179.26 224.64,179.26 225.95,179.26 226.39,178.82 233.37,178.82 233.63,178.82 233.63,178.82 234.02,178.82 236.91,181.71 248.05,181.71 248.67,181.1 251.87,181.1 252.03,181.25 253.31,181.25 253.74,180.82 256.66,180.82 257.44,181.6 258.95,181.6 262.57,177.98 263.27,177.98 265.22,176.02 265.22,173.85 264.83,173.46 264.83,157.19 265.04,156.98 265.96,156.98 266.53,156.42 266.53,155.82 264.57,153.87 264.57,151.41 265.5,150.49 265.5,149.94 266.12,149.31 266.12,145.77 267.7,144.2 267.7,142.69 268.91,141.48 268.91,140.45 270.04,139.32 270.04,137.62 269.86,137.44 269.86,128.84 270.59,128.1 270.59,126.34 269.8,125.55 269.8,119.3 270.59,118.5 270.59,102.72 272.67,100.64 272.67,92.41 271.46,91.2 271.46,76.01 269.4,73.95 269.4,73.07 267.64,71.31 267.64,65.12 267.09,64.57 267.09,62.1 266.43,61.45 266.43,58.09 266.8,57.72 268.43,57.72 269.52,56.63 v2(269.52,56.52)
  BOTTOM w0.102: v2(198.82,175.91) 198.57,175.91 197.8,176.68 197.8,177.9 197.43,178.27 196.25,178.27 195.83,178.69 195.83,179.55 196.25,179.97 JDOCK1.109
D_SERIRQ: length 211
  TOP w0.102: U46.A20 270.44,59.36 269.99,59.8 269.82,59.8 269.44,60.19 v2(268.46,60.19) 268.3,60.35 268.12,60.35 R780.2 267.55,60.9 267.04,61.4 v1(267.04,62.83)
  IN3 w0.127: v2(198.2,176.9) 198.24,176.94 198.24,177.03 198.48,177.27 200.68,177.27 201.54,176.4 212.8,176.4 213.13,176.73 217.4,176.73 217.85,177.18 220.72,180.05 226.45,180.05 226.87,179.63 232.86,179.63 236,182.77 248.1,182.77 249.01,181.86 251.49,181.86 252.2,182.56 260.05,182.56 265.98,176.63 265.98,172.96 266.51,172.44 266.51,165.52 267.41,164.62 267.41,150.85 266.89,150.33 266.89,146.09 270.02,142.95 270.02,141.77 270.37,141.43 270.79,141.43 271.42,140.8 271.42,137.93 270.62,137.13 270.62,129.4 271.36,128.66 271.36,126.03 270.56,125.23 270.56,119.61 271.36,118.82 271.36,103.12 273.54,100.94 273.54,92.64 274.11,92.07 274.11,90.21 274.46,89.86 275.06,89.86 275.24,89.69 275.24,77.65 273.43,75.83 273.43,73.79 272.22,72.58 272.22,71.83 269.97,69.58 269.97,64.77 268.85,63.65 268.85,60.51 268.52,60.19 v2(268.46,60.19)
  BOTTOM w0.102: v2(198.2,176.9) 198.03,177.08 198.03,178.42 197.75,178.7 JDOCK1.115
DAI_12MHZ#: length 197.1
  TOP w0.102: R1654.1 v2(338.95,163.84)
  IN1 w0.102: v2(344.62,186.66) 343.77,185.81 343.77,183.43 341.36,181.01 341.36,179.04 338.97,176.66 338.97,173.89 338.77,173.68 338.77,167.41 337.78,166.42 337.78,165.91 338.95,164.74 v2(338.95,163.84)
  IN2 w0.127: v2(317.48,186.99) 318.92,188.43 320.7,188.43 321.25,188.99 336.95,188.99 337.52,188.42 339.79,188.42 340.36,188.99 342.39,188.99 344.62,186.75 v2(344.62,186.66)
  IN4 w0.102: v2(190.09,178.71) 190.1,178.71 190.78,179.39 194.93,179.39 196.08,178.23 198.43,178.23 198.84,177.83 206.32,177.83 207.34,178.84 211.1,178.84 212.69,180.43 236.46,180.43 241.99,185.96 249.63,185.96 250.55,186.88 259.65,186.88 260.13,186.4 270.1,186.4 270.58,186.88 272.1,186.88 274.34,189.13 275.3,189.13 276.08,189.9 294.28,189.9 298.53,185.65 315.07,185.65 315.96,186.54 317.03,186.54 v2(317.48,186.99)
  BOTTOM w0.102: RE11.1 189.95,178.04 189.95,178.57 v2(190.09,178.71) 190.09,178.84 190.25,179 JDOCK1.89 ; v2(338.95,163.84) 339.12,163.84 339.81,164.53 C987.1
DAI_BCLK#: length 199.3
  TOP w0.102: v2(339.89,163.83) 339.96,163.91 R1668.1
  IN1 w0.102: v2(344.64,185.98) 344.25,185.6 344.25,183.23 343.56,182.53 343.56,182.53 342.25,181.22 342.25,178.41 341.52,177.69 341.52,174.4 340.23,173.1 340.23,168.19 339.13,167.1 339.13,165.34 339.89,164.59 v2(339.89,163.83)
  IN2 w0.127: v2(344.64,185.98) 344.58,185.98 342.08,188.48 340.57,188.48 340,187.91 337.31,187.91 336.74,188.48 321.64,188.48 320.19,187.04 v2(318.71,187.04)
  IN4 w0.102: v2(187.05,178.63) 187.05,178.37 187.82,177.61 190.08,177.61 190.64,178.17 195.46,178.17 195.97,177.66 198.27,177.66 198.59,177.34 206.52,177.34 207.54,178.36 211.3,178.36 212.89,179.95 236.66,179.95 241.29,184.58 247.47,184.58 248.27,185.38 249.74,185.38 250.75,186.4 256.19,186.4 257.11,185.48 264.78,185.48 264.82,185.43 268.06,185.43 268.49,185.86 270.25,185.86 270.67,186.28 272.27,186.28 274.3,188.32 277.64,188.32 278.63,189.31 294.1,189.31 298.31,185.1 315.44,185.1 316.37,186.03 317.44,186.03 318.45,187.04 v2(318.71,187.04)
  BOTTOM w0.102: RE12.1 187.05,177.89 v2(187.05,178.63) 187.25,178.82 JDOCK1.77 ; v2(339.89,163.83) 340.08,163.83 340.77,164.53 C986.1
DAI_DI: length 186
  TOP w0.102: v2(314.32,166.24) v1(313.69,166.24) ; U74.24 343.98,167.06 344.15,166.89 344.43,166.89 344.72,167.18 v2(344.72,167.47)
  IN2 w0.127: v2(308.35,180.7) 308.35,180.77 307.26,181.86 302.27,181.86 299.73,184.4 289.2,184.4 288.78,183.98 278.63,183.98 278.09,184.53 274.57,184.53 274.16,184.12 272.5,184.12 272.37,184.25 264.76,184.25 264.13,184.87 260.07,184.87 258.78,183.59 252.81,183.59 252.6,183.59 252.59,183.59 252.47,183.59 251.01,182.13 249.73,182.13 248.93,182.93 235.95,182.93 233.38,180.37 227.71,180.37 226.86,181.22 212.24,181.22 210.59,179.57 206.68,179.57 205.43,180.82 204.52,180.82 203.4,181.94 201.65,181.94 199.56,184.02 195.16,184.02 194.12,182.98 189.58,182.98 v2(189.23,182.63)
  IN3 w0.127: v2(314.32,166.24) 314.12,166.45 314.12,169.21 313.11,170.22 313.11,171.01 309.51,174.61 309.51,175.29 308.82,175.97 308.82,180.23 v2(308.35,180.7)
  IN4 w0.102: v2(333.08,167.78) 332.85,168.01 328.46,168.01 327.45,169.01 325.86,169.01 323.46,171.42 322.73,171.42 322.52,171.63 322.1,171.63 321.83,171.36 320.73,171.36 319.97,170.6 315.52,170.6 315.11,170.19 315.11,169.74 314.22,168.85 314.22,166.34 v2(314.32,166.24)
  BOTTOM w0.102: v2(344.72,167.47) 344.72,167.51 343.7,168.54 338.92,168.54 338.39,168.01 334.45,168.01 334.22,167.78 v2(333.08,167.78) ; JDOCK1.83 188.75,181.76 189.02,182.02 189.02,182.42 v2(189.23,182.63)
DAI_DO#: length 179.2
  TOP w0.102: v2(340.72,163.88) 340.98,164.13 R1097.1 ; v2(311.45,180.23) v1(312.75,181.53) 313.32,182.09 316.97,182.09 317.23,182.36 v2(329.47,182.36)
  IN2 w0.127: v2(311.45,180.23) 311.33,180.1 308.13,180.1 306.88,181.36 302.19,181.36 299.46,184.09 289.35,184.09 289,183.73 278.3,183.73 277.83,184.2 274.77,184.2 274.35,183.78 272.26,183.78 272.07,183.97 264.68,183.97 264.09,184.56 260.22,184.56 259,183.34 252.7,183.34 251.09,181.72 249.72,181.72 248.83,182.61 248.31,182.61 236.06,182.61 233.47,180.03 227.56,180.03 226.69,180.9 212.35,180.9 210.75,179.3 206.43,179.3 205.24,180.49 204.44,180.49 203.32,181.61 201.52,181.61 199.5,183.63 195.39,183.63 194.48,182.73 190.41,182.73 189.87,182.19 v2(189.62,182.19) ; v2(340.72,163.88) 339.23,165.38 338.07,165.38 337.37,166.08 333.89,166.08 v2(333.08,166.89)
  IN3 w0.127: v2(333.08,166.89) 332.01,166.89 331.58,167.32 331.58,171.21 330.83,171.96 v2(329.29,171.96)
  IN4 w0.102: v2(329.47,182.36) 329.52,182.31 329.52,175.07 329.29,174.84 v2(329.29,171.96)
  BOTTOM w0.102: JDOCK1.85 189.25,181.76 189.62,182.13 v2(189.62,182.19)
DAI_LRCK#: length 180.4
  TOP w0.102: v2(315.62,170) v1(316.4,170) ; U74.18 v2(340.98,166.89)
  IN2 w0.127: v2(311.44,180.82) 310.09,182.17 302.55,182.17 299.93,184.78 289.12,184.78 288.58,184.24 279.07,184.24 278.27,185.04 274.81,185.04 274.47,185.38 272.4,185.38 271.79,184.77 264.6,184.77 264.18,185.19 259.94,185.19 259.21,184.45 246.81,184.45 246.35,184 236.38,184 233.01,180.63 227.86,180.63 226.95,181.53 211.76,181.53 210.12,179.89 206.92,179.89 205.58,181.23 204.64,181.23 202.69,183.17 200.86,183.17 199.54,184.49 194.56,184.49 193.67,183.6 188.86,183.6 187.75,182.5 v2(187.75,182.1)
  IN3 w0.127: v2(311.44,180.82) 311.43,180.84 311.32,180.84 310.08,179.59 310.08,174.85 313.49,171.44 314.85,171.44 315.4,170.88 315.4,170.22 v2(315.62,170)
  IN4 w0.102: v2(329.8,165.39) 330.23,165.82 330.23,167.2 329.73,167.7 328.33,167.7 327.33,168.71 325.71,168.71 323.68,170.74 321.8,170.74 321.17,170.11 315.72,170.11 v2(315.62,170)
  BOTTOM w0.102: v2(340.98,166.89) 340.81,167.07 337.57,167.07 336.89,166.38 334.4,166.38 333.41,165.39 v2(329.8,165.39) ; v2(187.75,182.1) JDOCK1.79
DAT_DDC2_CRT: length 182.7
  TOP w0.102: v2(188.54,179.11) 188.64,179.01 188.64,178.33 190.06,176.91 190.54,176.91 191.85,175.6 191.85,171.78 191.45,171.37 v1(189.92,171.37) 188.7,171.37 187.76,172.31 U6.12 ; v2(55.99,203.34) 56,203.35 JBTB1.11
  IN2 w0.127: v2(188.54,179.11) 188.52,179.13 187.87,179.13 187.7,179.3 187.7,179.73 185.13,182.31 182.18,182.31 181.47,183.01 179.02,183.01 178.76,183.27 177.45,183.27 177.33,183.15 173.62,183.15 172.98,182.51 172.98,181.88 172.72,181.62 171.75,181.62 170.77,180.64 170.26,180.64 168.91,179.28 168.91,177.24 163.9,172.24 158.28,172.24 157.44,171.4 154.59,171.4 154.11,170.92 149.9,170.92 149.07,170.09 148.11,169.13 143.87,169.13 143.66,168.92 137.22,168.92 135.52,167.22 120.29,167.22 119.49,168.02 107.23,168.02 106.52,167.31 101.83,167.31 100.87,166.34 92.61,166.34 90.04,168.92 90.04,169.53 89.73,169.84 88.9,169.84 86.95,171.78 86.46,171.78 81.97,176.28 73.19,176.28 66.08,183.39 63.63,183.39 61.26,185.76 61.26,199.47 58.28,202.45 56.88,202.45 v2(55.99,203.34)
DAT_DDC2_DOCK: length 29.6
  TOP w0.102: v2(177.96,187.58) 178.01,187.63 178.01,187.77 178.32,188.07 178.93,188.07 181.63,185.37 181.63,182.31 183.52,180.42 186.28,180.42 186.99,179.7 187.27,179.7 188.18,178.79 188.18,178.28 189.95,176.52 190.43,176.52 191.5,175.45 191.5,173.96 191.27,173.73 v1(190.76,173.23) 190.57,173.03 190.57,172.5 189.96,171.89 188.72,171.89 187.9,172.71 U6.13
  BOTTOM w0.102: v2(177.96,187.58) 177.96,187.68 178.25,187.97 JDOCK1.46
DAT_KBD: length 184.5
  TOP w0.102: v2(187.75,190.13) v1(187.75,189.39) 187.75,187.28 188.63,186.4 192.49,186.4 193.62,185.27 193.62,182.88 194.1,182.4 v2(194.1,182.24) ; U51.B41 283.39,114.91 283.56,115.09 v2(283.64,115.09) ; v2(276.27,113.44) 276.22,113.44 275.8,113.86 275.8,114.16 276.05,114.41 276.66,114.41 R846.2
  IN3 w0.127: v2(194.1,182.24) 194.28,182.24 195.35,181.18 205.71,181.18 207.17,179.72 210.26,179.72 212.92,182.38 215.45,182.38 221.37,188.3 238.96,188.3 240.05,187.21 248.42,187.21 248.65,186.98 251.99,186.98 252.51,187.51 260.05,187.51 261.49,186.07 264.41,186.07 272.61,177.87 272.61,176.8 273.33,176.08 273.33,174.61 272.66,173.95 272.66,171.36 272.19,170.89 272.19,165.96 271.65,165.42 271.65,149.77 271.65,149.56 271.65,149.53 273.73,147.45 273.73,147.15 276.5,144.38 276.5,132.89 275.71,132.11 275.71,121.31 276.88,120.14 276.88,115.82 276.27,115.21 v2(276.27,113.44) 276.61,113.09 277.95,113.09 279.8,111.24 281.44,111.24 282.6,112.4 282.6,114.17 283.52,115.09 v2(283.64,115.09)
  BOTTOM w0.102: v2(187.75,190.13) JDOCK1.80
DAT_MSE: length 183.6
  TOP w0.102: v2(276.27,112.84) 275.57,113.54 275.57,114.26 275.95,114.64 276.46,114.64 R852.2 ; U51.B42 283.27,114.41 283.35,114.49 283.81,114.49 284.26,114.04 v2(284.26,113.99)
  IN3 w0.127: v2(284.26,113.99) 284.26,113.86 283.87,113.46 283.36,113.46 282.86,112.97 282.86,112.31 281.54,110.99 279.7,110.99 278.49,112.19 276.92,112.19 v2(276.27,112.84) 275.84,113.27 275.84,116.91 275.83,116.92 275.83,117.27 275.84,117.28 275.84,120.52 275.46,120.9 275.46,132.23 276.25,133.02 276.25,144.28 273.48,147.05 273.48,147.34 271.36,149.46 271.36,165.48 271.94,166.07 271.94,171.04 272.41,171.51 272.41,174.05 273.07,174.71 273.07,175.98 272.36,176.69 272.36,177.76 264.31,185.81 261.38,185.81 259.95,187.25 258.58,187.25 257.93,186.6 256.93,186.6 256.57,186.96 252.66,186.96 252.43,186.73 248.54,186.73 248.31,186.96 239.95,186.96 238.86,188.05 222.91,188.05 216.52,181.66 213.09,181.66 210.59,179.16 207.01,179.16 205.54,180.63 196.05,180.63 195.68,180.26 193.24,180.26 192.58,179.6 191.13,179.6 190.62,180.11 187.99,180.11 186.9,179.02 186.52,179.02 186.46,178.96 v2(185.87,178.96)
  BOTTOM w0.102: v2(185.87,178.96) 185.87,179.3 186.25,179.68 JDOCK1.73 ; v2(284.26,113.99) v1(284.26,113.46)
DAT_TP_SIO: length 62.8
  TOP w0.102: v2(280.34,99.1) 280.11,99.1 279.32,99.9 276.79,99.9 274.63,97.74 v4(273.85,97.74) 271.14,97.74 270.96,97.92 269.64,97.92 R903.2 269.1,97.78 268.97,97.9 268.28,97.9 268.08,97.7 C752.1 267.86,97.59 267.86,97.9 267.78,97.99 267.24,97.99 267.1,97.85 R1163.1 ; v2(284.29,115.09) 284.29,115.13 283.92,115.49 283.35,115.49 283.26,115.41 U51.B40
  IN1 w0.102: v2(284.29,115.09) 284.29,115 284.96,114.33 284.96,113.77 285.39,113.33 289.61,113.33 290.41,114.13 292.36,114.13 293.28,115.05 294.66,115.05 295.51,114.2 295.51,113.84 298.28,111.07 298.28,105.94 297.36,105.02 295.56,105.02 294.95,104.41 291.41,104.41 291.27,104.27 290.85,104.27 v2(290.44,104.67)
  BOTTOM w0.102: v2(290.44,104.67) 290.41,104.64 290.41,104.36 288.63,102.58 285.75,102.58 283.05,99.89 281.99,99.89 280.87,98.77 280.67,98.77 v2(280.34,99.1)
DBG_CNTL0: length 9.1
  BOTTOM w0.102: T115.1 241.28,142.76 239.38,142.76 237.63,141.01 235.36,141.01 235.12,141.26 235.12,141.39 234.79,141.73 234.15,141.73 234.02,141.6 UV1.AP8
DBG_DATA3: length 6.4
  BOTTOM w0.102: UV1.AP6 234.15,143.2 234.52,143.57 236.75,143.57 237.63,144.44 237.63,144.45 238.07,144.89 238.08,144.89 238.23,145.05 T91.1
DBG_DATA4: length 9.4
  BOTTOM w0.102: T92.1 243.95,145.43 238.23,145.43 236.7,143.9 UV1.AW5
DBG_DATA5: length 8.8
  BOTTOM w0.102: UV1.AU5 235.92,144.36 236.54,144.36 237.85,145.68 242.93,145.68 T93.1
DBG_DATA6: length 7.1
  BOTTOM w0.102: T94.1 240.52,144.67 238.17,144.67 236.84,143.34 235,143.34 234.66,143 UV1.AR6
DBG_DATA7: length 7.1
  BOTTOM w0.102: UV1.AW6 236.79,143 237.69,143.9 237.85,143.9 238.36,144.41 242.04,144.41 T95.1
DBG_DATA8: length 9.6
  BOTTOM w0.102: T96.1 243.19,144.16 238.49,144.16 237.35,143.01 237.09,143.01 236.71,142.63 236.08,142.63 235.71,143 UV1.AU6
DBG_DATA9: length 7.3
  BOTTOM w0.102: T97.1 240.39,143.01 238.23,143.01 237.85,142.63 237.85,142 237.36,141.5 236.61,141.5 236.25,141.87 235.71,141.87 235.38,142.2 UV1.AT7
DBG_DATA10: length 4.9
  BOTTOM w0.102: T98.1 238.36,143.52 237.65,142.81 237.65,142.18 237.3,141.83 236.67,141.83 236.3,142.2 UV1.AV7
DBG_DATA11: length 2.2
  TOP w0.102: v2(234.45,142.14) 234.46,142.13 T99.1
  BOTTOM w0.102: UV1.AN7 233.05,142.28 233.24,142.09 234.4,142.09 v2(234.45,142.14)
DBG_DATA12: length 5.2
  BOTTOM w0.102: T100.1 239.33,142.38 237.54,140.6 UV1.AV9
DBG_DATA13: length 5
  BOTTOM w0.102: T101.1 238.51,141.24 237.6,140.33 236.05,140.33 235.99,140.27 235.4,140.27 235.07,140.6 UV1.AT9
DBG_DATA14: length 1.2
  TOP w0.102: v2(235.08,139.49) 235.19,139.6 T102.1
  BOTTOM w0.102: UV1.AR10 234.77,139.8 v2(235.08,139.49)
DBG_DATA15: length 3.4
  BOTTOM w0.102: UV1.AW10 237.81,139.8 238.04,140.03 239.31,140.03 T103.1
DBG_DATA16: length 6
  BOTTOM w0.102: UV1.AU10 235.82,139.8 236.12,140.1 237.73,140.1 238.49,140.86 240.52,140.86 T104.1
DBG_DATA17: length 1.6
  TOP w0.102: v2(234.5,140.39) 234.01,140.39 T105.1
  BOTTOM w0.102: v2(234.5,140.39) 234.11,140 UV1.AP10
DBG_DATA18: length 5.9
  BOTTOM w0.102: UV1.AV11 237.81,139 237.85,138.95 241.41,138.95 T106.1
DBG_DATA19: length 6.2
  BOTTOM w0.102: UV1.AT11 235.4,139 235.7,139.3 238.52,139.3 238.6,139.22 240.2,139.22 T107.1
DBG_DATA20: length 5.9
  BOTTOM w0.102: T108.1 239.31,136.47 237.83,136.47 236.88,137.43 236.35,137.43 235.99,137.07 235.71,137.07 235.52,137.26 235.52,137.53 235.24,137.81 235.06,137.81 234.67,138.2 UV1.AR12
DBG_DATA21: length 5.8
  BOTTOM w0.102: UV1.AW12 240.57,138.2 241.47,137.3 T112.1
DBG_DATA22: length 6
  BOTTOM w0.102: UV1.AU12 235.69,138.2 236.2,137.68 237.85,137.68 238.36,137.17 239.94,137.17 T113.1
DBG_DATA23: length 6.6
  BOTTOM w0.102: UV1.AP12 234.12,138.4 234.3,138.57 T114.1
DBG_VREFG: length 22.1
  IN2 w0.102: v2(229.99,137.2) 229.99,137.29 230.87,138.16 237.12,138.16 237.85,137.43
  IN2 w0.127: v2(245.42,138.34) 245.3,138.47 240.7,138.47 239.34,137.11 238.17,137.11 237.85,137.43
  BOTTOM w0.102: v2(245.42,138.34) 245.96,137.81 CV115.1 RV68.2 RV66.1 v1(246.03,141.17)
  BOTTOM w0.254: UV1.AH13 229.1,137.15 229.94,137.15 v2(229.99,137.2)
DC_BLOCK_GC: length 3.1
  TOP w0.254: PU800.7 152.75,164.08 154.21,162.61 PR700.2
DC_IN_SS: length 3.1
  TOP w0.254: PU800.34 148.09,166.53 147.95,166.38 v1(147.42,166.38) 147.11,166.38 146.77,166.73 PR831.2
DDBIA0_0: length 27.6
  TOP w0.102: 207.12,116.28 207.77,116.93 207.77,118.17 207.44,118.5 v2(207.44,119.52)
  TOP w0.13: UV5.P13 189.07,115.52 189.07,114.36 189.62,113.82 190.18,113.82 191.36,112.64 195.73,112.64 196.07,112.98 v1(198.36,112.98) 200.36,112.98 200.45,112.89 201.59,112.89 202.7,114 203.65,114 204.26,114.6 204.92,114.6 205.46,115.14 205.98,115.14 207.12,116.28
  BOTTOM w0.102: UV1.A34 208.03,120.6 207.44,120 v2(207.44,119.52)
DDBIA0_1: length 25.9
  BOTTOM w0.102: 207.12,123.45 207.5,123.45 207.78,123.73 208.15,123.73 208.52,124.1 208.78,124.1 208.86,124.02 209.24,124.02 209.32,124.1 209.95,124.1 UV1.E30 ; 201.28,123.25 201.14,123.25 200.84,123.56 200.84,125.34 200.06,126.12 199.34,126.12 198.96,126.49 189.39,126.49 189.02,126.12 189.02,125.12 UV4.D2
  BOTTOM w0.13: 201.28,123.25 201.28,123.25 205.03,123.25 205.23,123.45 v1(205.63,123.45) 207.12,123.45
DDBIA0_2: length 24.7
  IN1 w0.127: v2(197.85,116.29) 198.26,115.89 198.26,115.19 198.76,114.68 200.67,114.68 204.15,118.16 204.15,119.06 204.69,119.61 205.61,119.61 206.26,120.26 206.26,122.18 206.38,122.31 206.38,125.66 206.26,125.78 v2(206.26,127.23)
  BOTTOM w0.102: UV4.P13 v2(197.85,116.29) ; UV1.E26 209.88,127 209.58,127.3 209.31,127.3 209.23,127.21 208.87,127.21 208.78,127.3 207.85,127.3 207.34,127.81 206.65,127.81 206.26,127.42 v2(206.26,127.23)
DDBIA0_3: length 16.9
  TOP w0.102: v2(197.85,124.3) UV5.D2
  IN4 w0.127: v2(207.86,130.63) 207.86,130.5 207.41,130.05 201.34,130.05 198.26,126.97 198.26,124.7 v2(197.85,124.3)
  BOTTOM w0.102: v2(207.86,130.63) 207.86,131.08 208.05,131.28 208.58,131.28 208.81,131.5 209.16,131.5 UV1.C20
DDBIA1_0: length 17.8
  IN1 w0.127: v2(207.8,135.38) 207.39,134.97 206.94,134.97 206.34,135.57 202.33,135.57 200.19,133.43 197.56,133.43 196.66,134.33 196.66,135.46 196.89,135.69 197.46,135.69 v2(197.85,135.29)
  BOTTOM w0.102: v2(197.85,135.29) UV6.D2 ; UV1.C16 209.22,135.23 208.86,135.23 208.79,135.3 208.13,135.3 208.05,135.38 v2(207.8,135.38)
DDBIA1_1: length 18.9
  TOP w0.102: UV3.P13 v2(197.85,143.3)
  IN4 w0.102: v2(207.39,138.28) 207.35,138.32 207.35,138.98 207.67,139.29 207.67,140.64 207.22,141.09 207.12,141.09
  IN4 w0.127: 207.12,141.09 206.59,141.09 205.87,141.81 201.35,141.81 200.52,140.97 198.66,140.97 198.26,141.38 198.26,142.89 v2(197.85,143.3)
  BOTTOM w0.102: UV1.C12 209.69,138.2 209.75,138.26 209.75,138.38 209.58,138.55 209.33,138.55 209.18,138.4 208.91,138.4 208.8,138.51 208.53,138.51 208.35,138.32 208.35,138.31 208.34,138.3 208.34,138.29 208.21,138.15 208.2,138.15 208.12,138.06 208.1,138.06 208.1,138.06 207.6,138.06 v2(207.39,138.28)
DDBIA1_2: length 30.7
  TOP w0.102: 207.17,137.16 208.7,137.16 208.83,137.29 208.83,137.99 209.63,138.79 209.63,138.94 209.88,139.18 211.17,139.18 211.19,139.19 212.63,139.19 v2(213.05,139.61)
  TOP w0.13: UV3.D2 189.09,134.54 189.09,133.39 189.74,132.74 194.31,132.74 194.72,133.16 199.91,133.16 201.11,134.37 201.11,135.5 202.78,137.16 207.17,137.16
  BOTTOM w0.102: v2(213.05,139.61) 213.45,139.21 UV1.J11
DDBIA1_3: length 25
  BOTTOM w0.102: UV1.F8 210.61,141.6 210.46,141.74 209.32,141.74 209.26,141.69 208.84,141.69 208.83,141.7 208.05,141.7 207.53,142.23 207.53,142.52 207.3,142.75 207.12,142.75
  BOTTOM w0.13: UV6.P13 189.91,144.16 189.91,145.16 190.51,145.75 200.67,145.75 v1(201.95,144.48) 203.18,143.25 205.74,143.25 206.13,142.86 206.69,142.86 206.8,142.75 207.12,142.75
DDBIB0_0: length 27.7
  TOP w0.102: 203.82,154.57 204.5,155.25 204.5,155.69 204.3,155.88 204.3,156.96 204.04,157.22 203.78,157.22 203.56,157.01 203.56,156.86 203.21,156.5 202.7,156.5 202.31,156.89 UV7.P13 ; 213.98,147.21 213.98,144.08 213.22,143.32 212.91,143.32 212.42,142.83 v2(212.22,142.83)
  TOP w0.13: 213.98,147.21 v1(213.98,148.35) 213.98,149.21 213.46,149.73 211.94,149.73 211.24,150.43 210.17,150.43 210.06,150.54 204.54,150.54 203.82,151.27 203.82,154.57
  BOTTOM w0.102: v2(212.22,142.83) 211.85,142.45 UV1.G7
DDBIB0_1: length 35.1
  BOTTOM w0.102: UV1.K1 214.18,145.86 214.18,146.52 214.08,146.62 214.08,147.21 ; 199.25,160.42 198.98,160.7 198.98,165.3 199.69,166.02 200.84,166.02 201.09,165.78 201.09,165.66 201.38,165.37 201.99,165.37 UV8.D2
  BOTTOM w0.13: 214.08,147.21 214.08,149.18 v1(211.65,151.61) 209.39,153.87 206.14,153.87 204.94,155.07 199.82,155.07 199.25,155.63 199.25,160.42
DDBIB0_2: length 16
  IN1 w0.102: v2(217.62,146.81) 217.47,146.96 217.47,147.21
  IN1 w0.127: 217.47,147.21 217.47,150.11 212.75,154.83 212.26,154.83 211.9,155.18 211.9,156.71 211.72,156.9 211.11,156.9 v2(210.71,157.29)
  BOTTOM w0.102: UV1.P1 217.65,145.64 217.33,145.96 217.33,146.52 v2(217.62,146.81) ; UV8.P13 v2(210.71,157.29)
DDBIB0_3: length 27.4
  TOP w0.102: UV7.D2 v2(210.71,165.3)
  IN4 w0.102: v2(210.71,165.3) 210.86,165.3 211.26,164.9 211.68,164.9 211.9,164.68 211.9,164.33 212.11,164.11 212.45,164.11 212.71,163.85 212.71,162.93 213.72,161.92 ; v2(221.97,144.82) 221.89,144.89 220.86,144.89 220.68,145.07 220.68,146.14 220.16,146.66 220.16,147.21
  IN4 w0.127: 213.72,161.92 215.69,159.95 215.69,155.03 216.11,154.61 216.11,153.03 217.1,152.04 217.1,151.3 219.23,149.17 219.23,148.46 220.16,147.54 220.16,147.21
  BOTTOM w0.102: UV1.W4 221.97,144.71 v2(221.97,144.82)
DDBIB1_0: length 33.7
  BOTTOM w0.102: UV10.D2 223.31,166 222.91,166.41 222.91,167.13 222.64,167.4 ; UV1.AC4 224.57,144.4 224.36,144.6 224.36,144.91 224.3,144.97 224.3,145.42 224.35,145.47 224.35,145.75 224.72,146.11 224.72,146.85 224.54,147.03 224.54,147.21
  BOTTOM w0.13: 222.64,167.4 220.38,167.4 217.24,164.26 217.24,155.46 220.21,152.49 v1(220.84,152.49) 222.7,152.49 223.04,152.15 223.04,151.66 223.88,150.81 223.88,149.79 224.54,149.13 224.54,147.21
DDBIB1_1: length 15.7
  TOP w0.102: UV9.P13 222.91,156.49 222.91,155.21 223.54,154.57 ; 227.44,147.21 227.57,147.08 227.57,146.42 227.76,146.23 228.22,146.23 229.04,145.41 229.04,145.12 v2(229.33,144.83)
  TOP w0.13: 223.54,154.57 223.96,154.15 223.96,150.68 227.44,147.21
  BOTTOM w0.102: v2(229.33,144.83) 229.3,144.8 UV1.AH3
DDBIB1_2: length 34.7
  TOP w0.102: v2(230.19,141.87) 230.19,142.1 v1(229.94,142.35) ; v2(231.71,166.08) 231.71,166.06 231.68,166.06 UV9.D2
  IN4 w0.102: 235.05,164.16 234.32,164.88 233.98,164.88 233.73,165.14 233.73,165.42 233.43,165.71 232.35,165.71 232,166.06 231.72,166.06 v2(231.71,166.08) ; v2(230.19,141.87) 230.49,141.58 230.91,141.58 231.7,140.79 233.62,140.79 234.17,141.35 234.2,141.35 235.9,143.05 235.9,147.21
  IN4 w0.127: 235.05,164.16 235.05,155.46 235.9,154.61 235.9,147.21
  BOTTOM w0.102: UV1.AJ8 229.92,141.6 v2(230.19,141.87)
DDBIB1_3: length 13
  IN1 w0.102: 231.76,154.91 231.36,155.31 231.36,156.16 v2(231.69,156.49)
  IN1 w0.127: v2(231.95,146.88) 231.95,147.61 231.76,147.8 231.76,154.91
  BOTTOM w0.102: v2(231.69,156.49) 231.69,156.51 UV10.P13 ; UV1.AM3 232.05,144.97 232.49,145.41 232.49,146.33 v2(231.95,146.88)
DDR3_DRAMRST#_CPU: length 75.1
  TOP w0.089: v2(139.73,80.92) 140.14,81.33 140.9,81.33 141.33,80.9 141.33,78.17 140.85,77.69 137.79,77.69 137.46,77.36
  TOP w0.102: 137.46,77.36 134.35,74.24 134.35,69.41 v1(132.6,67.66) 132.56,67.66 130.26,65.35 130.26,39.53 133.5,36.29 RD24.1 133.47,18.35 RD4.2 132.38,18.59 QD9.3
  BOTTOM w0.089: JCPU1.AN3 140.2,81.39 v2(139.73,80.92)
DDR3_DRAMRST#_Q: length 7.4
  TOP w0.102: RD2.2 133.49,17.44 RD4.1 132.11,17.94 QD9.1 129.55,19.26 RD25.1 129.95,20.19 v1(130.51,20.75)
DDR3_DRAMRST#_R: length 17.2
  TOP w0.102: RD25.2 131.3,19.66 v2(131.6,19.35) v1(131.6,26.1) 131.6,31.72 131.14,32.18 v2(131.14,32.35)
  BOTTOM w0.102: v2(131.14,32.35) 131.6,31.89 JDIMM1.30 ; JDIMM2.30 v2(131.6,19.35)
DDR_A_BS0: length 68.8
  IN4 w0.089: 157.15,77.36 157.15,82.17 157.01,82.32 156.44,82.32 155.93,82.84 155.93,83.67 v2(155.73,83.86)
  IN4 w0.165: 157.15,77.36 157.15,76.74 157.26,76.64 157.51,76.64 157.61,76.54 157.61,76.08 157.51,75.98 157.26,75.98 157.15,75.88 157.15,75.42 157.26,75.32 157.51,75.32 157.61,75.22 157.61,74.76 157.51,74.66 157.26,74.66 157.15,74.56 157.15,74.1 157.26,74 157.51,74 157.61,73.9 157.61,73.48 157.51,73.38 157.27,73.38 157.17,73.27 157.17,69.98 157.27,69.88 157.51,69.88 157.61,69.78 157.61,69.39 157.51,69.29 157.25,69.29 157.15,69.19 157.15,68.81 157.25,68.71 157.51,68.71 157.61,68.61 157.61,68.24 157.49,68.11 156.87,68.11 156.75,67.98 156.75,67.64 156.85,67.54 157.51,67.54 157.61,67.44 157.61,67.04 157.51,66.94 156.85,66.94 156.75,66.84 156.75,66.14 156.87,66.02 157.1,66.02 157.23,65.89 157.23,65.48 157.1,65.36 156.87,65.36 156.75,65.23 156.75,64.82 156.87,64.7 157.1,64.7 157.23,64.57 157.23,64.16 157.1,64.04 156.87,64.04 156.75,63.91 156.75,63.58 156.87,63.45 157.48,63.45 157.61,63.32 157.61,60.26 157.78,60.1 157.98,60.1 158.09,59.99 158.09,59.54 157.98,59.44 157.71,59.44 157.61,59.33 157.61,58.88 157.71,58.78 158.37,58.78 158.47,58.67 158.47,58.22 158.37,58.11 157.71,58.11 157.61,58.01 157.61,57.56 157.71,57.45 158.37,57.45 158.47,57.35 158.47,56.9 158.37,56.79 157.71,56.79 157.61,56.69 157.61,56.24 157.71,56.13 158.37,56.13 158.47,56.03 158.47,55.57 158.37,55.47 157.71,55.47 157.61,55.37 157.61,55 157.71,54.9 158.37,54.9 158.47,54.8 158.47,54.42 158.37,54.32 157.71,54.32 157.61,54.22 157.61,53.83 157.71,53.72 158.33,53.72 158.44,53.62 158.44,53.23 158.33,53.12 157.71,53.12 157.61,53.02 157.61,52.2 157.71,52.1 157.86,52.1 157.96,51.99 157.96,51.47 157.86,51.37 157.71,51.37 157.61,51.27 157.61,50.81 157.71,50.71 157.86,50.71 157.96,50.61 157.96,50.15 157.86,50.05 157.71,50.05 157.61,49.95 157.61,49.53 157.71,49.43 157.86,49.43 157.96,49.33 157.96,48.79 157.86,48.68 157.71,48.68 157.61,48.58 157.61,48.14 157.71,48.04 157.86,48.04 157.96,47.93 157.96,47.49 157.86,47.39 157.71,47.39 157.61,47.29 157.61,46.79 157.71,46.69 157.86,46.69 157.96,46.59 157.96,46.21 157.86,46.11 157.71,46.11 157.61,46 157.61,45.5 157.71,45.4 157.86,45.4 157.96,45.3 157.96,44.9 157.86,44.8 157.35,44.8 157.24,44.69 157.24,43.38 157.37,43.26 157.55,43.26 157.68,43.38 v2(157.68,43.6)
  BOTTOM w0.089: JCPU1.V5 155.32,83.45 v2(155.73,83.86)
  BOTTOM w0.165: JDIMM1.109 157.7,40.5 157.84,40.64 158.29,40.64 158.4,40.76 158.4,41.26 158.16,41.5 158.16,42.96 158.38,43.18 158.66,43.18 158.76,43.28 158.76,44.16 158.66,44.26 158.21,44.26 157.68,43.73 v2(157.68,43.6)
DDR_A_BS1: length 71.2
  IN4 w0.089: 158.6,77.36 158.6,78.51 158.32,78.79 158.32,83.26 158.25,83.33 156.58,83.33 156.5,83.25 156.5,83.05 156.63,82.92 v2(156.73,82.92)
  IN4 w0.165: 158.6,77.36 158.6,73.07 158.22,72.69 158.22,70.57 158.6,70.19 158.6,66.63 158.22,66.25 158.22,64.13 158.6,63.75 158.6,62.39 158.76,62.23 159.05,62.23 159.46,61.82 159.46,52.85 158.95,52.34 158.95,44.49 158.67,44.21 158.67,42.67 158.76,42.58 158.76,41.68 158.95,41.49 158.95,40.25 158.85,40.15 158.5,40.15 158.39,40.05 158.39,39.38 158.5,39.28 158.96,39.28 159.4,38.84 159.4,36.49 159.3,36.38 158.42,36.38 158.32,36.28 158.32,35.7 158.42,35.6 159.3,35.6 159.4,35.5 159.4,34.93 159.3,34.82 159.06,34.82 158.96,34.72 158.96,34.27 159.06,34.16 159.3,34.16 159.4,34.06 159.4,33.6 159.3,33.5 159.05,33.5 158.95,33.4 158.95,32.94 159.05,32.84 159.3,32.84 159.4,32.74 159.4,31.95 159.3,31.85 157.91,31.85 157.81,31.95 157.81,32.49 157.91,32.59 158.16,32.59 158.27,32.7 158.27,34.96 158.17,35.06 157.88,35.06 157.78,35.17 v2(157.78,35.4)
  BOTTOM w0.089: v2(156.73,82.92) JCPU1.U5
  BOTTOM w0.165: v2(157.78,35.4) 157.21,34.83 157.21,32.27 157.4,32.08 JDIMM1.108
