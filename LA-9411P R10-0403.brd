# Allegro board LA-9411P R10-0403.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
BCM5882_ALERT#: length 77.8
  TOP w0.102: U46.B62 269.19,48.5 v2(268.91,48.79) ; v2(261.56,88.06) 261.18,87.68 261.18,83.27 261.89,82.57 JUSH1.14 ; v2(272.4,87.77) v1(271.51,87.77)
  IN1 w0.102: v2(276.6,58.81) 276.36,58.57 276.36,46.08 v2(276.27,45.99)
  IN2 w0.127: v2(272.4,87.77) 272.35,87.72 271.48,87.72 271.31,87.9 268.13,87.9 265.63,90.4 265.07,90.4 262.73,88.06 v2(261.56,88.06)
  IN3 w0.127: v2(268.91,48.79) 268.91,47.82 269.21,47.51 270.99,47.51 272.58,45.92 274.34,45.92 274.71,45.55 275.84,45.55 v2(276.27,45.99)
  IN4 w0.102: v2(276.6,58.81) 276.6,58.81 276.1,58.31 275.48,58.31 274.95,58.84 274.95,63.71 274.12,64.54 274.12,74.24 271.74,76.62 271.74,87.24 272.27,87.77 v2(272.4,87.77)
BEEP: length 96.8
  TOP w0.102: U51.B19 290.97,118.24 290.76,118.03 v2(290.76,117.86) ; R1120.2 335.16,167.6 v2(336.25,167.6)
  IN2 w0.127: v2(325.97,157.91) 325.23,158.65 325.23,166.76 323.55,168.44 323.55,169.38 323.35,169.58 323.35,171.58 v2(322.93,172)
  IN3 w0.127: v2(290.76,117.86) 290.79,117.86 291.27,117.37 291.93,117.37 292.44,116.87 296.03,116.87 296.78,117.61 296.78,118.34 298.04,119.6 300.16,119.6 308.58,128.02 309.91,128.02 317.41,135.52 318.03,135.52 318.59,136.08 318.59,140.09 322.56,144.07 322.56,144.56 323.63,145.62 323.63,151.36 323.87,151.6 323.87,152.86 324.42,153.4 324.42,156.39 325.94,157.91 v2(325.97,157.91)
  BOTTOM w0.102: v2(322.93,172) 324.28,170.65 v1(325.1,170.65) 329.2,170.65 329.58,171.03 329.92,171.03 330.3,170.65 330.3,170.61 332.19,168.72 332.19,166.66 332.8,166.05 333.43,166.05 334.98,167.6 v2(336.25,167.6)
BIA_PWM_CVT: length 33
  TOP w0.102: v2(185.2,152.92) 185.2,153.59 184.73,154.06 D66.2 ; v2(176.39,133.36) 176.02,133.73 176.02,134.39 175.82,134.58 U27.19
  IN1 w0.102: v2(186.2,137.29) 186.2,136.42 184.55,134.77 183.24,134.77 182.56,134.09 178.51,134.09 177.9,133.48 176.5,133.48 v2(176.39,133.36)
  IN4 w0.102: v2(185.2,152.92) 185.03,152.76 185.03,151.09 186,150.13 186,137.49 v2(186.2,137.29)
  BOTTOM w0.102: v2(185.2,152.92) v1(185.91,152.92)
BIA_PWM_EC: length 213.4
  TOP w0.102: U51.B25 287.97,118.19 287.94,118.17 287.94,117.45 v2(287.52,117.03) ; D68.2 183.84,156.21 v2(183.07,156.98)
  IN3 w0.127: v2(287.52,117.03) 287.28,117.03 286.79,116.53 286.34,116.53 286.23,116.42 284.73,116.42 283.82,115.51 282.66,115.51 282.09,116.08 280.4,116.08 279.62,116.85 279.62,120.85 278.75,121.73 277.73,121.73 277.07,121.07 276.38,121.07 275.97,121.48 275.97,128.87 276.97,129.87 276.97,133.68 276.75,133.89 276.75,144.49 273.99,147.26 273.99,147.58 271.9,149.66 271.9,163.94 273.76,165.8 273.76,167.71 273.19,168.28 273.19,171.32 272.92,171.59 272.92,173.84 273.58,174.5 273.58,176.19 272.87,176.9 272.87,177.97 264.52,186.32 261.6,186.32 260.12,187.79 252.92,187.79 252.15,188.56 248.92,188.56 247.82,187.46 240.16,187.46 239.04,188.58 221.29,188.58 216.79,184.08 213.3,184.08 211.55,182.33 207.6,182.33 207.09,181.82 206.9,181.82 206.51,181.43 197.06,181.43 195.81,182.68 193.92,182.68 193.2,181.96 191.11,181.96 190.33,181.18 186.97,181.18 186.15,180.37 185.75,180.37 181.98,180.37 181.12,179.51 179.12,179.51 178.18,178.57 v2(177.72,178.57)
  IN4 w0.102: v2(177.72,178.57) 177.78,178.57 180.37,175.98 180.55,175.98 181.19,175.35 181.19,171.2 180.54,170.55 180.54,169.95 182.08,168.41 182.08,164.93 181.49,164.35 181.49,161.59 184.08,159 184.08,158.2 183.07,157.19 v2(183.07,156.98)
  BOTTOM w0.102: v2(287.52,117.03) 287.64,117.03 v1(287.97,116.7)
BIA_PWM_LVDS: length 6.5
  TOP w0.102: R1137.1 v1(178.59,153.78)
  TOP w0.508: R1137.1 180.78,155.08 v2(180.79,155.07) 181.57,155.84 D68.1 D66.1
  BOTTOM w0.508: RE32.2 180.58,154.85 v2(180.79,155.07)
BIA_PWM_PCH: length 103.8
  TOP w0.102: R109.1 174.68,126.68 v1(174.33,127.04) v2(173.78,127.58)
  IN3 w0.089: 217.35,81.1 216.54,80.29 216.54,75.25 214.91,73.61 214.91,72.87 v2(215.02,72.76)
  IN3 w0.127: 217.35,81.1 217.91,81.66 217.91,83.74 215.8,85.85 214.24,85.85 213.6,86.5 213.6,88.81 213.11,89.29 212.58,89.29 212.2,88.91 204.91,88.91 203.18,87.18 203.18,86.35 200.41,83.58 197.47,83.58 196.71,84.34 183.65,84.34 176.13,91.86 176.13,92.07 176.13,99.28 173.92,101.49 173.92,113.19 173.63,113.49 173.63,127.43 v2(173.78,127.58)
  BOTTOM w0.089: v2(215.02,72.76) 214.81,72.96 UH1.N36
BIA_PWM_PCH_R: length 9
  TOP w0.102: U27.21 176.62,134.1 177.24,133.49 v1(177.24,133.39) 177.24,129.9 176.64,129.3 R114.2 R109.2
BITCLK_TERM: length 2.5
  BOTTOM w0.102: v1(249.47,134.18) 249.84,134.54 R753.1 C677.1
BLUE_CRT: length 172.2
  TOP w0.102: v2(55.23,202.7) 55,202.93 JBTB1.15 ; U6.22 184.26,175.15 184.23,175.17 184.23,175.86 184.62,176.24 185.12,176.24 185.31,176.43 185.31,177.52 v2(185.43,177.63)
  IN2 w0.127: v2(185.43,177.63) 185.16,177.63 183.75,179.04 183.75,179.76 183.54,179.97 180.86,179.97 180.74,179.86 179.6,179.86 177.39,177.65 172.13,177.65 167.93,173.44 167.93,173.09 165.9,171.06 165.9,170.76 165.55,170.42 160.63,170.42 160.35,170.14 159.05,170.14 157.1,168.2 150.4,168.2 149.21,167.01 149.21,165.59 147.33,163.72 145.94,163.72 138.12,163.72 136.39,165.44 119.29,165.44 118.74,165.99 108.53,165.99 106.27,163.73 102.21,163.73 101.66,164.27 100.53,164.27 100.25,164.55 94.17,164.55 93.56,163.93 92.25,163.93 86.18,170 85.64,170 81.15,174.5 72.12,174.5 65,181.61 62.89,181.61 59.29,185.21 59.29,197.37 55.23,201.43 v2(55.23,202.7)
  BOTTOM w0.102: v2(55.23,202.7) v1(55.23,202.07)
BLUE_DOCK: length 10.9
  TOP w0.102: U6.21 184.66,175.66 v2(184.64,175.68)
  IN1 w0.102: v2(178.34,179.54) 179.87,179.54 180.83,178.58 180.83,177.62 182.01,176.44 184.17,176.44 184.64,175.97 v2(184.64,175.68)
  BOTTOM w0.102: JDOCK1.45 178.25,179.7 178.34,179.6 v2(178.34,179.54)
BOARD_ID: length 15.8
  TOP w0.102: v1(300.29,117.61) R875.2 C744.1 v2(300.94,115.33) ; U51.B10 291.83,114.41 291.52,114.11 291.17,114.11 v2(290.72,114.56)
  IN3 w0.127: v2(300.94,115.33) 298.67,115.33 297.34,113.99 296.07,113.99 295.94,113.87 293.23,113.87 292.97,114.12 291.03,114.12 290.72,114.43 v2(290.72,114.56)
BOOT1: length 3.2
  BOTTOM w0.102: PR550.2 125.14,155.8 125.56,156.22 127.38,156.22 v1(127.69,156.54)
BOOT1_1_VGA: length 1.6
  BOTTOM w0.102: PR649.1 303.7,156.98 v1(303.86,156.83)
BOOT1_VGA:
  vias: v1(307.07,158.89)
BOOT2:
  vias: v1(121.03,151.17)
BOOT2_2_VGA: length 1.6
  BOTTOM w0.102: v1(303.42,166.57) 303.2,166.34 PR614.1
BOOT2_VGA:
  vias: v1(306.05,165.87)
BOOT3:
  vias: v1(162.26,154.8)
BOOT_1.35V: length 2.9
  TOP w0.102: PR200.2 205.89,13.2 204.2,13.2 v1(203.97,13.42)
BQ24715_REGN: length 52.9
  TOP w0.254: PR741.1 80.88,182.3 v4(80.36,182.82) ; PR735.1 103.26,168.11 103.26,169.52 102.88,169.9 100.8,169.9 v1(100.34,170.35) 99.82,170.88 v2(99.82,171.78) ; v2(71.29,183.32) 71.64,183.32 72.02,183.71 PR746.1
  IN2 w0.254: v4(80.36,182.82) 80.36,181.57 78.33,179.54 73.63,179.54 73.07,180.1 73.07,182.84 72.59,183.32 v2(71.29,183.32)
  IN3 w0.254: v4(80.36,182.82) 83.17,182.82 84.18,181.8 84.18,176.76 90.18,170.76 99.2,170.76 99.82,171.39 v2(99.82,171.78)
  BOTTOM w0.254: PC706.1 79.71,183.46 v4(80.36,182.82)
BREATH_LED#: length 319
  TOP w0.102: U46.B39 263.86,54.64 263.98,54.52 264.41,54.52 264.89,54.03 v2(264.89,54.01) ; v2(246.21,185.24) 247.01,184.45 v2(247.01,179.85) ; v1(326.75,214.52) 326.37,214.13 v2(326.12,214.13)
  IN3 w0.127: v2(264.89,54.01) 264.44,54.47 263.76,54.47 263.47,54.76 263.47,56.18 263.38,56.27 263.38,58.51 263.19,58.7 263.19,59.3 262.41,60.09 262.41,62.4 265.86,65.86 265.86,72.05 266.54,72.73 266.54,74.71 267.47,75.64 267.47,91.87 267.71,92.11 267.71,95.02 268.22,95.53 268.22,97.03 267.71,97.54 267.71,104.1 268.27,104.66 268.27,124.94 267.67,125.54 267.67,128.05 267.91,128.29 267.91,138.67 267.38,139.21 267.38,140.85 266.17,142.06 266.17,143.57 263.98,145.76 263.98,149.85 263.05,150.78 263.05,173.75 262.86,173.94 262.86,175.63 262.29,176.2 261.62,176.2 258.9,178.92 251.91,178.92 251.25,179.57 247.28,179.57 v2(247.01,179.85) ; v2(193.65,187.53) 194.27,188.15 196.72,188.15 200.58,192.01 209.78,192.01 210.29,191.5 240.76,191.5 241.09,191.83 242.07,191.83 243.63,190.27 245.22,190.27 v2(245.86,190.91) 245.86,190.94 246.81,191.89 274.07,191.89 274.25,191.76 274.28,191.73 274.56,191.6 274.86,191.52 275.06,191.51 281.26,191.51 281.56,191.57 281.85,191.69 281.9,191.73 288.52,191.73 288.7,191.91 293.22,191.91 295,193.7 295,206.64 297.73,209.37 312.91,209.37 317.42,213.88 321.04,213.88 321.17,214.01 322.56,215.4 326.5,215.4 326.75,215.15 326.75,214.77 v2(326.12,214.13)
  BOTTOM w0.102: R955.1 324.9,214.13 v2(326.12,214.13) 326.23,214.25 Q84.1 ; v2(246.21,185.24) 245.86,185.59 v2(245.86,190.91) ; v2(193.65,187.53) 193.25,187.92 JDOCK1.98
BREATH_LED#_Q: length 15.4
  TOP w0.102: LED1.1 340.47,213.59 340.47,215.02 339.83,215.66 332.21,215.66 330.82,214.26 v1(329.62,214.26) v2(328.06,214.26)
  BOTTOM w0.102: Q84.6 328.07,214.25 v2(328.06,214.26)
BREATH_WHITE_LED#: length 225.3
  TOP w0.102: v2(325.48,214.77) v1(324.72,214.77)
  IN3 w0.127: v2(165.48,179) 165.77,179 168.83,182.07 170.06,182.07 170.66,182.66 171.23,182.66 175.05,186.49 178.09,186.49 179.09,187.49 179.09,187.78 178.93,187.95 178.93,189.7 179.45,190.22 180.69,190.22 181.54,189.37 183.7,189.37 184.69,188.38 190.48,188.38 191.23,187.63 192.77,187.63 193.47,186.93 195.86,186.93 200.69,191.76 209.68,191.76 210.19,191.25 240.9,191.25 241.23,191.58 241.84,191.58 243.4,190.02 245.78,190.02 247.25,191.49 253.53,191.49 254.38,190.64 256.19,190.64 257.03,191.48 274.23,191.48 274.23,191.48 274.48,191.36 274.83,191.27 275.05,191.26 281.28,191.26 281.63,191.33 281.97,191.47 281.98,191.48 288.62,191.48 288.8,191.66 293.32,191.66 295.26,193.59 295.26,206.54 297.84,209.12 313.02,209.12 317.53,213.63 317.95,213.63 321.55,213.63 322.69,214.77 v2(325.48,214.77)
  IN4 w0.102: v2(172.96,152.73) 172.83,152.73 171.36,154.2 171.36,166.92 170.04,168.24 170.04,169.98 167.56,172.45 167.56,176.92 v2(165.48,179)
  BOTTOM w0.102: JLVDS1.4 175.32,149.47 175.07,149.73 175.07,150.62 v2(172.96,152.73) ; R955.2 325.28,215.23 325.48,215.02 v2(325.48,214.77)
BREATH_WHITE_LED_SNIFF: length 14.1
  TOP w0.102: v2(331.75,213.21) 331.75,214.55 332.47,215.28 v1(335.52,215.28) 338.69,215.28 339.07,214.9 339.07,213.48 LED1.2
  BOTTOM w0.102: R957.1 331.4,213.55 v2(331.75,213.21)
BST_3V:
  vias: v1(147.68,7.39)
BST_5V: length 1.4
  BOTTOM w0.102: PR107.1 v1(153.78,8.97)
BST_+1.05VSP:
  vias: v1(237.51,11.06)
BT_LED#: length 7
  BOTTOM w0.102: JMINI2.46 272.25,177.27 R720.1 273.69,175.83 v1(273.69,174.4) 273.69,174.08 274.26,173.51 Q89.3
BT_RADIO_DIS#: length 246.5
  TOP w0.102: v2(276.8,183.72) 276.67,183.72 273.16,187.22 R695.1 v1(274.1,188.4) 274.56,188.86 v2(274.56,190.41) ; U46.A13 273.95,54.89 274.2,54.64 274.7,54.64 274.94,54.39 275.17,54.39 v2(275.69,53.87)
  IN1 w0.102: v2(323.45,158.38) 325.23,156.6 329.75,156.6 v2(330.2,156.16)
  IN2 w0.127: v2(276.8,183.72) 276.82,183.73 277.66,183.73 277.91,183.48 289.11,183.48 289.47,183.83 295.04,183.83 300.07,178.8 306.37,178.8 307.31,179.74 316.84,179.74 321.42,175.16 321.42,171.97 320.4,170.95 320.4,168.8 322.99,166.2 322.99,165.87 324.47,164.4 324.47,159.4 v2(323.45,158.38)
  BOTTOM w0.102: v2(274.56,190.41) 275.05,189.92 279.02,189.92 281.98,186.95 D36.1 ; v2(330.2,156.16) 330.25,156.11 330.25,153.97 326.79,150.52 326.79,143.1 325.69,142 325.69,122.01 325.18,121.5 318.38,121.5 315.21,118.33 315.21,106.41 308.05,99.24 287.98,99.24 286.88,98.13 284.06,98.13 279.19,93.27 279.19,67.65 281.35,65.48 281.35,58.12 277,53.77 275.79,53.77 v2(275.69,53.87)
BT_RADIO_DIS#_R: length 79.7
  TOP w0.102: v2(273.9,190.45) 274.2,190.14 v1(274.2,189.7) 274.2,189.6 273.92,189.32 R695.2
  IN4 w0.102: v2(273.9,190.45) 273.9,191.44 273.54,191.8 254.83,191.8 v2(254.34,191.3)
  BOTTOM w0.102: JMINI2.51 274.25,185.69 277.54,182.4 D36.2 279.78,182.78 280.7,183.71 280.7,187.91 278.93,189.69 274.66,189.69 v2(273.9,190.45) ; v2(254.34,191.3) 253.06,191.3 250.45,188.7 250.45,185.51 248.74,183.8 248.74,175.6 250.92,173.42 261.65,173.42 261.78,173.55 R729.1
CAM_MIC_CBL_DET#: length 182.1
  TOP w0.102: v2(205.67,48.78) 205.67,48.68 RPH6.2
  IN2 w0.089: v2(208.89,66.15) 209.45,66.15 210.71,64.9 210.71,64.06 210.82,63.94 210.82,62.26 211.59,61.49 211.59,61.25 211.72,61.12
  IN2 w0.127: v2(195.03,158.76) 195.03,157.84 194.8,157.61 187.51,157.61 183.66,153.76 182.38,153.76 180.73,152.11 175.33,152.11 173.81,153.63 172.37,153.63 171.45,152.7 167.02,152.7 166.39,152.08 166.39,131.77 167.23,130.94 v2(168.27,130.94) ; 211.72,61.12 211.82,61.02 211.82,60.5 211.49,60.17 211.17,60.17 210.85,59.85 210.85,55.66 209.86,54.67 209.86,53.63 205.94,49.71 205.94,49.05 v2(205.67,48.78)
  IN3 w0.089: v2(208.89,66.15) 208.34,66.15 208.07,66.42 208.07,66.78 206.07,68.78 206.07,69.39 206.27,69.6 206.27,70.4 204.4,72.26 203.88,72.26 203.55,72.59 203.55,73.61 199.88,77.28 199.88,78.98 199.49,79.37
  IN3 w0.127: 199.49,79.37 194.9,83.96 183.62,83.96 175.88,91.71 175.88,91.75 175.88,99.16 173.67,101.37 173.67,113 173.31,113.36 173.31,127.81 170.19,130.94 v2(168.27,130.94)
  IN4 w0.102: v2(195.03,158.76) 195.03,166.38 196.24,167.59 v2(196.24,168)
  BOTTOM w0.089: UH1.L15 208.89,66.41 v2(208.89,66.15)
  BOTTOM w0.102: v2(168.27,130.94) 168.27,131.6 v1(168.26,131.61) ; v2(196.24,168) 195.98,167.74 194.9,167.74 194.7,167.54 194.7,167.26 194.9,167.06 JCAM1.1
CARD_RESET#: length 14.6
  TOP w0.102: JEXP1.18 283.72,31.56 282.43,32.84 281.3,32.84 CE12.1 280.27,32.96 278.9,32.96 278.28,32.33 v1(273.79,32.33) 273.52,32.33 272.4,33.45 U41.8
CARD_SMBCLK: length 125.7
  TOP w0.102: JEXP1.6 282.38,28.56 v2(281.73,29.21) 281.69,29.21 281.3,29.6 280.98,29.6 R732.2 ; v2(282.66,107.13) 282.76,107.13 283.54,107.91 283.54,107.99 283.72,108.17 U51.A49
  IN1 w0.102: v2(278.62,102.96) 278.67,102.96 279.81,104.1 279.81,104.84 282.19,107.22 282.57,107.22 v2(282.66,107.13)
  IN2 w0.127: v2(278.62,102.96) 278.6,102.96 278.34,103.21 275.89,103.21 275.73,103.38 275.42,103.38 271.51,103.38 271.06,102.92 268.42,102.92 v2(268.23,102.73)
  IN4 w0.102: v2(268.23,102.73) 268.09,102.87 267.8,102.87 267.38,102.45 267.38,100.46 266.61,99.69 266.61,99.1 264.12,96.62 264.12,96.18 263.6,95.66 263.6,95.65 260.17,92.22 260.17,78.78 259.88,78.49 259.88,71.75 259.88,71.75 259.88,70.95 259.88,66.31 260.64,65.55 260.64,60.29 260.26,59.91 260.26,55.82 260.49,55.59 260.49,54.88 260.49,53.25 260.43,53.2 260.43,45.75 259.62,44.93 259.62,37.1 259.32,36.8 258.95,36.8 v2(258.76,36.61)
  BOTTOM w0.102: v2(258.76,36.61) 259.02,36.61 259.24,36.39 259.24,33.23 259.91,32.56 259.91,29.67 260.87,28.71 261.91,28.71 262.62,28 274.81,28 276.2,29.39 281.55,29.39 v2(281.73,29.21)
CARD_SMBDAT: length 126.1
  TOP w0.102: v2(282.66,107.72) 282.67,107.72 282.9,107.72 283.39,108.21 283.39,108.87 283.47,108.95 U51.B52 ; R731.2 280.73,30.33 281.15,29.91 281.62,29.91 v2(281.73,29.79) 282.47,29.06 JEXP1.8
  IN1 w0.102: v2(282.66,107.72) 282.39,107.45 282.09,107.45 279.59,104.94 279.59,104.2 278.93,103.54 v2(278.62,103.54)
  IN2 w0.127: v2(268.23,103.31) 268.37,103.17 270.95,103.17 271.29,103.52 271.41,103.63 275.53,103.63 275.83,103.63 276,103.47 278.54,103.47 v2(278.62,103.54)
  IN4 w0.102: v2(268.23,103.31) 268.02,103.1 267.71,103.1 267.15,102.55 267.15,100.56 266.38,99.78 266.38,99.2 263.89,96.71 263.89,96.28 263.37,95.75 263.37,95.75 259.94,92.32 259.94,78.88 259.65,78.59 259.65,71.84 259.65,71.84 259.65,70.85 259.65,70.85 259.65,66.22 260.41,65.46 260.41,60.38 260.03,60 260.03,55.72 260.26,55.49 260.26,54.79 260.26,54.79 260.26,53.35 260.21,53.29 260.21,45.84 259.39,45.03 259.39,37.2 259.23,37.03 258.92,37.03 v2(258.76,37.2)
  BOTTOM w0.102: v2(258.76,37.2) 258.99,36.97 259.19,36.97 259.47,36.69 259.47,33.32 260.14,32.65 260.14,29.77 260.97,28.94 262,28.94 262.71,28.23 274.72,28.23 276.1,29.62 281.55,29.62 v2(281.73,29.79)
CASA0#: length 30.3
  TOP w0.102: UV5.G3 v2(195.45,123.5)
  IN1 w0.102: 207.12,132.33 207.15,132.33 207.9,133.08 208.95,133.08 209.13,132.91 209.13,132.44 210.46,131.1 210.77,131.1 211.24,130.63 213.55,130.63 v2(214.11,131.19)
  IN1 w0.127: v2(195.45,123.5) 195.06,123.89 195.06,130.01 196.15,131.1 199.31,131.1 199.81,131.6 201.85,131.6 202.49,132.24 207.03,132.24 207.12,132.33
  BOTTOM w0.102: v2(214.11,131.19) 214.25,131.33 UV1.K20 ; UV5.G3 v2(195.45,123.5)
CASA1#: length 30.9
  TOP w0.102: UV3.G3 v2(192.25,135.29)
  IN4 w0.102: 207.32,134.8 208.41,134.8 208.9,134.3 213.88,134.3 214.36,134.78 v2(214.41,134.78)
  IN4 w0.127: v2(192.25,135.29) 191.49,136.06 191.49,136.89 191.88,137.29 194.81,137.29 195.04,137.06 195.04,136.74 195.29,136.5 195.6,136.5 195.84,136.26 195.84,135.14 195.87,135.12 195.87,134.35 195.87,134.35 195.87,134.33 196.1,134.1 199.6,134.1 199.84,134.34 199.84,134.74 200.03,134.92 200.45,134.92 200.92,135.4 204.52,135.4 204.78,135.13 206.47,135.13 206.89,134.71 207.23,134.71 207.32,134.8
  BOTTOM w0.102: v2(214.41,134.78) 214.25,134.62 UV1.K17 ; UV3.G3 v2(192.25,135.29)
CASB0#: length 32.4
  TOP w0.102: v2(208.31,164.5) UV7.G3
  IN4 w0.102: 218.3,147.21 218.88,146.63 219.02,146.63 219.39,146.26 219.39,145.28 220.29,144.37 220.29,143.5 220.18,143.38 220.18,141.9 220.55,141.53 220.74,141.53 221.02,141.25 221.02,140.77 v2(220.69,140.44) ; 213.48,154.57 213.49,154.58 ; v2(208.31,164.5) 208.7,164.11 209.24,164.11 209.49,163.85 209.49,163.57 210.1,162.97 210.92,162.97
  IN4 w0.127: 213.48,154.57 213.48,153.47 215.35,151.59 215.35,150.86 217.69,148.53 217.69,147.82 218.3,147.21 ; 213.49,154.58 213.49,160.18 212.87,160.8 212.87,161.01 210.92,162.97
  BOTTOM w0.102: v2(208.31,164.5) UV7.G3 ; v2(220.69,140.44) 221.13,140 UV1.W10
CASB1#: length 30.1
  TOP w0.102: UV9.G3 v2(229.31,164.5)
  IN4 w0.127: v2(229.31,164.5) 228.91,164.1 228.91,162.25 226.37,159.7 226.28,159.7 224.92,158.33 224.92,157.06 226.13,155.84 226.13,155.09 227.32,153.91 227.32,153.01 227.11,152.8 227.11,146.95 226.19,146.03 226.19,145.11 225.13,144.06 225.13,143.38 224.82,143.07 224.82,140.96 v2(224.28,140.42)
  BOTTOM w0.102: UV1.AA10 223.86,140 v2(224.28,140.42) ; UV9.G3 v2(229.31,164.5)
CCD_OFF: length 213.1
  TOP w0.102: v2(194.86,171.6) 194.86,171.4 194.62,171.16 v1(192.09,171.16) 191.7,170.76 189.86,170.76 189.56,170.46 189.56,168.99 190.7,167.84 Q23.2 ; v2(264.87,52.08) 264.87,52.1 264.33,52.64 U46.B43
  IN3 w0.127: v2(194.86,171.6) 194.86,171.61 194.86,171.74 195.31,172.19 200.35,172.19 201.05,171.49 203.89,171.49 205.08,172.67 214.14,172.67 214.32,172.85 218.55,172.85 221.41,175.7 221.91,176.2 224.46,176.2 224.67,176.2 224.85,176.02 225.23,176.02 225.24,176.02 232.47,176.02 236.25,176.02 237.27,177.04 246.71,177.04 246.93,177.27 252.93,177.27 255,175.2 259.16,175.2 261.22,173.14 261.22,171.28 261.53,170.98 261.53,150.15 262.45,149.22 262.45,145.13 264.65,142.93 264.65,141.42 265.86,140.22 265.86,138.57 266.39,138.04 266.39,130.24 265.4,129.25 265.4,121.72 266.01,121.11 266.01,110.33 266.57,109.77 266.57,105.57 266.04,105.04 266.04,94.26 266.04,94.26 266.04,93.7 265.78,93.45 265.78,89.1 264.84,88.16 264.84,75.39 264.21,74.76 264.21,66.36 260.89,63.04 260.89,58.4 260.5,58.01 260.5,53.1 261.19,52.41 262.89,52.41 262.97,52.5 264.45,52.5 v2(264.87,52.08)
CD3301_DCIN:
  vias: v1(149.12,163.33)
CD3301_SDC_IN: length 2.4
  TOP w0.254: PR854.2 152.87,163.42 152.25,164.04 PU800.6
CD_PBATT_OFF: length 4.9
  TOP w0.254: PU800.27 149.75,170.99 149.82,171.06 149.82,171.49 149.5,171.81 148.23,171.81 v1(147.82,172.21) 147.18,172.86 PR843.1
CFD_PWRBTN#_XDP: length 7.8
  TOP w0.102: RC21.2 111.07,111.52 v2(110.97,111.42) v1(110.37,111.42)
  BOTTOM w0.102: v2(110.97,111.42) 110.97,112.63 112.74,114.4 JXDP1.41
CFG0: length 29.6
  TOP w0.102: v2(115.64,102.31) v1(115.64,101.65)
  IN4 w0.089: v2(136.73,98.92) 136.19,98.92 136,99.11
  IN4 w0.102: v2(115.64,102.31) 115.74,102.41 120.71,102.41 121.85,101.27 125.06,101.27 125.66,100.67 128.46,100.67 129.94,99.19 135.92,99.19 136,99.11
  BOTTOM w0.102: v2(115.64,102.31) 115.22,102.74 115.22,104.32 115.4,104.51 115.4,106.01 115.01,106.4 JXDP1.9 ; JCPU1.AT20 v2(136.73,98.92)
CFG1: length 30.7
  TOP w0.102: v2(115.63,103.05) 115.63,103.7 v1(115.55,103.77)
  IN4 w0.089: 136,99.48 136.13,99.35 137.18,99.35 137.61,98.92 v2(137.73,98.92)
  IN4 w0.102: v2(115.63,103.05) 115.93,102.74 120.7,102.74 121.95,101.5 125.15,101.5 125.75,100.9 128.63,100.9 130.04,99.49 135.99,99.49 136,99.48
  BOTTOM w0.089: v2(137.73,98.92) JCPU1.AR20
  BOTTOM w0.102: JXDP1.11 115.27,106.9 115.63,106.54 v2(115.63,103.05)
CFG2: length 40.9
  TOP w0.089: v2(138.73,98.92) 138.73,98.95 139.24,99.45 139.24,100.18 138.93,100.48 136.63,100.48 136,99.85
  TOP w0.102: 136,99.85 135.48,99.33 v1(134.09,99.33) 133.59,99.33 132.85,98.59 132.55,98.59 RC76.1
  IN4 w0.089: v2(138.73,98.92) 138.63,98.92 138.16,99.39 137.41,99.39 137.26,99.54 136.37,99.54 136.09,99.82 136,99.82
  IN4 w0.102: v2(116.26,104.2) 116.26,103.88 117.18,102.97 120.8,102.97 122.04,101.73 125.25,101.73 125.85,101.13 128.73,101.13 130.04,99.82 136,99.82
  BOTTOM w0.089: v2(138.73,98.92) JCPU1.AP20
  BOTTOM w0.102: JXDP1.15 115.04,107.9 115.86,107.07 115.86,104.6 116.26,104.19 v2(116.26,104.2)
CFG3: length 70.4
  TOP w0.102: v2(129.47,97.04) 129.35,97.17 RC100.1 ; v2(110.93,117.96) v1(110.13,117.96)
  IN1 w0.089: 136,98.79 136.21,99 136.21,99.24 136.47,99.51 138.09,99.51 138.3,99.73 138.3,100.49 v2(138.73,100.92)
  IN1 w0.102: v2(129.47,97.04) 129.47,96.56 130.44,95.59 132.8,95.59 136,98.79
  IN2 w0.127: v2(129.47,97.04) 129.47,99.09 129.71,99.33 129.71,101.17 128.21,102.68 127.77,103.12 127.03,103.85 127.03,106.63 122.73,110.93 120.81,110.93 119.86,111.87 119.86,119.47 v2(120.33,119.94)
  IN4 w0.102: v2(120.33,119.94) 119.71,119.32 113.83,119.32 112.57,118.06 111.36,118.06 111.25,117.96 v2(110.93,117.96)
  BOTTOM w0.089: v2(138.73,100.92) JCPU1.AP22
  BOTTOM w0.102: JXDP1.17 112.61,108.4 111.87,109.13 111.17,109.13 110.31,109.99 110.31,114.15 110.98,114.82 110.98,117.91 v2(110.93,117.96) ; RC8.2 123.25,119.7 122.63,120.32 120.71,120.32 v2(120.33,119.94)
CFG3_R: length 3.8
  BOTTOM w0.102: v1(122.22,119.94) 122.33,119.82 RC8.1 122.22,118.9 JXDP1.60
CFG4: length 33.3
  IN4 w0.102: v2(117.12,103.61) 117.52,103.2 121.6,103.2 121.67,103.14 123.92,103.14 124.52,102.54 125.41,102.54 126.03,101.92 131.64,101.92 v2(132.56,101)
  BOTTOM w0.089: JCPU1.AT22 136,100.45
  BOTTOM w0.102: v2(117.12,103.61) 116.67,104.05 116.67,110.08 115.86,110.9 JXDP1.27 ; v1(131.89,99.56) RC77.1 131.91,101 v2(132.56,101) 134.08,101 134.63,100.45 136,100.45
CFG5: length 44.2
  TOP w0.089: v2(139.73,100.92) 139.16,101.49 136.34,101.49 136,101.16
  TOP w0.102: 136,101.16 v1(135.59,100.75) 134.6,99.76 133.28,99.76 132.47,98.95 RC78.1
  IN4 w0.089: v2(139.73,100.92) 139.73,101.16 139.56,101.33 136.51,101.33 136,101.84
  IN4 w0.102: v2(117.08,104.34) 117.55,104.81 121.59,104.81 122.58,103.82 126.76,103.82 126.99,103.59 134.25,103.59 136,101.84
  BOTTOM w0.089: v2(139.73,100.92) JCPU1.AN22
  BOTTOM w0.102: v2(117.08,104.34) 117.08,110.57 116.25,111.4 JXDP1.29
CFG6: length 33.3
  TOP w0.102: v2(117.85,104.36) v1(117.85,105.04)
  IN4 w0.102: v2(117.85,104.36) 118.2,104 121.63,104 122.04,103.59 124.11,103.59 124.71,103 125.6,103 126.07,102.53 132.67,102.53 v2(132.8,102.65)
  BOTTOM w0.089: JCPU1.AT25 136,103.45
  BOTTOM w0.102: 136,103.45 133.66,103.45 132.86,102.65 v2(132.8,102.65) 132.74,102.59 132.48,102.59 RC79.1 ; v2(117.85,104.36) 117.85,110.57 116.02,112.4 JXDP1.33
CFG7: length 45.2
  TOP w0.089: 136,101.86 136.51,102.37 139.28,102.37 v2(139.73,101.92)
  TOP w0.102: 136,101.86 135.73,101.59 135.48,101.59 v2(135.31,101.42) 134.03,100.14 133.22,100.14 132.51,99.43 129.93,99.43 129.35,100.01 RC83.1 ; v2(117.84,103.7) v1(117.84,103.01)
  IN4 w0.102: v2(117.84,103.7) 117.92,103.77 121.36,103.77 121.76,103.37 124.01,103.37 124.61,102.77 125.5,102.77 126.11,102.16 132.11,102.16 132.85,101.42 v2(135.31,101.42)
  BOTTOM w0.089: v2(139.73,101.92) JCPU1.AN23
  BOTTOM w0.102: JXDP1.35 114.93,112.9 115.11,112.71 116.02,112.71 118.25,110.48 118.25,104.11 v2(117.84,103.7)
CFG8: length 21.4
  TOP w0.102: v2(121.28,106.5) v1(120.57,106.5)
  IN4 w0.089: v2(137.73,102.92) 137.69,102.96 137.59,102.96 136,104.55
  IN4 w0.102: 136,104.55 134.23,106.31 129.59,106.31 129.23,105.96 122.51,105.96 121.97,106.5 v2(121.28,106.5)
  BOTTOM w0.089: v2(137.73,102.92) JCPU1.AR24
  BOTTOM w0.102: JXDP1.10 121.17,106.4 v2(121.28,106.5)
CFG9: length 20.5
  IN4 w0.089: 136,102.58 136.07,102.58 v2(136.73,101.92)
  IN4 w0.102: v2(121.9,105.6) 121.99,105.6 122.92,104.67 127.08,104.67 127.32,104.43 134.01,104.43 135.86,102.58 136,102.58
  BOTTOM w0.102: v2(136.73,101.92) JCPU1.AT23 ; JXDP1.12 120.85,106.9 120.93,106.97 121.42,106.97 121.84,106.55 v1(121.84,106.36) 121.84,105.66 v2(121.9,105.6)
CFG10: length 26.1
  IN4 w0.089: 136,101.38 136.43,100.95 137.14,100.95 137.6,100.49 138.9,100.49 139.29,100.1 139.29,99.57 139.73,99.12 v2(139.73,98.92)
  IN4 w0.102: v2(124.87,103.4) 125.07,103.59 126.67,103.59 126.9,103.37 134.02,103.37 136,101.38
  BOTTOM w0.089: v2(139.73,98.92) JCPU1.AN20
  BOTTOM w0.102: v2(124.87,103.4) 124.22,103.4 v1(123.83,103.8) 122.65,104.97 122.65,105.83 122.31,106.17 122.31,106.47 121.8,106.98 121.8,107.41 121.31,107.9 JXDP1.16
CFG11: length 23.3
  TOP w0.102: v2(122.99,106.4) 122.99,105.88 v1(122.92,105.8)
  IN4 w0.089: 136,104.91 136.28,104.63 136.3,104.63 137.39,103.54 138.11,103.54 v2(138.73,102.92)
  IN4 w0.102: 136,104.91 134.37,106.54 123.13,106.54 v2(122.99,106.4)
  BOTTOM w0.089: v2(138.73,102.92) JCPU1.AP24
  BOTTOM w0.102: JXDP1.18 121.77,108.4 122.03,108.14 122.03,107.36 v2(122.99,106.4)
CFG12: length 24
  IN4 w0.089: 136,105.78 137.24,104.53 138.35,104.53 v2(138.73,104.92)
  IN4 w0.102: 136,105.78 134.09,107.68 124.27,107.68 123.83,107.25 v2(123.81,107.25)
  BOTTOM w0.102: v2(123.81,107.25) 123.33,107.73 122.95,107.73 122.72,107.97 122.72,109.61 v1(121.87,110.46) 121.43,110.9 JXDP1.28 ; v2(138.73,104.92) JCPU1.AP26
CFG13: length 26.7
  TOP w0.102: v2(123.12,108.14) 122.33,108.14 v1(122.28,108.09)
  IN4 w0.089: 136,106.12 136.64,105.49 138.88,105.49 139.2,105.17 139.2,104.41 139.69,103.92 v2(139.73,103.92)
  IN4 w0.102: 136,106.12 134.21,107.91 124.15,107.91 123.97,107.73 123.53,107.73 v2(123.12,108.14)
  BOTTOM w0.102: v2(123.12,108.14) 123.12,110.41 122.14,111.4 JXDP1.30 ; v2(139.73,103.92) JCPU1.AN25
CFG14: length 26.6
  TOP w0.102: v2(123.8,108.14) v1(123.8,108.97)
  IN4 w0.089: v2(139.73,104.92) 139.73,105 139.34,105.4 139.34,106.15 139.1,106.39 136.11,106.39 136,106.5
  IN4 w0.102: 136,106.5 134.36,108.14 v2(123.8,108.14)
  BOTTOM w0.102: JXDP1.34 121.91,112.4 123.8,110.52 v2(123.8,108.14) ; v2(139.73,104.92) JCPU1.AN26
CFG15: length 26.2
  TOP w0.102: v1(125.2,107.2) 125.15,107.25 v2(124.44,107.25)
  IN4 w0.089: v2(138.73,103.92) 138.31,104.34 137.02,104.34 136.29,105.07 136.29,105.08 136,105.37
  IN4 w0.102: v2(124.44,107.25) 129.19,107.25 129.68,106.77 134.6,106.77 136,105.37
  BOTTOM w0.102: JXDP1.36 121.95,112.9 124.44,110.4 v2(124.44,107.25) ; v2(138.73,103.92) JCPU1.AP25
CFG16: length 22.7
  TOP w0.102: v2(123.07,102.5) v1(123.93,102.5)
  IN4 w0.089: 136,100.3 136.91,100.3 137.28,99.92 v2(137.73,99.92)
  IN4 w0.102: v2(123.07,102.5) 123.91,102.5 124.45,101.96 125.34,101.96 125.94,101.36 128.82,101.36 129.51,100.67 131.03,100.67 131.41,100.3 136,100.3
  BOTTOM w0.089: v2(137.73,99.92) JCPU1.AR21
  BOTTOM w0.102: JXDP1.6 120.76,105.4 121.12,105.04 121.78,105.04 123.07,103.75 v2(123.07,102.5)
CFG17: length 23.8
  TOP w0.102: v2(122.47,102.48) v1(121.8,102.48)
  IN4 w0.089: 136,100.6 137.23,100.6 137.52,100.3 138.31,100.3 138.7,99.92 v2(138.73,99.92)
  IN4 w0.102: 136,100.6 131.87,100.6 130.79,101.68 125.95,101.68 125.44,102.18 124.55,102.18 123.83,102.91 122.9,102.91 v2(122.47,102.48)
  BOTTOM w0.089: v2(138.73,99.92) JCPU1.AP21
  BOTTOM w0.102: JXDP1.4 120.94,104.9 121.02,104.81 121.68,104.81 122.47,104.02 v2(122.47,102.48)
CFG18: length 24.5
  TOP w0.102: v2(123.76,105.09) 124.52,105.09 v1(124.57,105.04)
  IN4 w0.089: 136,103.11 136.77,102.34 137.4,102.34 137.73,102 v2(137.73,101.92)
  IN4 w0.102: v2(123.76,105.09) 127.07,105.09 127.5,104.66 134.1,104.66 135.65,103.11 136,103.11
  BOTTOM w0.089: v2(137.73,101.92) JCPU1.AR23
  BOTTOM w0.102: JXDP1.24 121.46,109.9 122.49,108.86 122.49,107.8 123.76,106.53 v2(123.76,105.09)
CFG19: length 25.2
  IN4 w0.089: v2(138.73,101.92) 138.13,102.53 137.55,102.53 137.24,102.83 137.24,102.96 136.58,103.62 136.47,103.62 136,104.09
  IN4 w0.102: v2(123.12,105.08) 123.54,105.5 123.93,105.5 124.05,105.37 134.72,105.37 136,104.09
  BOTTOM w0.089: v2(138.73,101.92) JCPU1.AP23
  BOTTOM w0.102: JXDP1.22 121.37,109.4 122.26,108.51 122.26,107.71 123.53,106.44 123.53,106.06 v1(123.22,105.75) 123.12,105.65 v2(123.12,105.08)
CFG_RCOMP: length 7.2
  BOTTOM w0.254: JCPU1.AT31 132.79,109.45 v1(132.13,108.79) 131.89,108.55 RC81.1
CHAGER_SRC:
  vias: v1(94.88,189.47) v4(85.68,187.62) v4(85.68,186.98) v4(85.68,186.35) v4(86.34,188.99) v4(86.33,188.34) v4(86.34,187.67) v4(86.34,186.99) v4(86.34,186.27) v4(87.04,189) v4(87.02,188.37) v4(87.03,187.68) v4(87,186.99) v4(87,186.28)
CHARGE_EN: length 2.9
  TOP w0.102: R3.2 260.54,49.58 261.37,49.58 261.78,49.99 262.09,49.99 262.49,50.39 U46.A45
CHARGE_MODULE_BATT: length 245.5
  TOP w0.102: U46.A15 v2(274.42,55.89)
  TOP w0.254: PR876.2 169.01,173.53 169.57,173.53 170.66,174.62 v1(170.92,174.62) 171.89,174.62 v2(172.83,175.56)
  IN3 w0.127: v2(274.42,55.89) 274.42,56.02 274.72,56.32 275.22,56.32 275.31,56.24 278.87,56.24 279.92,57.28 279.92,61.53 276.71,64.73 276.71,93.47 275.48,94.7 275.48,102.51 272.5,105.49 272.5,125.37 272.3,125.57 272.3,129.19 271.61,129.87 271.61,135.58 271.89,135.86 271.89,137.04 272.46,137.61 272.46,142.66 271.95,143.17 271.83,143.17 268.17,146.83 268.17,149.78 268.79,150.4 268.79,165.48 267.8,166.47 267.8,169.11 268.49,169.8 268.49,171.63 268.07,172.05 268.07,173.11 268.71,173.75 268.93,173.75 269.54,174.36 269.54,176.29 266.93,178.9 262.62,183.21 252.51,183.21 251.35,184.37 249.15,184.37 248.22,183.44 235.56,183.44 232.3,180.19 227.19,180.19 226.61,180.76 220.23,180.76 216.7,177.24 212.73,177.24 212.48,176.98 205.29,176.98 204.57,177.71 202.32,177.71 202.26,177.77 197.94,177.77 197.67,177.51 195.93,177.51 195.67,177.77 194.76,177.77 194.49,177.51 192.39,177.51 190.88,176 188.92,176 187.42,174.5 183.78,174.5 183.55,174.73 179.5,174.73 179.36,174.59 178.57,174.59 178.11,175.04 177.14,175.04 176.99,175.2 176.44,175.2 176.13,174.89 173.5,174.89 v2(172.83,175.56)
CHARGE_MODULE_BATT_C2: length 5.8
  TOP w0.102: PR876.1 167.5,172.86 167.99,172.36 169.36,172.36 169.82,171.91 v1(169.82,171.54)
  TOP w0.203: PU808.9 167.38,172.82 PR876.1
CHARGE_PBATT: length 257.8
  TOP w0.102: v2(271.51,55.33) 271.51,55.47 272.11,56.08 272.36,56.08 272.42,56.14 U46.B16
  TOP w0.254: PR873.2 168.65,173.88 172.46,177.69 v2(172.46,178.12)
  IN3 w0.127: v2(215.98,178.68) 216.7,178.68 219.68,181.66 227.01,181.66 227.55,181.11 231.61,181.11 235.29,184.8 248.31,184.8 248.64,185.14 252.04,185.14 253.2,183.97 263.1,183.97 268.97,178.1 269.83,178.1 270.3,177.63 270.3,173.82 269.67,173.19 269.67,171.86 269.77,171.75 269.77,169.76 269.54,169.53 269.54,167.8 269.81,167.53 269.81,149.98 269.18,149.36 269.18,147.25 272.08,144.36 272.2,144.36 273.64,142.92 v2(273.64,142.51) ; v2(172.46,178.12) 172.58,178.12 173.38,178.92 174,178.92 174.23,179.15 174.23,179.63 174.63,180.03 175.42,180.03 177.3,178.16 178.18,178.16 179.26,179.23 180.34,179.23 180.62,178.96 180.62,178.51 181.31,177.81 182.09,177.81 182.32,178.04 182.32,179.31 183.12,180.11 183.91,180.11 186.32,180.11 187.01,180.8 190.29,180.8 191.24,179.86 192.48,179.86 193.55,180.92 205.6,180.92 207.09,179.44 210.34,179.44 213.03,182.13 215.66,182.13 216.12,182.58 216.69,183.16 v2(217.04,183.16) ; v2(272.25,102.96) 274.37,100.84 274.37,91.1 274.65,90.82 275.19,90.82 275.57,90.44 275.57,75.58 272.47,72.48 272.47,69.62 272.4,69.55 272.4,65.79 271.43,64.82 271.43,63.64 271.62,63.45 271.62,57.04 271.7,56.96 271.7,55.52 v2(271.51,55.33)
  BOTTOM w0.102: v2(215.98,178.68) 217.04,179.73 v2(217.04,183.16) ; v2(272.25,102.96) v1(272.25,104.15) 271.79,104.61 271.79,117.56 272.31,118.08 272.31,123.24 274.72,125.65 274.72,128.28 275.95,129.51 275.95,132.35 276.31,132.7 276.31,136.44 274.46,138.29 274.46,141.77 273.72,142.51 v2(273.64,142.51)
CHARGE_PBATT_C2: length 2.9
  TOP w0.203: PU808.10 v1(166.2,173.22) 166.77,173.22 PR873.1
CHARGER_CELL_PIN: length 16.9
  TOP w0.102: v1(70.59,182.5) 70.76,182.66 v2(71.29,182.66)
  TOP w0.254: PR745.1 71.45,182.82 v2(71.29,182.66)
  BOTTOM w0.254: PD818.2 58.78,183.78 61.32,181.24 68.79,181.24 70.21,182.66 v2(71.29,182.66)
CHARGER_SMBCLK: length 332.1
  TOP w0.102: R828.2 278.6,107.92 278.6,108.14 278.82,108.37 279.41,108.37 279.47,108.31 279.8,108.31 279.86,108.37 280.33,108.37 280.48,108.22 280.77,108.22 281.22,108.67 v2(281.29,108.67) ; PU700.9 75.19,184.17 75.06,184.29 74.43,184.29 v2(74.25,184.12) ; v2(284.25,110.04) 283.81,110.48 283.35,110.48 283.28,110.41 U51.B50
  IN1 w0.102: v2(280.15,173.05) 280.08,173.05 279.41,172.38 275.6,172.38 274.95,171.72 274.95,170.12 274.77,169.94 274.77,167.85 274.4,167.48 274.4,153.26 273.57,152.42 273.57,148.4 274.32,147.65 274.32,146.56 277.03,143.85 277.03,137.43 277.3,137.16 277.3,133.08 277.87,132.51 277.87,127.06 276.79,125.98 276.79,123.27 277.36,122.7 277.36,121.04 277.66,120.75 277.66,116.01 279.19,114.48 279.19,112.38 279.54,112.04 279.54,110.17 279.93,109.77 280.64,109.77 281.1,109.3 281.1,108.83 281.29,108.65 v2(281.29,108.67)
  IN2 w0.127: v2(280.15,173.05) 280.15,173.06 280.55,173.46 280.55,174.7 280.26,174.99 275.94,179.31 266.7,179.31 262.85,183.16 261.12,183.16 259.41,181.44 257.54,181.44 256.8,180.71 253.62,180.71 253.08,180.16 247.93,180.16 247.12,180.96 237.3,180.96 234.53,178.18 234.31,178.18 234.31,178.18 226.2,178.18 226.2,178.18 226.18,178.18 224.96,179.4 212.97,179.4 211.47,177.9 199.6,177.9 197.05,180.45 193.25,180.45 192.64,179.84 191.37,179.84 190.28,180.94 187.87,180.94 185.5,183.31 183.84,183.31 180.96,186.19 177.73,186.19 175.57,184.04 172.79,184.04 170.48,181.72 168.93,181.72 167.14,179.94 167.14,176.74 164.27,173.86 159.29,173.86 159.03,173.61 154.08,173.61 152.45,171.97 148.01,171.97 147.43,171.39 147.43,170.91 146.54,170.01 130.81,170.01 129.92,170.9 123.82,170.9 122.6,169.68 120.12,169.68 119.99,169.82 117.73,169.82 117.11,169.2 113.48,169.2 113.19,168.91 106.82,168.91 106.11,168.2 101.46,168.2 100.5,167.23 92.98,167.23 91.47,168.74 91.47,169.57 90.32,170.73 89.29,170.73 87.35,172.67 86.84,172.67 82.18,177.33 76.91,177.33 76.35,177.89 73.21,177.89 70.72,180.38 70.72,184.09 71.2,184.57 72.61,184.57 72.88,184.3 74.06,184.3 v2(74.25,184.12)
  IN4 w0.102: v2(281.29,108.67) 281.31,108.65 281.82,108.65 282.56,109.38 283.59,109.38 v2(284.25,110.04)
CHARGER_SMBDAT: length 327.2
  TOP w0.102: v2(280.64,108.67) 280.6,108.67 280.5,108.78 280.07,108.78 R827.2 279.97,109.18 281.45,110.66 U51.A47 ; PU700.8 75.19,184.67 75.04,184.52 74.33,184.52 74.25,184.61 v2(74.25,184.7)
  IN1 w0.102: v2(280.64,108.67) 280.88,108.91 280.88,109.21 280.55,109.54 279.84,109.54 279.31,110.07 279.31,111.94 278.96,112.29 278.96,114.38 277.43,115.92 277.43,120.65 277.14,120.94 277.14,122.6 276.56,123.18 276.56,126.08 277.64,127.16 277.64,132.42 277.07,132.99 277.07,137.07 276.8,137.34 276.8,143.75 274.09,146.47 274.09,147.56 273.34,148.3 273.34,152.51 274.18,153.35 274.18,167.58 274.54,167.94 274.54,170.03 274.72,170.21 274.72,171.82 275.51,172.61 279.31,172.61 279.74,173.03 279.74,173.28 279.98,173.52 280.02,173.52 v2(280.13,173.63)
  IN2 w0.127: v2(74.25,184.7) 74.11,184.56 72.99,184.56 72.72,184.82 71.09,184.82 70.47,184.2 70.47,180.28 73.11,177.63 76.24,177.63 76.8,177.08 82.07,177.08 86.73,172.41 87.24,172.41 89.19,170.47 90.21,170.47 91.22,169.46 91.22,168.63 92.87,166.98 100.61,166.98 101.57,167.94 106.22,167.94 106.93,168.66 113.29,168.66 113.58,168.95 117.21,168.95 117.84,169.57 119.88,169.57 120.02,169.43 122.71,169.43 123.93,170.65 129.81,170.65 130.7,169.76 146.64,169.76 147.68,170.8 147.68,171.28 148.12,171.72 152.55,171.72 154.19,173.35 159.14,173.35 159.39,173.61 164.37,173.61 167.39,176.63 167.39,179.83 169.03,181.47 170.58,181.47 172.89,183.78 175.68,183.78 177.84,185.94 180.85,185.94 183.74,183.06 185.39,183.06 187.77,180.68 190.17,180.68 191.27,179.59 192.75,179.59 193.36,180.2 196.94,180.2 199.5,177.65 211.58,177.65 213.08,179.15 224.84,179.15 226.06,177.93 226.1,177.93 226.1,177.93 234.41,177.93 234.41,177.93 234.63,177.93 237.41,180.71 247.02,180.71 247.82,179.91 253.18,179.91 253.73,180.45 256.91,180.45 257.64,181.19 259.51,181.19 261.23,182.91 262.74,182.91 266.59,179.06 275.84,179.06 280.3,174.6 280.3,173.8 v2(280.13,173.63)
CHG_LGATE: length 13
  TOP w0.102: v1(86.85,175.53) v4(87.55,175.53)
  IN4 w1.016: 80.5,181.62 81.72,181.62 86.93,176.42 87.23,176.42 ; 88.63,175.4 92.06,175.4
  vias: v2(93.09,175.76) v2(93.1,175.13) v4(79.17,182.51) v4(79.55,182) v4(87.55,174.89)
CHG_PHASE: length 7.8
  IN4 w1.016: 89.34,183.65 89.34,183.83 88.21,184.96 82.43,184.96 82.25,185.14
  vias: v1(80.96,184.94) v4(80.63,185.37) v4(81.26,185.39) v4(90.29,183.62) v4(91.41,183.62)
CHG_UGATE: length 8.5
  IN4 w1.016: 81.9,183.84 82.47,183.27 86.3,183.27 ; 92.48,181.66 92.39,181.75 89.48,181.75 89.38,181.65
  BOTTOM w0.102: 86.8,182.13 86.65,182.13 86.27,182.51 v1(86.27,182.52)
  vias: v4(80.44,184.48) v4(81.01,184.1) v4(86.98,182.56) v4(87.19,181.76) v4(93.33,181.75) v4(94.27,181.64)
CHGVR_DCIN: length 4
  TOP w0.102: PR833.2 147.01,163.56 v1(147.19,163.39)
  TOP w0.254: PR833.2 147.25,164.34 147.66,164.74 147.66,165.53 148.15,166.03 PU800.35
CKEA0: length 29.9
  TOP w0.102: UV5.J3 v2(193.85,124.3)
  IN4 w0.102: v2(213.24,130.04) 213.24,129.93 212.77,129.46 211.98,129.46 211.31,128.79 211.31,128.54 210.49,127.72 210.47,127.72 209.95,127.2
  IN4 w0.127: v2(193.85,124.3) 193.46,123.9 193.46,122.53 193.69,122.3 193.69,122.3 195.11,120.88 201.65,120.88 202.7,121.93 205.9,121.93 207.57,123.61 207.9,123.61 209.52,125.23 209.52,126.77 209.95,127.2
  BOTTOM w0.102: UV1.K21 214.18,130.6 213.62,130.03 213.15,130.03 213.15,130.04 213.21,130.04 213.21,130.04 v2(213.24,130.04) ; UV5.J3 v2(193.85,124.3)
CKEA1: length 26
  TOP w0.102: v2(193.05,136.09) UV3.J3
  IN4 w0.102: 207.92,133.11 209.01,133.11 209.38,133.48 210.14,133.48 211.21,132.42 211.21,132.36 211.92,131.65 212.47,131.65 v2(212.92,131.2)
  IN4 w0.127: v2(193.05,136.09) 193.44,135.7 193.44,133.51 194.44,132.52 207.33,132.52 207.92,133.11
  BOTTOM w0.102: v2(193.05,136.09) UV3.J3 ; v2(212.92,131.2) 213.45,131.73 UV1.J20
CKEB0: length 38.8
  TOP w0.102: UV7.J3 206.37,164.9 v2(206.77,165.3)
  IN4 w0.102: v2(220.64,139.82) 220.44,139.61 216.92,139.61 216.19,140.34 216.19,142.03 214.66,143.55 214.66,145.29 214.19,145.77 214.19,146.17 213.74,146.62
  IN4 w0.127: 213.74,146.62 213.34,147.01 212.3,147.01 209.95,149.36 208.67,150.64 208.67,150.91 207.91,151.67 207.91,159.09 205.11,161.89 205.11,163.03 204.69,163.45 204.69,164.64 204.95,164.9 206.37,164.9 v2(206.77,165.3)
  BOTTOM w0.102: UV7.J3 206.37,164.9 v2(206.77,165.3) ; UV1.U10 220.47,140 v2(220.64,139.82)
CKEB1: length 30
  TOP w0.102: UV9.J3 v2(227.71,165.3)
  IN1 w0.102: 222.5,147.21 222.5,146.96 222.87,146.59 222.87,144.26 222.68,144.07 222.68,140.23 v2(223.07,139.84)
  IN1 w0.127: v2(227.71,165.3) 227.31,164.9 227.31,164.34 227.06,164.09 226.75,164.09 226.51,163.86 226.51,163.36 226.11,162.95 226.11,162.51 224.51,160.91 224.51,159 223.74,158.24 223.74,155.39 223.16,154.81 223.16,151.82 222.5,151.16 222.5,147.21
  BOTTOM w0.102: v2(223.07,139.84) 223.05,139.81 UV1.AA11 ; UV9.J3 v2(227.71,165.3)
CLK_80H: length 4.1
  TOP w0.089: v2(216.92,71.42) 216.99,71.42 v1(218,70.41) 219.05,69.36 RH159.2
  BOTTOM w0.089: UH1.F36 216.98,71.13 216.98,71.36 v2(216.92,71.42)
CLK_BUF_BCLK: length 10.9
  TOP w0.089: 199.67,82.35 v1(199.67,82.26) ; 199.96,81.75 199.67,82.05
  TOP w0.102: 199.67,82.35 199.67,83.96 199.13,84.49 RPH5.3 ; v2(204.71,76.71) 204.71,77.29 203.47,78.53 203.19,78.53 199.96,81.75 ; 199.67,82.05 v1(199.67,82.26)
  BOTTOM w0.089: v2(204.71,76.71) 204.22,76.71 UH1.AT24
CLK_BUF_BCLK#: length 11.7
  TOP w0.102: v2(205.2,76.27) 205.26,76.34 v1(205.26,76.85) 205.26,77.02 203.47,78.81 203.32,78.81 202.44,79.68 202.44,79.68 200.12,82.01 200.12,84 199.78,84.34 199.78,84.55 RPH5.4
  BOTTOM w0.089: v2(205.2,76.27) 204.63,76.27 UH1.AR24
CLK_BUF_CKSSCD: length 5.9
  BOTTOM w0.089: UH1.BC6 196.9,73.67 196.41,73.67 195.99,74.1 195.2,74.1 194.99,73.89 194,73.89
  BOTTOM w0.102: RH143.1 192.4,74.73 192.98,74.73 193.82,73.89 194,73.89
CLK_BUF_CKSSCD#: length 4.2
  BOTTOM w0.089: UH1.BE6 196.19,74.36 195.16,74.36 194.95,74.16 194.27,74.16
  BOTTOM w0.102: RH141.1 192.99,75.09 193.92,74.16 194.27,74.16
CLK_BUF_DMI: length 9.5
  TOP w0.089: 199.01,81.69 199.44,81.26
  TOP w0.102: v2(203.8,77.63) 203.2,77.63 202.77,78.06 202.77,78.33 202.19,78.9 201.8,78.9 v1(200.09,80.61) 199.44,81.26 ; RPH5.1 198.97,83.24 198.97,81.74 199.01,81.69
  BOTTOM w0.089: v2(203.8,77.63) 203.65,77.48 UH1.AW24
CLK_BUF_DMI#: length 8.6
  TOP w0.089: 199.3,81.98 199.3,81.88 199.66,81.51
  TOP w0.102: RPH5.2 199.3,83.62 199.3,81.98 ; v2(203.34,78.09) 203.31,78.09 202.27,79.13 202.04,79.13 v1(201.79,79.39) 199.66,81.51
  BOTTOM w0.089: v2(203.34,78.09) 203.07,78.09 UH1.AY24
CLK_BUF_DOT96: length 9.9
  TOP w0.089: 219.06,68.47 218.42,69.1 217.36,69.1 216.16,70.29 216.16,70.57 v2(216.3,70.7)
  TOP w0.102: RH138.1 222.53,65.63 222.21,65.95 221.57,65.95 220.07,67.45 219.06,68.47
  BOTTOM w0.089: v2(216.3,70.7) 216.25,70.65 UH1.G33
CLK_BUF_DOT96#: length 10.6
  TOP w0.089: 218.88,68.29 218.82,68.35 218.82,68.36 218.81,68.36 218.81,68.37 218.32,68.86 217.46,68.86 217.26,68.86 215.92,70.19 215.92,70.36 215.87,70.41 v2(215.87,71.15)
  TOP w0.102: RH136.1 222.34,65.46 222.1,65.7 221.47,65.7 v4(219.89,67.27) 218.88,68.29
  BOTTOM w0.089: UH1.H33 215.75,71.07 215.84,71.16 215.88,71.16 215.88,71.14 215.86,71.14 215.86,71.15 v2(215.87,71.15)
CLK_CPU_DMI: length 61.5
  TOP w0.102: RC48.2 176.39,102.81 177.11,102.81 177.5,103.2 177.5,103.29 v2(177.97,103.76)
  IN2 w0.089: v2(211.67,78.76) 211.52,78.91 211.52,79.06 211.88,79.42 211.88,84.02 211.78,84.13
  IN2 w0.127: 211.78,84.13 211.78,89.96 213.33,91.52 213.33,96.99 209.83,100.49 205.35,100.49 204.31,101.54 201.46,101.54 200.6,102.39 197.44,102.39 197.32,102.51 194.75,102.51 193.96,103.3 188.11,103.3 187.99,103.19 181.23,103.19 180.72,102.68 180.18,102.68 179.67,103.19 177.64,103.19 177.55,103.28 177.55,103.48 177.83,103.76 v2(177.97,103.76)
  BOTTOM w0.089: UH1.AF40 211.84,78.59 v2(211.67,78.76)
CLK_CPU_DMI#: length 61.5
  TOP w0.102: v2(177.25,103.77) 177.25,103.25 177.01,103.01 176.86,103.01 176.74,103.13 176.74,103.45 176.42,103.77 RC46.2
  IN2 w0.089: 211.47,84.13 211.47,84.12 211.49,84.1 211.49,84.01 211.62,83.89 211.62,79.53 211.26,79.17 v2(211.26,78.35)
  IN2 w0.127: 211.47,84.13 211.47,90.09 213.03,91.64 213.03,96.86 209.7,100.19 205.23,100.19 204.19,101.23 201.33,101.23 200.48,102.08 197.32,102.08 197.19,102.21 194.62,102.21 193.84,103 188.23,103 188.12,102.88 181.35,102.88 180.84,102.37 180.06,102.37 179.55,102.88 177.52,102.88 177.25,103.15 v2(177.25,103.77)
  BOTTOM w0.089: v2(211.26,78.35) 211.26,78.35 211.26,78.35 211.45,78.17 UH1.AF39
CLK_CPU_DPLL: length 78.2
  IN2 w0.089: v2(210.34,77.42) 210.34,77.32 210.42,77.23 210.62,77.23 210.76,77.37 211.52,77.37 211.64,77.25 212.3,77.25 212.93,77.88 212.93,80.05 212.66,80.33 212.66,82.46 212.33,82.79 212.33,83.17 212.31,83.19 212.31,83.28 212.29,83.3 212.29,83.31
  IN2 w0.102: 168.4,106.93 168.38,106.93 168.37,106.95 168.28,106.95 168.26,106.96 168.03,106.96 167.38,106.31 166.48,106.31 166.2,106.59 166.2,107 166.12,107.07 165.89,107.07 v2(165.73,106.92)
  IN2 w0.127: 212.29,83.31 212.29,89.36 213.98,91.05 213.98,97.28 209.16,102.1 201.72,102.1 200.82,103 197.86,103 197.8,103.06 194.93,103.06 194.12,103.87 187.96,103.87 187.78,103.7 182.51,103.7 182.18,104.03 180.89,104.03 177.99,106.93 168.4,106.93
  BOTTOM w0.089: JCPU1.H28 165.26,106.45 v2(165.73,106.92) ; 210.93,77.32 210.77,77.16 210.65,77.16 210.39,77.42 v2(210.34,77.42)
CLK_CPU_DPLL#: length 78.3
  IN2 w0.089: 212.59,83.31 212.59,82.91 212.92,82.58 212.92,80.44 213.2,80.16 213.2,77.77 212.41,76.99 211.53,76.99 211.41,77.11 210.87,77.11 210.73,76.97 v2(209.95,76.97)
  IN2 w0.102: v2(166.66,107) 166.48,106.82 166.48,106.71 166.6,106.59 167.27,106.59 167.92,107.24 168.4,107.24
  IN2 w0.127: 168.4,107.24 178.11,107.24 181.02,104.33 182.3,104.33 182.63,104 187.65,104 187.83,104.18 194.24,104.18 195.05,103.37 197.92,103.37 197.99,103.3 200.95,103.3 201.85,102.4 209.28,102.4 214.28,97.4 214.28,90.92 212.59,89.23 212.59,83.31
  BOTTOM w0.089: v2(166.66,107) 166.2,106.54 JCPU1.G28 ; UH1.AF35 210.01,76.9 v2(209.95,76.97)
CLK_CPU_ITP: length 129.3
  TOP w0.089: 214.16,82.96 214.16,82.96 214.32,82.79 214.78,82.79 214.85,82.87 214.85,83.11 214.77,83.19 v2(214.59,83.19)
  TOP w0.102: v2(208.38,100.93) 208.21,100.76 208.21,99.52 209.49,98.25 209.49,95.54 209.08,95.13 209.08,94.33 210.2,93.21 211.31,93.21 215.04,89.48 215.04,87.27 214.6,86.83 214.6,85.55 214.16,85.1 214.16,82.96
  IN4 w0.114: v2(208.38,100.93) 208.38,100.86 207.79,100.28 207.2,100.28 206.58,100.9 203.66,100.9 198.24,106.32 189.78,106.32 188.84,107.25 188.84,108.76 188.36,109.25 184.93,109.25 183.85,108.17 179.8,108.17 177.91,110.06 176.44,110.06 174.67,111.82 174.67,113.73 171.03,117.37 159.34,117.37 157.92,118.8 151.6,118.8 151.44,118.96 149.15,118.96 148.38,119.74 148.03,119.74 147.63,119.34 145.35,119.34 145.02,119.01 143.78,119.01 143.3,118.53 142.67,118.53 141.96,119.24 140.08,119.24 139.28,118.44 138.46,118.44 138.05,118.85 134.09,118.85 133.7,118.45 125.45,118.45 125.37,118.37 v2(125.37,118.2)
  BOTTOM w0.089: UH1.AH45 213.15,80.49 213.65,80.99
  BOTTOM w0.102: RH1.2 123.63,113.8 123.96,113.8 124.16,114 124.16,114.6 124.54,114.99 124.54,115.3 125.2,115.96 125.2,118.03 v2(125.37,118.2) ; v2(214.59,83.19) 214.77,83.19 214.84,83.12 214.84,82.91 214.71,82.77 214.71,82.54 214.38,82.21 214.38,81.36 214.19,81.17 213.83,81.17 213.65,80.99
CLK_CPU_ITP#: length 129.3
  TOP w0.089: v2(215.09,82.55) 214.22,82.55 213.9,82.87 ; 213.9,82.95 213.9,82.96
  TOP w0.102: 213.9,82.87 213.9,82.95 ; 213.9,82.96 213.9,85.21 214.35,85.65 214.35,86.94 214.79,87.38 214.79,89.37 211.2,92.96 210.09,92.96 208.83,94.23 208.83,95.24 209.23,95.64 209.23,98.14 207.96,99.42 207.96,100.76 v2(207.79,100.93)
  IN4 w0.089: 173.36,115.46 173.59,115.22
  IN4 w0.114: v2(207.79,100.93) 207.79,100.69 207.67,100.57 207.32,100.57 206.7,101.19 203.78,101.19 198.36,106.61 189.9,106.61 189.14,107.37 189.14,108.88 188.48,109.54 184.81,109.54 183.73,108.46 179.92,108.46 178.03,110.35 176.56,110.35 174.96,111.94 174.96,113.85 173.59,115.22 ; v2(124.79,118.2) 125.33,118.74 133.58,118.74 133.97,119.14 138.17,119.14 138.58,118.73 139.16,118.73 139.96,119.53 142.08,119.53 142.79,118.82 143.18,118.82 143.66,119.3 144.9,119.3 145.23,119.63 147.51,119.63 147.91,120.03 148.5,120.03 149.27,119.25 151.56,119.25 151.72,119.09 158.04,119.09 159.46,117.67 171.15,117.67 173.36,115.46
  BOTTOM w0.089: 212.39,79.85 212.48,79.85 212.82,80.19 213.15,80.19 213.54,80.57
  BOTTOM w0.102: RH2.2 123.63,114.06 123.86,114.06 123.91,114.11 123.91,114.71 124.29,115.09 124.29,115.41 124.95,116.07 124.95,118.03 v2(124.79,118.2) ; v2(215.09,82.55) 215.09,82.55 214.61,82.08 214.61,81.28 214.28,80.95 213.91,80.95 213.54,80.57
CLK_CPU_SSC_DPLL: length 63.9
  TOP w0.102: RC44.2 179.37,105.82 179.64,105.82 180.07,105.38 180.07,102.03 179.62,101.59 178.61,101.59 178.24,101.96 178.24,102.15 v2(178.06,102.32)
  IN2 w0.089: 210.91,83.84 210.93,83.83 210.93,83.21 211.16,82.99 211.16,80.26 211.02,80.12 210.8,80.12 210.5,79.82 210.5,79.43 210.56,79.36 v2(210.56,79.04)
  IN2 w0.127: v2(178.06,102.32) 178.06,101.66 178.72,101 181.52,101 182.58,102.07 188.49,102.07 188.59,102.17 193.33,102.17 195.08,100.42 202.79,100.42 203.86,99.35 208.51,99.35 212.03,95.83 212.03,92.57 210.56,91.1 210.56,84.19 210.91,83.84
  BOTTOM w0.089: v2(210.56,79.04) 210.74,78.86 211.08,78.86
CLK_CPU_SSC_DPLL#: length 63.8
  TOP w0.102: RC42.2 178.66,105.26 178.66,105.46 178.76,105.56 179.53,105.56 179.81,105.28 179.81,102.14 179.52,101.84 178.71,101.84 178.49,102.06 178.49,102.17 v2(178.65,102.32)
  IN2 w0.089: v2(210.99,79.44) 210.87,79.44 210.76,79.54 210.76,79.71 210.91,79.86 211.13,79.86 211.43,80.15 211.43,83.1 211.2,83.32 211.2,83.99 211.16,84.03
  IN2 w0.127: 211.16,84.03 210.87,84.32 210.87,90.97 212.34,92.44 212.34,95.95 208.64,99.66 203.98,99.66 202.92,100.72 195.21,100.72 193.45,102.48 188.46,102.48 188.36,102.37 182.46,102.37 181.39,101.31 178.85,101.31 178.37,101.79 178.37,102.04 178.65,102.32 v2(178.65,102.32)
  BOTTOM w0.089: v2(210.99,79.44) 210.99,79.35 211.17,79.17 211.39,79.17 211.5,79.28
CLK_DDC2_CRT: length 178.6
  TOP w0.102: JBTB1.9 56.5,203.21 v2(55.99,202.7) ; U6.14 188.25,173.11 188.59,173.46 190.49,173.46 191.12,174.08 v1(191.12,175.04) 191.12,175.33 190.29,176.16 189.54,176.16 187.69,178.01 v2(187.69,178.54)
  IN2 w0.127: v2(187.69,178.54) 187.69,178.74 187.32,179.11 187.32,179.57 184.97,181.93 181.92,181.93 181.22,182.63 178.8,182.63 178.58,182.85 177.63,182.85 177.54,182.77 173.85,182.77 173.36,182.28 173.36,181.72 172.88,181.24 171.91,181.24 170.83,180.16 170.32,180.16 169.32,179.16 169.32,177.12 164.06,171.86 158.44,171.86 157.6,171.02 154.75,171.02 154.27,170.54 150.06,170.54 149.45,169.93 148.27,168.74 144.02,168.74 143.82,168.54 137.49,168.54 135.78,166.84 120.11,166.84 119.31,167.64 107.44,167.64 106.73,166.93 101.99,166.93 101.03,165.96 92.2,165.96 86.76,171.4 86.3,171.4 81.81,175.89 73.03,175.89 65.92,183.01 63.47,183.01 60.69,185.79 60.69,199.28 58.02,201.94 56.75,201.94 v2(55.99,202.7)
CLK_DDC2_DOCK: length 25.2
  TOP w0.102: v2(178.57,187.58) 178.92,187.58 181.25,185.25 181.25,182.19 183.53,179.91 v1(184.73,179.91) 185.5,179.91 186.63,178.77 186.63,178.41 189.24,175.81 190.14,175.81 190.75,175.2 190.75,174.28 190.28,173.81 188.44,173.81 188.14,173.51 U6.15
  BOTTOM w0.102: v2(178.57,187.58) 178.75,187.76 JDOCK1.48
CLK_ENABLE#_VGA: length 3.8
  BOTTOM w0.203: PR620.2 313.58,167.49 v1(313.58,166.75) 313.58,166.28 313.23,165.93 312.22,165.93 312.04,165.75 PU600.40
CLK_KBD: length 165.7
  TOP w0.102: U51.A38 281.64,115.16 281.49,115.01 281.22,115.01 280.68,115.55 v2(280.68,115.65) 280.37,115.96 R845.2
  IN2 w0.127: v2(277.73,173.62) 277.73,173.76 275.15,176.34 262.54,176.34 261.96,176.92 255.67,176.92 255.65,176.95 248.52,176.95 248.43,176.85 237.67,176.85 v2(237.17,176.35)
  IN4 w0.102: v2(280.68,115.65) 279.79,115.65 279.14,116.3 279.14,119.7 277.38,121.46 277.38,123.1 276.82,123.66 276.82,126.21 276.92,126.31 276.92,130.92 276.93,130.93 276.93,131.73 276.92,131.74 276.92,134.28 277.47,134.83 277.47,139.95 277.63,140.11 277.63,146.07 276.91,146.79 276.91,165.04 278.14,166.27 278.14,170 277.91,170.23 277.91,173.44 v2(277.73,173.62)
  BOTTOM w0.102: JDOCK1.78 187.25,187.88 187.66,187.46 187.66,186.68 190.86,183.48 193.05,183.48 193.33,183.75 200.23,183.75 200.34,183.86 203,183.86 203.13,183.73 204.09,183.73 206.36,181.47 206.36,180.41 212.95,173.82 221.15,173.82 221.69,173.29 231.92,173.29 232.3,173.67 234.49,173.67 v1(235.56,174.74) v2(237.17,176.35)
