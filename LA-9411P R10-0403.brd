# Allegro board LA-9411P R10-0403.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
DPC_CPU_LANE_N2_C: length 1.3
  TOP w0.102: C686.2 172.93,189.22 172.93,189.49 173.11,189.67 RE22.2
DPC_CPU_LANE_N3: length 102.9
  TOP w0.102: v2(178.47,182.35) 178.29,182.53 178.29,182.86 174.97,186.18 174.97,187.49 C694.1
  IN1 w0.089: 154.26,115.46 154.26,115.44 154.27,115.43 154.27,115.26 154.34,115.19 154.34,114.82 154.12,114.6 154.12,111.68 154.47,111.33 155.09,111.33 155.5,111.74 155.5,111.84 155.58,111.92 v2(155.67,111.92)
  IN1 w0.114: v2(178.47,182.35) 178.47,182.89 177.5,183.86 168.94,183.86 165.94,180.86 165.94,178.32 166.11,178.15 166.11,177.15 165.94,176.98 165.94,148.44 165.65,148.15 165.65,141.19 165.94,140.9 165.94,129.33 164.26,127.65 164.26,127.29 164.41,127.14 164.41,126.97 164.17,126.73 164.01,126.73 163.85,126.89 163.5,126.89 163.12,126.51 163.12,126.16 163.28,126 163.28,125.84 163.04,125.6 162.88,125.6 162.72,125.76 162.37,125.76 160.78,124.17 160.78,123.82 160.94,123.66 160.94,123.5 160.7,123.26 160.54,123.26 160.38,123.42 160.03,123.42 159.65,123.04 159.65,122.69 159.81,122.53 159.81,122.37 159.57,122.13 159.4,122.13 159.25,122.28 158.89,122.28 158.52,121.91 158.52,121.56 158.68,121.4 158.68,121.24 158.43,120.99 158.27,120.99 158.11,121.15 157.76,121.15 156.22,119.61 156.22,119.25 155.24,118.27 155.24,117.8 154.59,117.16 154.59,116.13 154.26,115.79 154.26,115.46
  BOTTOM w0.089: JCPU1.U33 155.73,111.92 v2(155.67,111.92)
DPC_CPU_LANE_N3_C: length 1.4
  TOP w0.102: C694.2 174.98,189.2 174.98,189.58 175.08,189.67 RE24.2
DPC_CPU_LANE_P0: length 90.6
  TOP w0.102: C691.1 168.66,187.49 168.66,186.88 169.49,186.05 170.55,186.05 171.99,184.61 171.99,184.19 171.97,184.17 171.97,183.62 171.99,183.6 171.99,182.29 v2(171.8,182.1)
  IN1 w0.089: v2(155.73,112.92) 156.07,112.92 156.15,113.01 156.15,114.4 156.51,114.75 156.51,115.4
  IN1 w0.114: 156.51,115.4 156.51,116.78 157.15,117.42 157.15,117.54 167.39,127.78 167.39,141.62 167.5,141.72 167.5,143.13 167.37,143.26 167.37,146.96 167.51,147.1 167.51,148.79 167.39,148.91 167.39,174.42 167.64,174.67 168.16,174.67 168.28,174.8 168.28,175.11 168.16,175.24 167.64,175.24 167.39,175.49 167.39,176.02 167.64,176.27 168.42,176.27 168.55,176.4 168.55,176.71 168.42,176.84 167.85,176.84 167.64,177.06 167.64,177.93 169.97,180.26 169.97,180.42 169.26,181.13 169.26,181.48 169.63,181.86 169.99,181.86 170.7,181.15 170.86,181.15 171.14,181.43 171.68,181.43 171.9,181.65 171.9,182 v2(171.8,182.1)
  BOTTOM w0.089: v2(155.73,112.92) JCPU1.U34
DPC_CPU_LANE_P0_C: length 1.4
  TOP w0.102: RE17.2 168.54,189.67 168.66,189.55 168.66,189.21 C691.2
DPC_CPU_LANE_P1: length 90.7
  TOP w0.102: C682.1 170.69,187.49 170.69,187.11 172.11,185.7 172.11,185.67 172.6,185.18 172.63,185.18 173.19,184.62 173.19,183.81 174.09,182.91 174.09,182.29 v2(173.87,182.07)
  IN1 w0.089: v2(154.73,113.92) 155.01,113.92 155.2,114.11 155.2,114.3 155.42,114.52 155.65,114.52 155.74,114.6 155.74,114.83 155.39,115.18 155.39,115.35 155.38,115.37 155.38,115.43 155.37,115.44 155.37,115.46
  IN1 w0.114: v2(173.87,182.07) 173.87,181.58 173.71,181.42 173.55,181.42 173.19,181.79 173.19,182.41 172.75,182.84 169.55,182.84 169.45,182.73 169.38,182.73 167.2,180.56 167.2,178.56 166.86,178.22 166.86,176.79 166.66,176.59 166.66,148.11 166.42,147.86 166.42,141.48 166.66,141.23 166.66,128.2 158.37,119.91 158.21,119.91 158.06,120.06 157.71,120.06 157.33,119.68 157.33,119.33 157.48,119.18 157.48,119.02 156.4,117.93 156.4,117.73 155.77,117.11 155.77,116.17 155.69,116.08 155.57,116.08 155.37,115.88 155.37,115.46
  BOTTOM w0.089: v2(154.73,113.92) JCPU1.V35
DPC_CPU_LANE_P1_C: length 1.4
  TOP w0.102: RE19.2 170.65,189.67 170.72,189.6 170.72,189.24 C682.2
DPC_CPU_LANE_P2: length 102.9
  TOP w0.102: v2(175.9,182.06) 176.07,182.23 176.07,182.98 175.76,183.29 175.69,183.29 175.67,183.27 175.12,183.27 175.1,183.29 174.93,183.29 174.3,183.91 174.3,184.62 174.04,184.88 173.27,185.65 173.27,186.51 172.77,187.01 172.77,187.45 C693.1
  IN1 w0.089: 157.53,114.31 157.42,114.31 157.34,114.23 157.34,113.65 157.16,113.47 157.16,113.37 157.4,113.13 157.4,112.88 156.83,112.31 156.32,112.31 156.26,112.24 156.26,111.38 156.12,111.24 156.12,110.78 156.18,110.72 156.28,110.72 v2(156.49,110.93)
  IN1 w0.114: v2(175.9,182.06) 176.26,182.41 176.26,182.52 176.15,182.63 175.73,182.63 175.43,182.33 175.43,181.32 174.3,180.19 171.6,180.19 171.41,180 171.41,177.58 171.16,177.34 170.04,177.34 169.92,177.22 169.92,176.88 170.04,176.76 171.9,176.76 172.16,176.5 172.16,176 171.9,175.74 170.04,175.74 169.92,175.62 169.92,175.28 170.04,175.16 171.53,175.16 171.79,174.9 171.79,174.24 171.53,173.98 169.54,173.98 168.69,173.13 168.69,172.63 168.73,172.59 168.73,154.56 168.44,154.27 168.44,152.97 168.73,152.68 168.73,148.66 168.99,148.39 168.99,128.02 158.49,117.52 158.49,117.35 157.81,116.66 157.81,116.5 158.11,116.19 158.11,115.85 157.91,115.65 157.53,115.65 157.46,115.58 157.46,115.23 157.51,115.19 157.91,115.19 158.12,114.97 158.12,114.57 157.86,114.31 157.53,114.31
  BOTTOM w0.089: v2(156.49,110.93) 156.97,110.45 JCPU1.T32
DPC_CPU_LANE_P2_C: length 1.3
  TOP w0.102: C693.2 172.72,189.2 172.72,189.52 172.56,189.67 RE21.2
DPC_CPU_LANE_P3: length 102.8
  TOP w0.102: v2(177.88,182.35) 178.08,182.55 178.08,182.77 174.76,186.1 174.76,187.49 C688.1
  IN1 w0.089: 154.49,115.46 154.49,115.44 154.47,115.43 154.47,115.35 154.54,115.28 154.54,114.73 154.33,114.52 154.33,111.76 154.55,111.53 155,111.53 155.3,111.83 155.3,112.27 155.15,112.42 154.86,112.42 154.73,112.29 v2(154.73,111.92)
  IN1 w0.114: v2(177.88,182.35) 178.24,182.71 178.24,182.8 177.41,183.63 169.03,183.63 166.17,180.77 166.17,178.42 166.34,178.24 166.34,177.06 166.17,176.89 166.17,148.34 165.88,148.06 165.88,141.28 166.17,140.99 166.17,129.24 164.48,127.55 164.48,127.39 164.64,127.23 164.64,126.88 164.27,126.5 163.91,126.5 163.76,126.66 163.59,126.66 163.35,126.42 163.35,126.26 163.51,126.1 163.51,125.75 163.13,125.37 162.78,125.37 162.62,125.53 162.46,125.53 161.01,124.08 161.01,123.92 161.17,123.76 161.17,123.41 160.79,123.03 160.44,123.03 160.28,123.19 160.12,123.19 159.88,122.95 159.88,122.78 160.04,122.63 160.04,122.27 159.66,121.9 159.31,121.9 159.15,122.06 158.99,122.06 158.75,121.81 158.75,121.65 158.91,121.49 158.91,121.14 158.53,120.77 158.18,120.77 158.02,120.92 157.86,120.92 156.45,119.51 156.45,119.15 155.47,118.17 155.47,117.71 154.82,117.06 154.82,116.03 154.49,115.7 154.49,115.46
  BOTTOM w0.089: v2(154.73,111.92) JCPU1.V33
DPC_CPU_LANE_P3_C: length 1.4
  TOP w0.102: RE23.2 174.62,189.67 174.77,189.52 174.77,189.23 C688.2
DPC_DOCK_AUX: length 36.2
  TOP w0.102: v2(193.94,173.14) 193.94,173.28 193.52,173.69 193.26,173.69 192.98,173.97 192.98,175.33 193.76,176.11 193.76,176.76 191.55,178.97 191.12,178.97 189.6,180.5 187.24,180.5 186.71,181.03 184.25,181.03 182.5,182.78 182.48,182.78 182.28,182.98 v2(182.28,183.07)
  BOTTOM w0.102: U20.3 193.27,172.46 193.94,173.13 v2(193.94,173.14) 194.61,172.46 195.19,172.46 195.84,173.11 U20.11 ; v2(182.28,183.07) 178.34,183.07 175.38,186.02 175.38,187.79 175.25,187.93 JDOCK1.34
DPC_DOCK_AUX#: length 37.8
  TOP w0.102: v2(182.28,183.88) 182.28,183.69 182.71,183.26 182.71,182.87 184.34,181.24 186.8,181.24 187.33,180.71 189.68,180.71 191.21,179.18 191.64,179.18 193.98,176.85 193.98,176.02 193.19,175.24 193.19,174.06 193.34,173.9 193.56,173.9 193.84,174.18 v2(193.84,174.25) 194.1,174.25 194.29,174.05 194.29,173.77 v2(194.94,173.13)
  BOTTOM w0.102: U20.8 195.82,175.06 195.22,174.46 195.22,173.41 v2(194.94,173.13) ; JDOCK1.36 175.75,187.91 175.59,187.75 175.59,186.11 178.42,183.28 181.84,183.28 182.28,183.72 v2(182.28,183.88) ; v2(193.84,174.25) 193.44,174.25 193.27,174.41 U20.6
DPC_DOCK_LANE_N0: length 4.1
  TOP w0.102: RE18.1 168.96,190.59 168.87,190.67 168.87,191.05 v2(169.06,191.24)
  BOTTOM w0.102: JDOCK1.12 169.75,189.86 169.61,190 169.61,190.31 169.29,190.63 168.99,190.63 168.88,190.75 168.88,191.06 v2(169.06,191.24)
DPC_DOCK_LANE_N1: length 3.9
  TOP w0.102: v2(171.08,191.24) 170.89,191.06 170.89,191 RE20.1
  BOTTOM w0.102: JDOCK1.18 171.25,189.68 171.11,189.83 171.11,189.89 171.37,190.16 171.37,190.63 171.18,190.82 170.95,190.82 170.89,190.89 170.89,191.05 v2(171.08,191.24)
DPC_DOCK_LANE_N2: length 4.2
  TOP w0.102: v2(173.11,191.31) 172.91,191.11 172.91,190.96 173.27,190.59 RE22.1
  BOTTOM w0.102: JDOCK1.24 172.75,189.68 172.61,189.83 172.61,190.08 172.7,190.17 173.05,190.17 173.22,190.35 173.22,190.73 172.93,191.02 172.93,191.13 v2(173.11,191.31)
DPC_DOCK_LANE_N3: length 4.2
  TOP w0.102: v2(175.16,191.27) 174.98,191.09 174.98,190.98 RE24.1
  BOTTOM w0.102: v2(175.16,191.27) 174.94,191.05 174.94,190.42 174.72,190.2 174.21,190.2 174.11,190.1 174.11,190 174.25,189.86 JDOCK1.30
DPC_DOCK_LANE_P0: length 4.1
  TOP w0.102: v2(168.47,191.24) 168.66,191.05 168.66,190.7 168.55,190.59 RE17.1
  BOTTOM w0.102: JDOCK1.10 169.25,189.86 169.39,190 169.39,190.23 169.2,190.42 168.91,190.42 168.67,190.66 168.67,191.04 v2(168.47,191.24)
DPC_DOCK_LANE_P1: length 3.9
  TOP w0.102: RE19.1 170.68,190.98 170.68,191.06 v2(170.49,191.24)
  BOTTOM w0.102: JDOCK1.16 170.75,189.68 170.89,189.83 170.89,189.98 171.16,190.24 171.16,190.54 171.09,190.61 170.87,190.61 170.68,190.8 170.68,191.06 v2(170.49,191.24)
DPC_DOCK_LANE_P2: length 4.2
  TOP w0.102: v2(172.53,191.31) 172.7,191.15 172.7,190.96 RE21.1
  BOTTOM w0.102: JDOCK1.22 172.25,189.68 172.39,189.82 172.39,190.17 172.61,190.38 172.96,190.38 173.01,190.43 173.01,190.64 172.72,190.93 172.72,191.12 v2(172.53,191.31)
DPC_DOCK_LANE_P3: length 4.2
  TOP w0.102: v2(174.57,191.27) 174.77,191.08 174.77,191 RE23.1
  BOTTOM w0.102: JDOCK1.28 173.75,189.86 173.89,190 173.89,190.19 174.12,190.41 174.63,190.41 174.73,190.51 174.73,191.12 v2(174.57,191.27)
DPC_PCH_DOCK_AUX: length 196.3
  IN1 w0.089: v2(219.36,74.89) 219.18,74.71 219.18,74.46 219.32,74.32 219.68,74.32 219.86,74.49 219.86,75.42 219.01,76.27 219.01,77.67 219.31,77.98 219.82,78.48 219.82,78.5 219.86,78.55 219.86,78.57 219.87,78.57
  IN1 w0.114: 219.87,78.57 221.05,79.76 224.49,79.76 232.77,88.04 232.77,89.5 v2(232.39,89.88)
  IN4 w0.114: v2(191.35,172.47) 191.73,172.85 192.3,172.85 192.72,172.43 200.62,172.43 201,172.81 209.15,172.81 210.52,174.18 217.88,174.18 218.26,174.56 237.66,174.56 241.52,178.43 241.52,178.63 242.24,179.34 245.88,179.34 246.03,179.18 251.44,179.18 254.14,176.49 254.14,173.3 253.86,173.02 253.86,162.34 254.05,162.15 254.05,158.5 254.74,157.8 254.74,148.3 252.95,146.51 252.95,138.02 252.51,137.57 252.51,131.52 253.03,131 253.03,116.23 251.44,114.64 251.44,111.4 251.77,111.07 251.77,109.03 246.06,103.31 246.06,100.16 240.47,94.58 234.37,94.58 232.78,92.98 232.78,90.26 v2(232.39,89.88)
  BOTTOM w0.089: v2(219.36,74.89) 219.4,74.93 219.4,75.2 218.99,75.6 218.68,75.6 218.49,75.42 218.43,75.42 218.33,75.32 UH1.K45
  BOTTOM w0.102: v2(191.35,172.47) 190.99,172.83 190.44,172.83 190.39,172.78 190.39,172.52 C357.2
DPC_PCH_DOCK_AUX#: length 196.4
  IN1 w0.089: 220.03,78.41 219.21,77.59 219.21,76.35 220.06,75.5 220.06,74.41 219.77,74.12 219.24,74.12 218.98,74.37 218.98,75.07 v2(218.83,75.22)
  IN1 w0.114: 220.03,78.41 221.15,79.53 224.58,79.53 233,87.95 v2(233,89.88)
  IN4 w0.114: v2(191.33,173.08) 192.4,173.08 192.82,172.66 200.52,172.66 200.9,173.04 209.05,173.04 210.42,174.41 217.79,174.41 218.17,174.79 237.56,174.79 241.3,178.52 241.3,178.72 242.14,179.57 245.98,179.57 246.13,179.41 251.54,179.41 254.36,176.59 254.36,173.2 254.08,172.92 254.08,162.43 254.28,162.24 254.28,158.59 254.97,157.89 254.97,148.21 253.18,146.42 253.18,137.92 252.74,137.48 252.74,131.62 253.26,131.09 253.26,116.14 251.67,114.55 251.67,111.5 252,111.17 252,108.93 246.29,103.22 246.29,100.07 240.56,94.35 234.47,94.35 233.01,92.89 233.01,89.88 v2(233,89.88)
  BOTTOM w0.089: UH1.K43 217.78,74.68 217.85,74.75 217.85,74.96 217.91,75.02 218.3,75.02 218.37,74.94 218.5,74.94 218.58,75.02 218.58,75.17 218.63,75.22 v2(218.83,75.22)
  BOTTOM w0.102: v2(191.33,173.08) 191.3,173.04 190.99,173.04 C360.2
DPC_PCH_DOCK_AUX#_C: length 2.2
  BOTTOM w0.102: U20.5 191.76,173.76 191.19,174.33 C360.1
DPC_PCH_DOCK_AUX_C: length 3.5
  BOTTOM w0.102: v1(191.03,170.18) 190.61,170.6 C357.1 191.45,171.39 191.88,171.81 U20.2
DPC_PCH_DOCK_HPD: length 228.1
  TOP w0.102: C696.1 R758.1 176.87,190.06 176.87,187.85 176.65,187.63 v1(176.65,186.58) v2(176.65,185.79)
  IN1 w0.102: v2(192.83,167.68) 191.82,168.69 188.92,168.69 187.28,170.33 187.28,173.99 186.08,175.2 186.08,176.22 184.26,178.04 184.26,180.35 182.42,182.19 179.94,182.19 177.39,184.73 177.39,185.05 v2(176.65,185.79)
  IN3 w0.089: v2(216.53,73.07) 217.16,73.07 217.31,73.22 217.9,73.22 218.61,73.93 221.94,73.93 221.96,73.95
  IN3 w0.127: v2(192.83,167.68) 193.53,167.68 194.28,166.93 196.56,166.93 197.52,167.89 220.85,167.89 223.52,170.55 225.71,170.55 226.42,171.26 232.28,171.26 233.65,172.63 239.62,172.63 239.67,172.58 246.69,172.58 246.91,172.35 252.14,172.35 254.03,170.46 254.03,163.35 254.59,162.79 254.59,158.72 256.37,156.95 256.37,136.27 255.3,135.2 255.3,131.62 257.2,129.73 257.2,114.52 254.52,111.84 254.52,104.39 248.15,98.02 246.17,98.02 243.18,95.02 243.18,88.18 242.78,87.78 238.8,87.78 236.99,85.98 232.56,85.98 228.98,82.4 228.98,80.33 223.31,74.66 223.06,74.66 222.34,73.95 221.96,73.95
  BOTTOM w0.089: UH1.K38 216.02,73.07 v2(216.53,73.07)
  BOTTOM w0.102: JDOCK1.40 176.75,187.7 176.64,187.59 176.64,185.8 v2(176.65,185.79)
DPD_CA_DET: length 52.8
  TOP w0.102: v2(178.3,175.78) 178.23,175.7 v1(177.1,175.7) 174.99,177.81 174.99,178.62 174.7,178.92 173.16,178.92 172.23,179.84 168.87,179.84 v2(168.46,179.44)
  IN1 w0.102: v2(184.77,178.68) 184.79,178.7 185.15,178.7 187.18,176.67 188.58,176.67 189.33,175.92 v2(189.33,175.21) 189.33,173.75 188.62,173.04 v2(188.62,172.86)
  IN4 w0.102: v2(168.46,179.44) 169.02,179.44 169.99,180.4 177.22,180.4 177.91,179.72 177.91,179.08 180.58,176.42 183.24,176.42 184.77,177.94 v2(184.77,178.68)
  BOTTOM w0.102: v2(188.62,172.86) U23.4 ; JDOCK1.5 168.25,179.64 168.46,179.43 v2(168.46,179.44) ; v2(189.33,175.21) 188.97,175.57 188.49,175.57 188.26,175.34 188.26,174.9 188.17,174.81 U23.1 ; R491.2 178.8,176.29 178.3,175.79 v2(178.3,175.78) 177.82,175.3 177.82,174.9 Q6.2 177.42,174.09 178.14,173.37 178.14,172.73 177.91,172.5 U24.2
DPD_CA_DET#: length 11.3
  BOTTOM w0.102: Q6.1 179.32,176.12 179.69,176.49 R416.2 ; Q6.1 178.62,175.15 178.37,174.89 178.37,173.39 178.61,173.15 U24.4 179.41,172.81 179.41,172.5 179.94,171.97 180.5,171.97 180.74,172.21 U23.10 ; Q6.1 179.56,175.15 v1(180.2,174.51) 180.55,174.16 U23.13
DPD_CPU_LANE_N0: length 77.9
  IN1 w0.089: v2(158.73,107.92) 158.54,107.92 158.25,108.21 158.25,108.33 158.06,108.52 157.55,108.52 157.32,108.75 157.32,109.16 156.98,109.5 156.57,109.5 156.35,109.72 156.35,110.14 156.55,110.35 156.76,110.35 157.26,110.85 157.26,112.14 158.01,112.89 158.01,113.38 158.31,113.68 158.31,114.16 158.61,114.45 158.61,114.86 158.83,115.09 158.83,115.18 158.85,115.19 158.85,115.2
  IN1 w0.114: 158.85,115.2 158.85,115.93 159.05,116.13 159.05,116.73 164.96,122.63 165.2,122.63 165.84,123.28 166.04,123.28 166.69,122.63 167.2,122.63 167.81,123.24 167.81,123.63 166.9,124.55 166.9,124.9 169.72,127.72 169.72,148.7 169.46,148.95 169.46,152.98 169.22,153.23 169.22,153.94 169.46,154.18 169.46,157.64 170.01,158.19 170.01,164.29 169.85,164.45 169.85,165.08 169.46,165.46 169.46,171.04 169.86,171.44 169.86,172.24 169.77,172.33 v2(169.77,172.84)
  BOTTOM w0.089: v2(158.73,107.92) JCPU1.P29
  BOTTOM w0.102: C679.2 169.38,173.52 169.38,173.41 169.55,173.25 169.55,173.06 v2(169.77,172.84)
DPD_CPU_LANE_N0_C: length 2
  BOTTOM w0.102: RE8.2 169.38,176.06 169.38,175.24 C679.1
DPD_CPU_LANE_N1: length 77.6
  IN1 w0.089: 159.6,115.46 159.6,115.43 159.59,115.42 159.59,115.35 159.58,115.34 159.58,115.01 159.28,114.71 159.28,113.7 158.61,113.04 158.61,112.85 157.65,111.89 157.65,110.51 157.32,110.17 157.32,109.73 157.55,109.5 157.97,109.5 159.34,108.14 159.34,107.32 v2(159.73,106.92)
  IN1 w0.114: v2(171.59,173.09) 171.38,172.89 171.38,172.39 170.79,171.79 170.79,166.76 171.05,166.5 171.05,162.92 170.79,162.65 170.79,157.9 170.3,157.42 170.3,149.15 170.44,149.01 170.44,142.6 171.24,141.8 171.24,140.47 170.46,139.69 170.46,127.35 168.55,125.44 168.55,122.5 167.84,121.79 165.17,121.79 159.79,116.41 159.79,115.84 159.6,115.65 159.6,115.46
  BOTTOM w0.089: v2(159.73,106.92) JCPU1.N28
  BOTTOM w0.102: C683.2 171.41,173.52 171.41,173.28 171.59,173.11 v2(171.59,173.09)
DPD_CPU_LANE_N1_C: length 2
  BOTTOM w0.102: C683.1 171.41,175.24 171.41,176.06 RE10.2
DPD_CPU_LANE_N2: length 78.8
  IN1 w0.089: v2(158.73,109.92) 158.43,109.92 158.28,110.07 158.28,110.27 158.05,110.5 158.05,111.67 159.07,112.69 159.07,112.86 159.74,113.53 159.74,114.32 160.37,114.95 160.37,115.39 160.43,115.46
  IN1 w0.114: 160.43,115.46 160.56,115.58 160.56,116.15 165.39,120.98 168.38,120.98 170.12,122.71 170.12,123.3 169.35,124.07 169.35,124.25 169.58,124.47 169.76,124.47 170.68,123.55 171.05,123.55 171.51,124.01 171.51,124.38 170.18,125.71 170.18,126.01 171.18,127.01 171.18,136.86 172.37,138.06 172.37,141.75 171.59,142.54 171.59,162.36 171.78,162.55 171.78,166.94 171.51,167.21 171.51,171.16 171.68,171.34 172.48,171.34 173.6,172.46 v2(173.6,173.22)
  BOTTOM w0.089: v2(158.73,109.92) JCPU1.P31
  BOTTOM w0.102: v2(173.6,173.22) 173.44,173.38 173.44,173.55 173.82,173.93 C685.2
DPD_CPU_LANE_N2_C: length 2
  BOTTOM w0.102: RE14.2 173.44,176.06 173.44,175.24 C685.1
DPD_CPU_LANE_N3: length 78.8
  IN1 w0.089: 161.67,115.46 161.67,115.37 161.45,115.15 161.03,115.15 160.78,114.9 160.78,114.56 160.9,114.43 160.9,113.94 160.32,113.36 160.32,112.67 159.95,112.31 159.38,112.31 158.44,111.37 158.44,110.76 158.6,110.6 158.87,110.6 159.32,110.16 159.32,109.42 159.13,109.23 159.13,108.9 159.48,108.55 159.69,108.55 159.77,108.64 159.77,108.78 v2(159.61,108.95)
  IN1 w0.114: v2(175.62,173.24) 175.27,172.88 175.27,172.22 174.81,171.77 173.97,171.77 172.89,170.69 172.89,164.66 172.75,164.52 172.75,162.48 172.32,162.05 172.32,157.69 172.49,157.52 172.49,142.82 173.12,142.18 173.12,136.45 172.32,135.65 172.32,127.92 172.33,127.91 172.33,127.38 172.32,127.38 172.32,123.63 172.19,123.49 168.87,120.18 165.66,120.18 161.67,116.19 161.67,115.46
  BOTTOM w0.089: v2(159.61,108.95) 160.14,108.42 160.18,108.42 160.2,108.44 JCPU1.N30
  BOTTOM w0.102: C689.2 175.46,173.51 175.46,173.41 v2(175.62,173.24)
DPD_CPU_LANE_N3_C: length 2
  BOTTOM w0.102: C689.1 175.48,175.24 175.48,176.06 RE16.2
DPD_CPU_LANE_P0: length 77.9
  IN1 w0.089: 158.62,115.2 158.62,115.16 158.4,114.94 158.4,114.54 158.11,114.24 158.11,113.77 157.81,113.46 157.81,112.97 157.06,112.23 157.06,110.93 156.68,110.55 156.47,110.55 156.14,110.22 156.14,109.64 156.49,109.3 156.9,109.3 157.12,109.07 157.12,108.66 157.46,108.32 157.98,108.32 158.05,108.25 158.05,108.09 157.88,107.92 v2(157.73,107.92)
  IN1 w0.114: v2(169.18,172.84) 169.54,172.48 169.54,172.24 169.63,172.14 169.63,171.53 169.24,171.14 169.24,165.37 169.62,164.99 169.62,164.36 169.78,164.19 169.78,158.29 169.24,157.74 169.24,154.27 168.99,154.03 168.99,153.13 169.24,152.89 169.24,148.86 169.49,148.6 169.49,127.82 166.67,125 166.67,124.45 167.58,123.54 167.58,123.34 167.11,122.86 166.78,122.86 166.14,123.51 165.75,123.51 165.1,122.86 164.86,122.86 158.82,116.82 158.82,116.22 158.62,116.02 158.62,115.2
  BOTTOM w0.089: v2(157.73,107.92) JCPU1.R29
  BOTTOM w0.102: v2(169.18,172.84) 169.34,173 169.34,173.16 169.17,173.33 169.17,173.52 C690.2
DPD_CPU_LANE_P0_C: length 2
  BOTTOM w0.102: RE7.2 169.17,176.06 169.17,175.24 C690.1
DPD_CPU_LANE_P1: length 77.6
  IN1 w0.089: v2(158.73,106.92) 159.13,107.32 159.13,108.05 157.89,109.3 157.47,109.3 157.11,109.65 157.11,110.25 157.45,110.59 157.45,111.97 158.41,112.93 158.41,113.12 159.08,113.79 159.08,114.8 159.37,115.09 159.37,115.46
  IN1 w0.114: v2(171,173.09) 171.15,172.94 171.15,172.48 170.56,171.89 170.56,166.67 170.82,166.4 170.82,163.01 170.56,162.74 170.56,157.99 170.07,157.51 170.07,149.05 170.21,148.91 170.21,142.51 171.01,141.71 171.01,140.57 170.23,139.78 170.23,127.44 168.32,125.54 168.32,122.6 167.74,122.02 165.08,122.02 159.56,116.5 159.56,115.93 159.37,115.75 159.37,115.46
  BOTTOM w0.089: v2(158.73,106.92) JCPU1.P28
  BOTTOM w0.102: v2(171,173.09) 171.19,173.28 171.19,173.54 C681.2
DPD_CPU_LANE_P1_C: length 2
  BOTTOM w0.102: RE9.2 171.2,176.06 171.2,175.24 C681.1
DPD_CPU_LANE_P2: length 78.9
  IN1 w0.089: 160.17,115.46 160.17,115.04 159.53,114.4 159.53,113.61 158.87,112.95 158.87,112.78 157.84,111.76 157.84,110.42 158.07,110.19 158.07,110.07 157.92,109.92 v2(157.73,109.92)
  IN1 w0.114: 160.17,115.46 160.17,115.52 160.33,115.68 160.33,116.25 165.29,121.21 168.29,121.21 169.89,122.81 169.89,123.21 169.12,123.97 169.12,124.34 169.48,124.7 169.85,124.7 170.77,123.78 170.95,123.78 171.28,124.1 171.28,124.28 169.95,125.62 169.95,126.1 170.95,127.11 170.95,136.96 172.14,138.15 172.14,141.66 171.36,142.44 171.36,162.45 171.55,162.64 171.55,166.85 171.28,167.11 171.28,171.26 171.59,171.56 172.39,171.56 173.38,172.55 173.38,172.86 v2(173.02,173.22)
  BOTTOM w0.089: v2(157.73,109.92) JCPU1.R31
  BOTTOM w0.102: C692.2 173.23,173.53 173.23,173.42 v2(173.02,173.22)
DPD_CPU_LANE_P2_C: length 2
  BOTTOM w0.102: RE13.2 173.23,176.06 173.23,175.24 C692.1
DPD_CPU_LANE_P3: length 78.7
  IN1 w0.089: 161.44,115.46 161.44,115.43 161.37,115.35 160.95,115.35 160.57,114.98 160.57,114.47 160.7,114.34 160.7,114.03 160.12,113.44 160.12,112.76 159.87,112.51 159.3,112.51 158.24,111.45 158.24,110.68 158.52,110.4 158.79,110.4 159.11,110.08 159.11,109.51 158.92,109.32 158.92,108.82 159.4,108.34 159.63,108.34 159.74,108.24 v2(159.74,107.94)
  IN1 w0.114: v2(175.04,173.24) 175.04,172.32 174.72,172 173.88,172 172.66,170.78 172.66,164.75 172.53,164.61 172.53,162.58 172.09,162.15 172.09,157.59 172.26,157.43 172.26,142.72 172.89,142.09 172.89,136.54 172.09,135.74 172.09,127.82 172.1,127.82 172.1,127.48 172.09,127.47 172.09,123.72 168.78,120.41 165.57,120.41 161.51,116.35 161.44,116.28 161.44,115.46
  BOTTOM w0.089: JCPU1.P30 159.22,108.45 v2(159.74,107.94)
  BOTTOM w0.102: C687.2 175.25,173.54 175.25,173.45 v2(175.04,173.24)
DPD_CPU_LANE_P3_C: length 2
  BOTTOM w0.102: RE15.2 175.26,176.06 175.26,175.24 C687.1
DPD_DOCK_AUX: length 20.5
  IN1 w0.114: v2(175.37,179.39) 175.69,179.07 176.55,179.07 177.64,177.98 177.64,175.57 179.1,174.11 179.1,173.34 179.36,173.08 179.36,172.25 179.6,172.01 179.84,172.01 180.15,172.31 180.15,172.44 v2(180.06,172.53)
  BOTTOM w0.102: v2(175.37,179.39) 175.4,179.36 175.52,179.36 175.59,179.43 175.59,179.74 175.53,179.81 175.31,179.81 175.25,179.86 JDOCK1.33 ; U23.3 186.45,173.51 186.24,173.3 185.16,173.3 184.51,172.66 183.84,172.66 183.5,173 182.62,173 182.48,172.86 U23.11 180.68,172.86 180.35,172.53 v2(180.06,172.53)
DPD_DOCK_AUX#: length 20.5
  IN1 w0.114: v2(175.42,178.75) 175.51,178.84 176.46,178.84 177.41,177.89 177.41,175.48 178.88,174.02 178.88,173.24 179.13,172.99 179.13,172.16 179.5,171.78 179.69,171.78 179.84,171.63 v2(179.84,171.32)
  BOTTOM w0.102: v2(179.84,171.32) 179.84,171.06 180.01,170.89 v1(180.13,170.89) 180.15,170.91 U23.8 182.25,170.91 182.9,171.56 U23.6 ; v2(175.42,178.75) 175.8,179.13 175.8,179.86 175.75,179.91 JDOCK1.35
DPD_DOCK_LANE_N0: length 3.8
  BOTTOM w0.102: JDOCK1.11 169.75,179.95 169.61,179.81 169.61,179.38 169.36,179.13 169.36,178.87 169.4,178.83 169.4,178.1 169.36,178.07 169.36,177.8 RE8.1
DPD_DOCK_LANE_N1: length 3.8
  BOTTOM w0.102: RE10.1 171.36,177.84 171.36,178.13 171.37,178.15 171.37,178.89 171.36,178.9 171.36,179.46 171.11,179.71 171.11,179.81 171.25,179.95 JDOCK1.17
DPD_DOCK_LANE_N2: length 4.2
  BOTTOM w0.102: RE14.1 173.38,177.85 173.38,178.75 173.11,179.02 172.72,179.02 172.61,179.14 172.61,179.61 172.75,179.76 JDOCK1.23
DPD_DOCK_LANE_N3: length 4.2
  BOTTOM w0.102: JDOCK1.29 174.25,179.76 174.11,179.61 174.11,179.27 v4(174.89,178.48) 175.47,177.9 175.47,177.81 175.88,177.41 RE16.1
DPD_DOCK_LANE_P0: length 3.7
  BOTTOM w0.102: RE7.1 169.15,177.77 v4(169.15,178.45) 169.15,179.22 169.39,179.46 169.39,179.76 169.25,179.91 JDOCK1.9
DPD_DOCK_LANE_P1: length 3.7
  BOTTOM w0.102: RE9.1 171.15,177.73 v4(171.15,178.51) 171.15,179.37 170.89,179.62 170.89,179.77 170.75,179.91 JDOCK1.15
DPD_DOCK_LANE_P2: length 4.2
  BOTTOM w0.102: JDOCK1.21 172.25,179.76 172.39,179.61 172.39,179.05 172.63,178.81 173.02,178.81 173.15,178.68 v4(173.15,178.37) 173.15,177.7 RE13.1
DPD_DOCK_LANE_P3: length 4.2
  BOTTOM w0.102: RE15.1 175.26,177.78 175.26,177.81 175.06,178.01 175.01,178.01 174.48,178.55 174.48,178.6 173.89,179.18 173.89,179.61 173.75,179.76 JDOCK1.27
DPD_PCH_DOCK_AUX: length 199.1
  IN1 w0.089: 219.02,79.42 216.72,77.12 216.72,75.51 218.22,74.02 218.22,73.55 217.94,73.27 217.63,73.27 217.43,73.46 217.43,73.63 217.48,73.69 v2(217.83,73.69)
  IN1 w0.114: v2(231.48,90.49) 230.89,90.49 229.61,89.2 229.61,86.32 223.97,80.67 220.27,80.67 219.02,79.42
  IN4 w0.114: v2(189.89,173.04) 190.39,172.54 190.39,171.7 191.05,171.04 213.29,171.04 215.6,173.35 224.32,173.35 224.69,173.72 238.11,173.72 241.87,177.48 251.58,177.48 253.45,175.61 253.45,174.59 252.98,174.12 252.98,170 253.36,169.62 253.36,162.13 253.55,161.94 253.55,157.83 254.22,157.16 254.22,148.49 252.11,146.37 252.11,142.86 252.43,142.54 252.43,138.56 252.01,138.14 252.01,131.24 252.52,130.73 252.52,116.8 250.91,115.18 250.91,108.87 245.56,103.52 245.56,100.43 240.48,95.35 233.49,95.35 231.69,93.55 231.69,91.75 230.95,91.01 230.95,90.62 231.08,90.49 v2(231.48,90.49)
  BOTTOM w0.089: v2(217.83,73.69) 217.84,73.7 217.84,74.24 218.15,74.56 UH1.J44
  BOTTOM w0.102: C367.2 189.09,173.24 189.4,172.93 189.78,172.93 v2(189.89,173.04)
DPD_PCH_DOCK_AUX#: length 198.9
  IN1 w0.089: 219.19,79.26 216.92,77 216.92,75.6 218.42,74.1 218.42,73.46 218.02,73.06 217.55,73.06 217.04,73.57 v2(217.03,73.57)
  IN1 w0.114: v2(231.47,89.89) 231.1,90.26 230.99,90.26 229.84,89.11 229.84,86.22 224.06,80.44 220.37,80.44 219.19,79.26
  IN4 w0.114: v2(189.89,172.45) 189.97,172.45 190.17,172.26 190.17,171.61 190.96,170.81 213.38,170.81 215.69,173.13 224.42,173.13 224.79,173.49 238.2,173.49 241.96,177.25 251.48,177.25 253.22,175.51 253.22,174.69 252.75,174.22 252.75,169.91 253.13,169.53 253.13,162.04 253.32,161.85 253.32,157.73 254,157.06 254,148.58 251.88,146.47 251.88,142.77 252.2,142.44 252.2,138.65 251.79,138.23 251.79,131.15 252.29,130.64 252.29,116.89 250.68,115.28 250.68,108.96 245.33,103.61 245.33,100.53 240.39,95.58 233.4,95.58 231.46,93.64 231.46,91.85 230.72,91.11 230.72,90.52 230.98,90.26 231.1,90.26 v2(231.47,89.89)
  BOTTOM w0.089: v2(217.03,73.57) 217.06,73.53 217.25,73.53 217.39,73.67 217.39,73.75 217.27,73.88 217.27,73.96 217.39,74.08 UH1.J42
  BOTTOM w0.102: C368.2 189.47,172.68 189.67,172.68 v2(189.89,172.45)
DPD_PCH_DOCK_AUX#_C: length 3.4
  BOTTOM w0.102: v1(189.58,170.23) 189.09,170.73 C368.1 188.26,172.21 U23.5
DPD_PCH_DOCK_AUX_C: length 1.7
  BOTTOM w0.102: U23.2 188.91,174.16 C367.1
DPD_PCH_DOCK_HPD: length 223.4
  TOP w0.102: v1(179.45,169.13) 179.14,168.82 v2(179.14,168.29)
  IN1 w0.102: v2(175.88,178.21) 176.89,177.19 176.89,175.2 177.86,174.23 177.86,170.94 179.11,169.69 179.11,168.6 179.14,168.57 v2(179.14,168.29)
  IN3 w0.089: 222.3,73.61 218.58,73.61 217.84,72.87 217.74,72.87 v2(217.45,72.58)
  IN3 w0.127: 222.3,73.61 222.36,73.61 223.16,74.41 223.71,74.41 229.48,80.19 229.48,81.98 233.02,85.51 236.92,85.51 238.91,87.5 242.87,87.5 243.47,88.1 243.47,94.95 246.28,97.76 248.25,97.76 254.77,104.28 254.77,111.71 257.45,114.39 257.45,129.83 255.55,131.73 255.55,135.09 256.62,136.16 256.62,157.05 255.19,158.49 255.19,164.41 254.49,165.11 254.49,170.37 252.26,172.61 247.02,172.61 246.78,172.85 239.76,172.85 239.73,172.88 232.91,172.88 232.47,172.44 225.04,172.44 220.76,168.16 197.41,168.16 196.52,167.27 194.46,167.27 193.56,168.17 189,168.17 188.01,167.18 187.04,167.18 186.44,166.59 180.84,166.59 v2(179.14,168.29)
  BOTTOM w0.089: v2(217.45,72.58) 217.13,72.9 UH1.H39
  BOTTOM w0.102: JDOCK1.39 176.75,180.03 177.03,179.74 177.03,179.36 v2(175.88,178.21) 176.17,177.91 R757.1 176.91,177.89 177.89,177.89 C695.1
DPRSLPVR_R: length 4.3
  TOP w0.254: v4(312.86,166.56) 312.09,166.56 v1(311.93,166.41) 311.92,166.41 311.39,165.87 PR616.2
  BOTTOM w0.203: v4(312.86,166.56) 312.82,166.52 312.19,166.52 311.64,165.98 PU600.39
DQA0_0: length 29.9
  TOP w0.102: v2(209.9,119.48) 209.57,119.48 208.63,120.42 207.74,120.42 207.12,119.8
  TOP w0.13: UV5.N11 189.9,117.14 189.9,114.72 189.9,114.72 189.9,114.39 190.13,114.16 190.43,114.16 190.72,113.88 190.96,113.88 191.47,113.36 194.47,113.36 194.83,113.72 200.71,113.72 201.42,114.42 201.6,114.42 202.51,115.34 204.8,115.34 205.28,115.82 205.82,115.82 206.87,116.87 207.1,116.87 207.4,117.17 207.4,118 206.99,118.4 206.99,119.67 207.12,119.8
  BOTTOM w0.102: v2(209.9,119.48) 209.45,119.03 UV1.C37
DQA0_1: length 32.4
  TOP w0.102: 187.97,113.79 188.08,113.68
  TOP w0.13: v2(208.91,117.08) 208.99,117 208.99,115.46 205.12,111.59 202.98,111.59 202.44,111.06 190.7,111.06 188.08,113.68 ; UV5.T13 187.85,115.62 187.4,115.16 187.4,114.74 187.38,114.72 187.38,114.38 187.97,113.79
  BOTTOM w0.102: UV1.C35 209.08,119.33 208.42,119.33 207.67,118.57 207.67,118.37 208.91,117.12 v2(208.91,117.08)
DQA0_2: length 26.2
  TOP w0.102: 191.18,114.21 190.85,114.21 190.67,114.39 190.67,115.47 UV5.N13
  TOP w0.13: 191.18,114.21 191.31,114.08 194.06,114.08 194.42,114.44 200.64,114.44 201.37,115.16 201.68,115.16 202.1,115.58 202.1,116.55 202.24,116.68 202.65,116.68 202.78,116.55 202.78,115.93 202.91,115.8 203.3,115.8 203.43,115.93 203.43,116.55 203.56,116.68 203.95,116.68 204.08,116.55 204.08,115.88 204.16,115.8 204.59,115.8 204.73,115.94 204.73,116.55 204.86,116.68 205.9,116.68 206.03,116.81 206.03,117.18 206.15,117.31 206.73,117.31 206.91,117.5 v2(206.91,117.77)
  BOTTOM w0.102: 207.12,117.97 207.44,118.3 207.44,118.64 208.5,119.7 UV1.A35
  BOTTOM w0.13: 207.12,117.97 v2(206.91,117.77)
DQA0_3: length 27.4
  TOP w0.13: UV5.M11 191.05,117.5 190.61,117.94 190.61,119.85 190.94,120.18 201.35,120.18 201.74,119.8 201.74,118.39 202.52,117.6 204.72,117.6 205.58,118.46 205.58,118.46 205.85,118.73 205.85,120.24 207.48,121.88 208.63,121.88 v2(209.42,121.09)
  BOTTOM w0.102: UV1.E34 209.91,120.6 v2(209.42,121.09)
DQA0_4: length 30.2
  TOP w0.13: v2(211.35,122.4) 210.48,122.4 210.02,121.93 210.02,120.71 209.79,120.48 209.13,120.48 208.9,120.71 207.32,120.71 206.43,119.82 206.43,118.58 205.55,117.69 205.55,117.27 205.41,117.14 v1(203.31,117.14) 201.78,117.14 200.87,118.05 200.87,119.39 200.64,119.62 191.7,119.62 191.5,119.42 191.5,116.34 UV5.M13
  BOTTOM w0.102: UV1.G32 211.75,122 v2(211.35,122.4)
DQA0_5: length 38.5
  TOP w0.102: v2(210.52,121.04) 210.5,121.02 210.5,120.04 210.31,119.85 210.31,119.59 210.31,119.58 210.31,119.01 209.34,118.05 209.34,117.14 209.52,116.97 209.52,116.22
  TOP w0.13: UV5.U11 187.46,117.08 187.46,115.76 187.15,115.45 186.6,115.45 186.31,115.16 186.31,114.41 186.86,113.86 186.86,112.74 187.74,111.86 189.25,111.86 190.51,110.6 v1(200.9,110.6) 202.69,110.6 203.16,111.06 205.24,111.06 209.52,115.34 209.52,116.22
  BOTTOM w0.102: UV1.D33 210.12,121.12 210.29,121.12 210.38,121.04 v2(210.52,121.04)
DQA0_6: length 43.3
  TOP w0.102: v2(211.37,121.62) 211.37,118.35 210.59,117.56 210.59,116.22
  TOP w0.13: 210.59,116.22 210.59,115.11 204.25,108.78 v1(202.04,108.78) 195.96,108.78 195.05,109.68 190.13,109.68 188.87,110.94 187.36,110.94 185.67,112.64 185.67,116.62 186.89,117.84 187.5,117.84 UV5.T11
  BOTTOM w0.102: UV1.F32 211.37,121.67 v2(211.37,121.62)
DQA0_7: length 39.9
  TOP w0.102: 210.13,116.22 210.13,116.73 209.69,117.17 209.69,117.65 210.98,118.95 210.98,121.32 v2(210.63,121.68) ; 185.95,115.38 186.46,115.89 UV5.U13
  TOP w0.13: 210.13,116.22 210.13,115.3 204.06,109.23 196.15,109.23 195.25,110.14 190.32,110.14 189.06,111.4 187.55,111.4 186.28,112.68 186.28,113.87 185.95,114.2 185.95,115.38
  BOTTOM w0.102: UV1.E32 210.63,121.82 v2(210.63,121.68)
DQA0_8: length 25.6
  BOTTOM w0.102: 207.12,121.73 207.29,121.9 207.33,121.9 207.68,122.24 207.95,122.24 208.42,122.72 208.9,122.72 208.97,122.64 209.13,122.64 209.2,122.72 209.57,122.72 UV1.D31
  BOTTOM w0.13: UV4.F4 191.05,122.92 191.45,122.52 191.45,121.23 191.86,120.82 195.4,120.82 195.5,120.72 195.5,120.53 195.62,120.41 195.78,120.41 195.9,120.53 195.9,120.72 196,120.82 196.21,120.82 196.31,120.72 196.31,120.54 196.43,120.42 196.6,120.42 196.72,120.54 196.72,120.72 196.82,120.82 197.02,120.82 197.12,120.72 197.12,120.54 197.24,120.42 197.41,120.42 197.53,120.54 197.53,120.72 197.63,120.82 197.89,120.82 198.01,120.7 198.01,120.56 198.14,120.43 198.4,120.43 198.52,120.56 198.52,120.7 198.65,120.82 198.93,120.82 199.06,120.7 199.06,120.52 199.18,120.4 199.45,120.4 199.58,120.52 199.58,120.7 199.7,120.82 200.01,120.82 200.13,120.7 200.13,120.56 200.26,120.43 200.62,120.43 200.74,120.56 200.74,120.7 200.87,120.82 v1(201.81,120.82) 204.36,120.82 204.49,120.95 204.49,121.6 204.62,121.73 204.89,121.73 204.98,121.63 204.98,121.55 205.11,121.43 205.38,121.43 205.51,121.55 205.51,121.65 205.58,121.73 205.8,121.73 205.98,121.55 206.2,121.55 206.37,121.73 207.12,121.73
DQA0_9: length 26.5
  BOTTOM w0.102: UV1.F30 210.49,123.6 210.23,123.34 210.23,122.64 210.09,122.5 209.28,122.5 209.19,122.42 208.91,122.42 208.82,122.5 208.52,122.5 207.61,121.6 207.61,121.42 207.46,121.27 207.12,121.27
  BOTTOM w0.13: 207.12,121.27 206.57,121.27 206.38,121.08 206.38,120.64 206.11,120.36 v1(203.63,120.36) 201.08,120.36 200.74,120.03 195.22,120.03 195.12,120.13 195.12,120.19 195.02,120.29 194.82,120.29 194.71,120.19 194.71,120.13 194.61,120.03 194.41,120.03 194.31,120.13 194.31,120.19 194.21,120.29 194,120.29 193.9,120.19 193.9,120.13 193.8,120.03 193.6,120.03 193.49,120.13 193.49,120.19 193.39,120.29 193.19,120.29 193.09,120.19 193.09,120.13 192.99,120.03 192.78,120.03 192.68,120.13 192.68,120.19 192.58,120.29 191.28,120.29 190.65,120.93 190.65,122.99 190.54,123.1 UV4.E4
DQA0_10: length 25.6
  BOTTOM w0.102: 207.12,122.19 207.17,122.19 207.6,122.62 207.6,122.98 207.95,123.32 208.97,123.32 UV1.C30
  BOTTOM w0.13: UV4.F2 191.32,124.7 191.45,124.57 191.45,122.96 191.71,122.69 192.11,122.69 192.25,122.55 192.25,121.48 192.44,121.28 201.83,121.28 201.96,121.41 201.96,121.73 202.09,121.85 202.35,121.85 202.48,121.73 202.48,121.41 202.61,121.28 202.87,121.28 203,121.41 203,122.07 203.13,122.2 203.39,122.2 203.52,122.07 203.52,121.41 203.64,121.28 203.9,121.28 204.03,121.41 204.03,122.06 204.16,122.19 v1(204.96,122.19) 205.66,122.19 205.88,122.4 206.49,122.4 206.7,122.19 207.12,122.19
DQA0_11: length 25.4
  BOTTOM w0.102: 207.12,122.86 207.2,122.86 207.86,123.52 208.51,123.52 208.65,123.67 UV1.A30 ; 200.63,121.83 200.63,125.25 199.97,125.91 199.25,125.91 198.88,126.29 190.87,126.29 190.73,126.15 190.73,124.83 190.59,124.7 UV4.E2
  BOTTOM w0.13: 200.63,121.83 200.72,121.74 201.04,121.74 201.17,121.87 201.17,122.53 201.29,122.66 201.56,122.66 201.68,122.53 201.68,122.44 201.81,122.31 202.07,122.31 202.2,122.44 202.2,122.53 202.33,122.66 v1(202.78,122.66) 205.28,122.66 205.48,122.86 207.12,122.86
DQA0_12: length 30.8
  BOTTOM w0.102: 186.93,126.63 186.93,126.54 186.7,126.31 186.43,126.31 186.23,126.11 186.23,125.68 186.75,125.16 187.05,125.16 187.51,124.7 UV4.B2 ; 207.12,125.08 209.03,125.08 209.21,124.9 209.23,124.9 209.24,124.89 209.66,124.89 209.77,124.99 210.35,124.99 210.55,125.2 UV1.F28
  BOTTOM w0.13: 186.93,126.63 186.93,127.15 188.06,128.28 199.6,128.28 200.64,127.24 200.64,126.65 201.87,125.43 203.22,125.43 203.82,124.83 204.38,124.83 204.78,125.23 v1(205.71,125.23) 206.13,125.23 206.29,125.08 207.12,125.08
DQA0_13: length 42
  BOTTOM w0.102: UV1.C28 209.45,126.23 209.18,126.5 208.88,126.5 208.86,126.48 208.37,126.48 208.32,126.53 207.03,126.53 ; 185.53,123.28 186.14,122.67 187.42,122.67 UV4.B4
  BOTTOM w0.13: 207.03,126.53 206.75,126.81 202.63,126.81 202.25,127.19 v1(202.25,130.67) 202.25,131.09 200.01,133.34 194.24,133.34 194.01,133.11 187.02,133.11 185.25,131.34 185.25,123.56 185.53,123.28
DQA0_14: length 35.2
  BOTTOM w0.102: UV4.A2 186.49,124.7 186.03,125.16 186.03,126.31 186.25,126.54 186.25,126.63 ; 206.23,125.89 206.8,125.89 207.01,125.68 207.52,125.68 207.81,125.4 UV1.A28
  BOTTOM w0.13: 206.23,125.89 v1(203.07,125.89) 202.25,125.89 201.33,126.81 201.33,130.71 199.66,132.38 194.79,132.38 194.44,132.04 187.41,132.04 186.25,130.89 186.25,126.63
DQA0_15: length 39.9
  BOTTOM w0.102: 206.23,126.35 206.82,126.35 207.02,126.14 207.49,126.14 207.89,125.74 208.88,125.74 209.11,125.5 209.11,125.28 209.29,125.1 209.31,125.1 209.32,125.09 209.58,125.09 209.88,125.39 210.25,125.39 UV1.E28
  BOTTOM w0.13: UV4.A4 187,123.05 186.43,123.05 185.79,123.69 185.79,131.08 187.21,132.5 194.2,132.5 194.55,132.84 199.85,132.84 201.79,130.9 201.79,127 202.44,126.35 v1(204.62,126.35) 206.23,126.35
DQA0_16: length 28.9
  IN1 w0.127: v2(195.45,117.9) 195.05,117.5 195.05,115.35 197.35,113.06 200.67,113.06 200.82,112.9 203.27,112.9 209.51,119.14 209.51,119.95 209.89,120.34 209.89,124.52 210.28,124.9 v2(210.28,125.9)
  BOTTOM w0.102: v2(210.28,125.9) 209.97,126.2 UV1.D27 ; UV4.M11 v2(195.45,117.9)
DQA0_17: length 26.6
  IN1 w0.127: v2(210.26,126.48) 208.91,125.13 208.91,120.13 207.53,118.75 207.53,117.82 203.23,113.51 201.58,113.51 201.32,113.77 197.43,113.77 195.87,115.33 195.87,115.91 v2(196.25,116.29)
  BOTTOM w0.102: UV4.M13 v2(196.25,116.29) ; UV1.F26 210.58,126.8 v2(210.26,126.48)
DQA0_18: length 23.9
  IN1 w0.102: 207.12,125.65 207.18,125.72 207.18,126.84 v2(207.33,126.99)
  IN1 w0.127: v2(197.05,116.29) 197.46,115.89 197.46,114.93 198.15,114.24 201.35,114.24 206.93,119.82 206.93,121.96 207.02,122.05 207.02,125.55 207.12,125.65
  BOTTOM w0.102: v2(207.33,126.99) 207.59,126.74 208.4,126.74 208.46,126.68 208.77,126.68 209.09,127 UV1.C26 ; UV4.N13 v2(197.05,116.29)
DQA0_19: length 20.6
  IN1 w0.127: v2(206.84,127.32) 206.28,127.88 202.45,127.88 201.13,126.56 201.13,122.29 198.06,119.23 196.83,119.23 196.66,119.05 196.66,118.3 v2(196.25,117.9)
  BOTTOM w0.102: UV4.N11 v2(196.25,117.9) ; UV1.A26 208.55,127.1 207.76,127.1 207.35,127.51 207.03,127.51 v2(206.84,127.32)
DQA0_20: length 23.1
  IN1 w0.127: v2(204.56,127.38) 204.55,127.37 204.55,122.85 201.51,119.82 201.51,118.22 200.64,117.36 200.64,116.13 200.41,115.9 200.38,115.9 200.38,115.9 199.85,115.9 v2(199.45,116.29)
  BOTTOM w0.102: UV4.T13 v2(199.45,116.29) ; 207.12,128.84 207.21,128.84 207.56,128.48 208.04,128.48 208.46,128.07 208.89,128.07 208.92,128.1 209.54,128.1 209.73,128.29 210.95,128.29 UV1.F24
  BOTTOM w0.13: v2(204.56,127.38) v1(204.56,128.26) 204.56,128.59 204.81,128.84 207.12,128.84
DQA0_21: length 20.8
  IN1 w0.127: v2(200.25,116.29) 200.25,117.82 200.95,118.51 200.95,119.9 203.54,122.49 203.54,126.15 203.98,126.6 v2(203.98,127.39)
  BOTTOM w0.102: UV4.U13 v2(200.25,116.29) ; 207.12,129.3 207.26,129.3 207.81,128.75 208.07,128.75 208.54,128.27 208.81,128.27 208.84,128.3 209.16,128.3 UV1.C24
  BOTTOM w0.13: 207.12,129.3 v1(205.74,129.3) 204.48,129.3 203.98,128.8 v2(203.98,127.39)
DQA0_22: length 19.4
  IN1 w0.127: v2(199.45,117.9) 199.68,118.12 199.68,119.28 203.04,122.64 203.04,126.3 203.38,126.64 v2(203.38,127.39)
  BOTTOM w0.102: UV4.U11 v2(199.45,117.9) ; UV1.A24 208.24,129.01 207.83,129.01 207.45,129.39 207.45,129.62 207.31,129.76 207.12,129.76
  BOTTOM w0.13: v2(203.38,127.39) v1(203.38,128.85) 204.29,129.76 207.12,129.76
DQA0_23: length 22.3
  IN1 w0.127: v2(198.65,117.9) 199.17,118.41 199.17,119.41 202.59,122.83 202.59,126.49 202.71,126.62 v2(202.71,127.38)
  BOTTOM w0.102: UV1.E24 209.91,128.94 208.7,128.94 208.4,129.23 207.89,129.23 207.65,129.47 207.65,129.91 207.3,130.26 207.12,130.26 ; UV4.T11 v2(198.65,117.9)
  BOTTOM w0.13: 207.12,130.26 v1(204.35,130.26) 204.08,130.26 202.71,128.89 v2(202.71,127.38)
DQA0_24: length 15.9
  TOP w0.102: v2(200.25,123.5) UV5.A4
  IN4 w0.127: v2(210.36,130.72) 210.37,130.72 210.26,130.61 210.26,129.72 209.6,129.06 209.6,128.47 208.31,127.18 208.31,126.9 207.53,126.11 207.53,126.11 207.4,125.98 203.44,125.98 200.95,123.5 v2(200.25,123.5)
  BOTTOM w0.102: UV1.C22 209.59,130.34 209.81,130.34 210.19,130.72 v2(210.36,130.72)
DQA0_25: length 15.8
  TOP w0.102: v2(199.45,123.5) UV5.B4
  IN4 w0.127: v2(209.82,129.88) 209.82,129.61 209.37,129.17 209.37,128.71 208.03,127.37 208.03,126.98 207.52,126.47 206.98,126.47 206.65,126.8 203.31,126.8 200.41,123.9 199.86,123.9 v2(199.45,123.5)
  BOTTOM w0.102: v2(209.82,129.88) 209.11,129.88 208.79,130.2 UV1.A22
DQA0_26: length 18.8
  TOP w0.102: v2(198.65,124.3) UV5.B2
  IN4 w0.127: v2(198.65,124.3) 199.06,124.7 199.69,124.7 199.86,124.87 199.86,126.2 202.04,128.38 207.43,128.38 208.12,129.07 208.63,129.07 209.04,129.48 209.04,130.92 209.61,131.5 210.6,131.5 210.6,131.48 v2(210.62,131.48)
  BOTTOM w0.102: v2(210.62,131.48) 210.61,131.48 210.75,131.35 210.75,130.3 UV1.F22
DQA0_27: length 13.8
  TOP w0.102: v2(200.25,125.1) UV5.A2
  IN4 w0.127: v2(209.43,130.68) 209.43,130.37 209.27,130.2 209.27,129.38 208.73,128.84 208.22,128.84 207.3,127.92 202.23,127.92 200.26,125.95 200.26,125.11 200.27,125.11 v2(200.25,125.1)
  BOTTOM w0.102: v2(209.43,130.68) 209.74,131 UV1.D21
DQA0_28: length 20.2
  TOP w0.102: v2(197.05,123.5) UV5.E4
  IN4 w0.102: 207.21,131.6 207.81,131.6 v2(207.91,131.7)
  IN4 w0.127: v2(197.05,123.5) 196.66,123.89 196.01,123.89 195.86,124.04 195.86,126.84 197.4,128.39 197.4,129.36 198.65,130.61 199.63,130.61 200.62,131.6 207.21,131.6
  BOTTOM w0.102: UV1.A20 208,131.8 v2(207.91,131.7)
DQA0_29: length 23.8
  TOP w0.102: v2(195.45,122.7) UV5.F4
  IN4 w0.127: v2(195.45,122.7) 195.06,123.09 195.06,126.68 196.82,128.45 196.82,129.43 198.46,131.06 199.44,131.06 200.43,132.06 207.42,132.06 v2(207.55,132.19)
  BOTTOM w0.102: v2(207.55,132.19) 207.65,132.1 208.78,132.1 208.79,132.09 209.31,132.09 209.38,132.16 209.57,132.16 209.64,132.09 210.12,132.09 210.13,132.1 210.4,132.1 210.46,132.04 210.8,132.04 UV1.F20
DQA0_30: length 18.7
  TOP w0.102: v2(197.05,125.1) UV5.E2
  IN4 w0.127: v2(209.86,133.1) 209.86,133.1 209.85,133.1 ; 209.85,133.1 209.85,133.1 209.85,133.1 209.85,132.18 208.77,131.1 207.69,131.1 207.28,130.69 201.08,130.69 197.44,127.05 197.44,125.49 v2(197.05,125.1) ; 209.85,133.1 209.85,133.12 209.85,133.1
  BOTTOM w0.102: UV1.D19 209.85,133.1 209.85,133.1 ; 209.85,133.1 209.86,133.1 v2(209.86,133.1) ; 209.85,133.1 209.85,133.12 209.85,133.1
DQA0_31: length 21.5
  TOP w0.102: v2(196.25,124.3) UV5.F2
  IN4 w0.102: v2(208,132.58) 208.34,132.24 208.34,131.57 208.09,131.32 207.29,131.32 207.12,131.15
  IN4 w0.127: v2(196.25,124.3) 196.66,124.7 196.66,126.91 200.89,131.15 207.12,131.15
  BOTTOM w0.102: UV1.E18 210.25,132.56 209.98,132.29 209.72,132.29 209.66,132.36 209.29,132.36 209.23,132.29 208.87,132.29 208.86,132.31 208.27,132.31 v2(208,132.58)
DQA1_0: length 21.2
  IN1 w0.127: v2(195.45,136.9) 195.22,136.9 194.83,136.5 194.5,136.5 194.25,136.26 194.25,134.31 196.05,132.52 201.47,132.52 202.97,134.02 205.7,134.02 206.32,133.4 207.3,133.4 v2(207.49,133.59)
  BOTTOM w0.102: v2(207.49,133.59) 208,133.08 209.01,133.08 209.32,133.4 UV1.C18 ; v2(195.45,136.9) UV6.F4
DQA1_1: length 16.5
  IN1 w0.127: v2(196.25,135.29) 196.25,135.04 195.87,134.66 195.87,134.33 197,133.2 200.35,133.2 200.77,133.62 201.28,133.62 202.59,134.94 206.07,134.94 206.7,134.31 208.05,134.31 v2(208.22,134.14)
  BOTTOM w0.102: v2(208.22,134.14) 208.65,133.71 UV1.A18 ; v2(196.25,135.29) UV6.F2
DQA1_2: length 18.4
  IN1 w0.127: v2(205.33,136.47) 205.06,136.21 202.07,136.21 200.63,134.77 200.63,134.33 200.09,133.79 197.87,133.79 197.46,134.21 197.46,134.89 v2(197.05,135.29)
  BOTTOM w0.102: UV1.F18 210.9,133.75 209.07,133.75 208.75,134.07 208.75,134.39 208.36,134.77 207.16,134.77 207.12,134.81 ; v2(197.05,135.29) UV6.E2
  BOTTOM w0.13: v2(205.33,136.47) 205.33,136.31 206.05,135.59 206.32,135.59 206.32,135.58 206.35,135.58 207.12,134.81
DQA1_3: length 21.2
  IN1 w0.127: v2(209.84,134.7) 209.7,134.7 208.74,133.74 208.06,133.74 207.77,134.04 207.34,134.04 207.16,133.86 206.51,133.86 205.88,134.48 202.78,134.48 201.28,132.98 196.38,132.98 195.06,134.3 195.06,135.47 195.29,135.7 195.62,135.7 195.86,135.94 195.86,136.5 v2(196.25,136.9)
  BOTTOM w0.102: v2(209.84,134.7) 209.84,134.69 209.85,134.68 UV1.D17 ; v2(196.25,136.9) UV6.E4
DQA1_4: length 15.6
  IN1 w0.102: 207.12,135.69 v2(207.22,135.58)
  IN1 w0.127: 207.12,135.69 207.03,135.78 207.03,136.8 206.73,137.11 204.01,137.11 203.57,136.66 201.35,136.66 201.12,136.43 201.12,136.12 199.84,134.85 199.84,134.28 199.59,134.02 198.57,134.02 198.26,134.33 198.26,134.92 v2(198.64,135.31)
  BOTTOM w0.102: UV1.A16 207.6,135 207.22,135.38 v2(207.22,135.58) ; v2(198.64,135.31) 199.05,134.89 UV6.B2
DQA1_5: length 18.6
  IN1 w0.102: 208.91,136.03 208.83,136.11 208.83,138.89 208.29,139.43 207.96,139.43 207.31,138.79 207.12,138.79
  IN1 w0.127: 208.91,136.03 209.28,135.66 210.09,135.66 v2(210.34,135.92) ; v2(199.42,135.31) 199.97,135.85 199.97,136.53 200.34,136.9 200.34,137.79 200.88,138.34 202.87,138.34 203.44,138.9 205.61,138.9 205.73,138.79 207.12,138.79
  BOTTOM w0.102: v2(199.42,135.31) 199.83,134.89 UV6.A2 ; v2(210.34,135.92) 211.05,135.21 UV1.F16
DQA1_6: length 17.4
  IN1 w0.127: v2(198.65,136.9) 199.04,136.5 199.61,136.5 200.11,137 200.11,138.07 200.83,138.8 202.68,138.8 203.25,139.36 205.8,139.36 205.92,139.24 207.46,139.24 208.06,139.84 208.59,139.84 209.05,139.38 209.05,136.48 v2(209.43,136.09)
  BOTTOM w0.102: UV1.D15 209.73,135.8 v2(209.43,136.09) ; v2(198.65,136.9) UV6.B4
DQA1_7: length 16.5
  IN1 w0.127: v2(209.44,137.12) 209.84,137.52 209.84,137.98 209.38,138.44 209.38,139.42 208.72,140.08 207.92,140.08 207.72,140.29 203.53,140.29 202.5,139.25 200.82,139.25 199.88,138.32 199.88,137.33 v2(199.45,136.9)
  BOTTOM w0.102: v2(199.45,136.9) UV6.A4 ; v2(209.44,137.12) 209.63,137.12 210.15,136.6 UV1.E14
DQA1_8: length 26.7
  TOP w0.102: UV3.N11 v2(197.05,142.5)
  IN4 w0.102: 207.12,146.2 207.27,146.2 207.6,145.87 207.6,145.33 211.84,141.09 211.84,138.77 211.46,138.39 211.36,138.39 v2(210.37,137.4)
  IN4 w0.127: v2(197.05,142.5) 197.05,142.72 196.66,143.11 196.66,145.06 197.8,146.2 207.12,146.2
  BOTTOM w0.102: v2(210.37,137.4) 210.54,137.4 210.7,137.24 210.7,137.14 UV1.F14
DQA1_9: length 18.8
  TOP w0.102: UV3.U11 v2(200.25,142.5)
  IN4 w0.102: v2(209.45,137.71) 209.72,137.98 209.72,141.48 207.12,144.08
  IN4 w0.127: v2(200.25,142.5) 200.64,142.89 200.64,143.46 200.4,143.7 200.09,143.7 199.86,143.93 199.86,144.26 200.34,144.74 206.46,144.74 207.12,144.08
  BOTTOM w0.102: UV1.D13 209.76,137.4 v2(209.45,137.71)
DQA1_10: length 21.6
  TOP w0.102: UV3.T11 v2(199.45,142.5)
  IN4 w0.102: 207.13,144.74 210.07,141.81 210.07,138.68 210.37,138.38 210.91,138.38 211.34,138.81 v2(211.34,138.81)
  IN4 w0.127: v2(199.45,142.5) 199.84,142.89 199.84,143.46 199.6,143.7 199.29,143.7 199.06,143.93 199.06,145.06 199.29,145.29 206.59,145.29 207.13,144.74
  BOTTOM w0.102: UV1.F12 211.05,138.5 211.34,138.79 211.34,138.8 211.35,138.81 211.35,138.82 211.34,138.82 211.34,138.81 v2(211.34,138.81)
DQA1_11: length 15.7
  TOP w0.102: UV3.U13 v2(200.25,144.1)
  IN4 w0.102: v2(207.87,137.67) 209.01,138.81 209.01,141.04 207.16,142.89
  IN4 w0.127: v2(200.25,144.1) 206.46,144.1 206.93,143.62 206.93,143.12 207.16,142.89
  BOTTOM w0.102: v2(207.87,137.67) 208.01,137.67 208.29,137.95 208.4,137.95 UV1.A12
DQA1_12: length 20.1
  TOP w0.102: UV3.T13 v2(198.65,143.3)
  IN4 w0.127: v2(198.65,143.3) 198.25,143.7 197.62,143.7 197.46,143.54 197.46,140.83 198.09,140.2 200.64,140.2 201.62,141.17 205.21,141.17 205.44,140.94 v2(205.44,139.78)
  BOTTOM w0.102: 207.12,138.71 207.83,139.42 208.24,139.42 208.38,139.28 208.9,139.28 208.98,139.35 209.4,139.35 209.75,139 UV1.D11
  BOTTOM w0.13: 207.12,138.71 206.35,138.71 205.44,139.61 v2(205.44,139.78)
DQA1_13: length 19.7
  TOP w0.102: UV3.N13 v2(197.05,144.1)
  IN4 w0.102: v2(210.71,139.56) 210.33,139.94 210.33,142.19 210.16,142.37
  IN4 w0.127: 210.16,142.37 207.39,145.14 207.39,145.16 206.8,145.75 198.14,145.75 197.44,145.05 197.44,144.49 v2(197.05,144.1)
  BOTTOM w0.102: UV1.F10 211.05,139.9 v2(210.71,139.56)
DQA1_14: length 16.4
  TOP w0.102: UV3.M11 v2(195.45,141.7)
  IN4 w0.127: v2(195.45,141.7) 195.84,141.3 195.84,141.06 195.84,141.06 195.84,140.73 195.84,140.73 195.84,140.41 196.77,139.48 201.22,139.48 201.87,140.13 203.26,140.13 204.52,138.87 206.14,138.87 v2(206.93,139.66)
  BOTTOM w0.102: 207.12,139.66 207.21,139.66 207.38,139.83 208.62,139.83 UV1.A10
  BOTTOM w0.13: 207.12,139.66 v2(206.93,139.66)
DQA1_15: length 18
  TOP w0.102: UV3.M13 v2(196.25,143.3)
  IN4 w0.127: v2(196.25,143.3) 196.25,143.11 196.66,142.71 196.66,140.91 197.7,139.86 200.96,139.86 201.81,140.72 203.32,140.72 204.71,139.33 205.74,139.33 v2(206.09,139.69)
  BOTTOM w0.102: 207.12,139.19 207.55,139.62 208.39,139.62 208.53,139.48 208.77,139.48 208.85,139.56 209.21,139.56 UV1.C10
  BOTTOM w0.13: v2(206.09,139.69) 206.09,139.68 206.6,139.17 207.1,139.17 207.12,139.19
DQA1_16: length 31.3
  TOP w0.102: v2(212.55,138.46) 212.28,138.72 211.79,138.72 211.39,138.32 210.55,138.32 209.91,137.68 209.91,136.98 209.51,136.58 207.64,136.58 207.12,136.05
  TOP w0.13: UV3.B2 188.25,134.49 188.25,133.29 189.31,132.23 194.48,132.23 194.89,132.64 200.22,132.64 201.7,134.12 201.7,135.03 202.63,135.95 v1(203.56,135.95) 207.02,135.95 207.12,136.05
  BOTTOM w0.102: v2(212.55,138.46) 212.55,138.31 212.04,137.8 UV1.G13
DQA1_17: length 41.5
  TOP w0.102: v2(212.46,137.26) 212.46,137.28 212.9,137.72 213.21,137.72 213.43,137.49 213.43,137.18 212.77,136.51 211.88,136.51 211.5,136.13 211.5,134.74 210.34,133.57 209.61,133.57 209.33,133.29 208.44,133.29 208.12,132.97 207.83,132.97 207.5,132.64 207.12,132.64
  TOP w0.13: 207.12,132.64 203.76,132.64 199.61,128.49 189.27,128.49 185.49,132.27 185.49,135.8 186.09,136.4 186.95,136.4 UV3.A4
  BOTTOM w0.102: v2(212.46,137.26) 212.46,137.49 212.65,137.68 UV1.H13
DQA1_18: length 38.6
  TOP w0.102: v2(213.05,137.33) 213.05,137.28 212.61,136.84 211.76,136.84 211.16,136.25 211.16,134.68 210.67,134.2 209.39,134.2 208.95,133.76 208.28,133.76 207.7,133.18 207.21,133.18
  TOP w0.13: UV3.B4 187.4,136.04 186.39,136.04 185.95,135.6 185.95,132.46 188.71,129.7 200.17,129.7 203.89,133.42 v1(205.47,133.42) 206.98,133.42 207.21,133.18
  BOTTOM w0.102: v2(213.05,137.33) 213.45,137.73 UV1.J13
