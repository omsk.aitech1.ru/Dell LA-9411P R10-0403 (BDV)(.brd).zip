# Allegro board LA-9411P R10-0403.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
GPU_VID_3: length 108
  TOP w0.102: v2(244.32,141.76) v1(244.32,142.37)
  TOP w0.254: v4(309.6,170.47) 309.69,170.47 310.24,171.03 PR618.1
  IN1 w0.102: v4(309.6,170.47) 309.79,170.28 309.79,168.97 310.83,167.93 310.83,165.94 312.44,164.32 312.44,161.68 313.78,160.34 314.3,160.34 315.54,159.11 315.54,157.81 315.16,157.43 315.16,152.82 314.28,151.94 314.28,149.59 v2(315.22,148.65)
  IN2 w0.127: v2(244.32,141.76) 244.38,141.69 245.8,141.69 246.22,141.27 248.86,141.27 250.99,143.4 250.99,144.94 252.15,146.1 252.97,146.1 254.66,144.41 255.44,144.41 261.14,144.41 261.4,144.67 262.88,146.15 274.01,146.15 274.26,145.9 285.59,145.9 289.03,142.46 300.89,142.46 303.7,142.46 304.73,143.48 308.27,143.48 309.21,144.42 311.98,144.42 315.22,147.66 v2(315.22,148.65)
  BOTTOM w0.102: RV39.1 244.23,141.87 244.32,141.78 v2(244.32,141.76)
GPU_VID_4: length 111.8
  TOP w0.254: PR617.1 312.28,171.39 312.63,171.74 v1(313.42,171.74) 313.89,171.74 314.88,170.75 314.9,170.75 v4(314.93,170.73)
  IN1 w0.102: v2(309.56,143.59) 309.53,143.56 309.53,141.99 309.95,141.57 312.68,141.57 318.88,147.77 318.88,154.27 319.27,154.66 319.27,157.91 318.47,158.71 318.47,166.19 317.12,167.54 317.12,169.64 316.12,170.64 315.02,170.64 v4(314.93,170.73)
  IN2 w0.127: v2(309.56,143.59) 309.49,143.65 309.2,143.65 308.53,142.98 304.94,142.98 303.91,141.95 302.89,141.95 288.79,141.95 285.35,145.39 277.04,145.39 276.15,144.5 263.77,144.5 258.85,139.59 255.3,139.59 251.65,135.93 250.16,135.93 249.93,135.7 247.93,135.7 v2(247.71,135.92)
  BOTTOM w0.102: v2(247.71,135.92) 247.57,135.78 RV40.1
GPU_VSS_SENSE: length 123.2
  TOP w0.254: v2(311.51,156.05) 311.85,155.71 v1(312.28,155.71) 312.78,155.71 313.23,155.27 313.23,154.6 313.77,154.06 315.41,154.06 v2(316.12,154.77)
  IN2 w0.254: v2(229.12,123.38) 228.88,123.38 228.15,122.64 227.75,122.64 227.36,123.03 227.36,124.47 227.96,125.07 228.82,125.07 231.02,127.27 237.07,127.27 237.23,127.1 241.58,127.1 245.6,131.13 246.29,131.13 248.05,132.89 249.07,132.89 249.64,132.32 254.14,132.32 254.9,131.56 259.44,131.56 259.95,132.07 259.95,138.54 260.9,139.5 262.15,139.5 266.07,143.42 276.6,143.42 276.85,143.67 285.3,143.67 286.41,142.57 v2(286.41,142.49)
  BOTTOM w0.254: v2(316.12,154.77) 316.12,153.35 315.86,153.09 315.86,148.45 312.85,145.44 312.42,145.44 311.48,144.5 304.62,144.5 304.15,144.03 292.54,144.03 290.44,141.93 286.96,141.93 v2(286.41,142.49) ; UV1.AH29 229.4,124.25 229.4,123.95 229.22,123.77 229.22,123.48 v2(229.12,123.38) ; v2(311.51,156.05) PR657.1
GREEN_CRT: length 168.4
  TOP w0.102: v2(181.82,178.27) v1(181.82,176.8) 181.82,176.66 183.06,175.42 U6.25 ; v2(53.96,203.47) 54,203.51 JBTB1.19
  IN2 w0.127: v2(181.82,178.27) 181.16,178.27 180.2,179.22 179.87,179.22 177.63,176.99 172.39,176.99 168.72,173.31 168.72,172.5 166,169.79 161.17,169.79 160.28,168.9 159.22,168.9 157.23,166.9 150.29,166.9 149.84,166.46 149.84,165.85 149.84,165.85 149.84,165.33 147.6,163.08 146.21,163.08 146.21,163.08 137.86,163.08 136.27,164.67 119.12,164.67 118.46,165.33 110.19,165.33 107.95,163.09 101.94,163.09 101.4,163.64 100.26,163.64 99.99,163.91 97.35,163.91 96.74,163.3 91.99,163.3 85.93,169.35 85.15,169.35 81.95,172.55 81.82,172.55 80.51,173.86 71.85,173.86 64.87,180.85 62.76,180.85 58.66,184.95 58.66,197 54.59,201.06 54.59,202.84 54.22,203.21 54.16,203.21 54.08,203.29 54.08,203.34 v2(53.96,203.47)
GREEN_DOCK: length 7.1
  TOP w0.102: U6.24 183.46,175.35 182.43,176.38 182.43,178.07 v1(182.76,178.39) v2(183.27,178.9)
  BOTTOM w0.102: JDOCK1.59 182.75,179.42 v2(183.27,178.9)
H_CATERR#: length 13.6
  TOP w0.089: 137.35,115.46 138.35,114.45 138.88,114.45 139.17,114.16 139.17,112.66 139.38,112.46 139.92,112.46 140.2,112.17 140.2,111.39 139.73,110.92 v2(139.73,110.92)
  TOP w0.102: 137.35,115.46 v1(136.97,115.84) 136.21,116.59 135.88,116.59 134.03,118.44 134.03,119.51 RC28.2
  BOTTOM w0.089: v2(139.73,110.92) JCPU1.AN32
H_CPU_RSVD: length 3.6
  TOP w0.089: v2(165.73,105.92) v1(165.24,105.42) RC82.1
  BOTTOM w0.089: v2(165.73,105.92) 165.73,104.92 JCPU1.G26
H_CPU_SVIDALRT#: length 19.5
  TOP w0.102: RC88.1 130.37,96.91 v2(130.22,97.07)
  IN1 w0.089: 136.89,100.92 137.46,101.49 139.83,101.49 140.27,101.92 140.27,105.45 v2(140.73,105.92)
  IN1 w0.102: 136.89,100.92 134.95,98.97 134.95,98.54 132.66,96.25 131.03,96.25 v2(130.22,97.07)
  BOTTOM w0.089: JCPU1.AM28 141.2,106.39 v2(140.73,105.92)
  BOTTOM w0.102: v2(130.22,97.07) v1(131.02,97.07)
H_CPU_TESTLO: length 15.6
  TOP w0.089: v2(153.73,112.93) 153.73,112.98 154.28,113.53 154.28,114.08 155.15,114.96 156.15,114.96 156.65,115.46
  TOP w0.102: RC80.1 162.67,122.88 161.86,122.07 v1(161.86,122.06) 161.86,121.3 159.9,119.34 159.9,117.91 158.69,116.7 157.89,116.7 156.65,115.46
  BOTTOM w0.089: v2(153.73,112.93) 154.2,112.46 JCPU1.W34
H_CPUPWRGD: length 190.1
  TOP w0.102: RC20.1 114.23,110.25 113.51,109.52 v1(113.19,109.52) 111.98,109.52 v2(110.99,110.52) ; v2(136.19,125.27) 136.58,124.88 136.58,124.43 136.51,124.35 RC33.1
  IN1 w0.102: v2(112.14,119.85) 110.27,117.98 110.27,111.24 v2(110.99,110.52) 111.45,110.06 111.62,110.06 112.16,109.52 112.16,108.04 111.77,107.64 111.77,105.6 112.55,104.81 112.55,102.49 118.78,96.27 118.78,64.82 118.89,64.71 118.89,64.06 v2(119.36,63.59)
  IN4 w0.102: v2(187.51,75.5) 188.49,74.52 189.29,74.52 193.15,70.66 193.38,70.66 193.79,70.25 v2(193.79,69.95) ; v2(112.14,119.85) 112.42,120.13 119.07,120.13 120.43,121.49 127.5,121.49 128.15,122.14 131.83,122.14 131.97,122 131.97,121.25 132.18,121.04 135.03,121.04 135.54,120.54 137.2,120.54 137.7,121.04 137.7,123.74 136.19,125.25 v2(136.19,125.27)
  BOTTOM w0.089: 195.37,69.81 196.02,70.46 196.65,70.46 196.69,70.5 197.18,70.5 197.51,70.83 UH1.AV3
  BOTTOM w0.102: 195.37,69.81 195.1,69.54 194.74,69.54 194.33,69.95 v2(193.79,69.95) ; v2(187.51,75.5) 187.51,75.38 184.16,72.03 184.16,71.44 172.1,59.37 124.79,59.37 120.57,63.59 v2(119.36,63.59)
H_CPUPWRGD_XDP: length 13.1
  TOP w0.102: v2(111.73,110.54) 111.73,110.99 111.86,111.11 112.15,111.11 112.28,110.99 v1(112.28,110.83) 112.28,110.6 112.38,110.5 RC20.2
  BOTTOM w0.102: v2(111.73,110.54) 111.89,110.39 112.28,110.39 112.5,110.62 112.5,110.88 112.4,110.99 111.47,110.99 111.35,111.1 111.35,111.27 111.47,111.39 112.4,111.39 112.5,111.49 112.5,111.7 112.4,111.8 111.49,111.8 111.37,111.92 111.37,112.09 111.49,112.2 112.4,112.2 112.5,112.31 112.5,112.51 112.4,112.61 111.93,112.61 111.81,112.73 111.81,112.9 111.93,113.02 112.4,113.02 112.5,113.12 112.5,113.59 112.81,113.9 JXDP1.39
H_PM_SYNC: length 167.3
  IN1 w0.102: v2(111.2,107.47) 111.29,107.38 111.29,105.5 112.14,104.65 112.14,102.23 118.35,96.02 118.35,69.91 117.55,69.11 117.55,65.43 118.49,64.49 v2(118.49,64.48)
  IN4 w0.089: v2(195.21,70.57) 194.64,70.57 194.11,71.1 194.07,71.1 ; 136,107.58 136.66,106.92 v2(136.73,106.92)
  IN4 w0.102: 136,107.58 135.03,108.55 122.58,108.55 122.11,108.08 113.88,108.08 113.64,107.84 111.57,107.84 v2(111.2,107.47) ; v2(187.98,75.86) 188.64,75.2 189.21,75.2 193.31,71.1 194.07,71.1
  BOTTOM w0.089: UH1.AY3 196.75,71.1 196.23,71.1 196.06,70.93 195.77,70.93 195.4,70.57 v2(195.21,70.57) 194.71,70.57 194.36,70.92 194.25,70.92
  BOTTOM w0.102: v2(136.73,106.92) JCPU1.AT28 ; v2(118.49,64.48) 118.5,64.48 118.98,64 120.74,64 124.96,59.78 171.93,59.78 183.76,71.61 183.76,72.32 187.34,75.91 187.93,75.91 v2(187.98,75.86) ; 194.25,70.92 193.57,70.92 T74.1
H_PROCHOT#: length 326.1
  TOP w0.102: RC30.1 RC29.2 v1(128.47,122.87) 127.52,122.87 v2(127.19,122.54) ; v2(95.23,159.07) 95.39,159.22 PR724.2 ; Q47.1 113.65,154.57 v4(114.03,154.95) 113.22,155.77 R1180.2 ; v2(245.47,134.18) 244.65,133.35 QV8.3
  TOP w0.254: PQ805.3 57.4,181.95 v2(56.74,181.29)
  IN2 w0.127: v2(187.71,168.12) 187.71,168.11 187.49,167.88 186.75,167.88 185.2,166.33 182.05,166.33 179.84,164.12 179.84,161.86 176.61,158.64 171,158.64 170.75,158.89 169.11,158.89 168.85,159.14 164.87,159.14 163.6,160.41 157.29,160.41 155.01,158.13 135.92,158.13 133.55,160.49 129.54,160.49 127.45,158.41 124.39,158.41 122.92,156.93 116.6,156.93 114.62,154.95 v4(114.03,154.95) 114.03,155.13 113.66,155.5 101.94,155.5 98.17,159.27 95.44,159.27 v2(95.23,159.07)
  IN2 w0.254: v2(79.18,171.93) 79.14,171.97 75.5,171.97 75.24,172.22 69.82,172.22 69.49,172.55 69.49,173.89 64.58,178.8 59.69,178.8 57.2,181.29 v2(56.74,181.29)
  IN4 w0.102: v2(127.19,122.54) 120.49,122.54 115.73,127.3 113.69,129.35 113.69,139.05 109.88,142.86 109.88,147.1 112.75,149.97 112.75,153.39 114.03,154.67 v4(114.03,154.95) ; v2(187.71,168.12) 187.71,169.05 188.88,170.22 214.79,170.22 215.27,170.7 217.69,170.7 219.62,172.64 224.62,172.64 224.99,173.01 238.4,173.01 242.16,176.76 244.99,176.76 248.69,173.06 248.69,172.17 250.34,170.52 250.34,168.37 250.83,167.89 250.83,157.31 251.97,156.17 251.97,149.57 249.44,147.04 249.44,143.1 249.38,143.04 249.38,138.49 249.2,138.3 249.2,135.18 248.64,134.63 245.75,134.63 245.47,134.35 v2(245.47,134.18) ; v2(79.18,171.93) 79.61,171.93 80.72,170.83 82.55,170.83 86.55,166.84 86.55,164.51 88.96,162.09 92.4,162.09 95.23,159.26 v2(95.23,159.07)
  BOTTOM w0.102: PR524.1 v4(114.03,154.95) PR527.2 PC510.1
H_PROCHOT#_R: length 18.9
  TOP w0.089: 136,110.43 136.11,110.32 138.96,110.32 139.25,110.03 139.25,109.79 139.6,109.45 140.21,109.45 v2(140.73,108.92)
  TOP w0.102: 136,110.43 135.43,111 135.43,113.4 v1(133.61,115.22) 131.38,117.45 130.76,117.45 129.4,118.82 RC30.2
  BOTTOM w0.089: JCPU1.AM30 v2(140.73,108.92)
H_THERMTRIP#: length 298.7
  TOP w0.102: Q4.3 279.11,125.35 v2(278.95,125.51)
  IN2 w0.127: v2(278.89,173.24) 278.79,173.24 278.37,173.66 278.37,173.84 275.36,176.85 269.71,176.85 269.36,177.19 262.7,177.19 261.95,177.95 254.53,177.95 254.03,177.46 237.26,177.46 235.69,175.89 224.86,175.89 223.88,176.87 212.91,176.87 212.62,176.58 206.05,176.58 204.99,175.53 204.03,175.53 203.52,175.02 199.67,175.02 197.35,172.71 193.67,172.71 192.05,174.33 184.36,174.33 183.17,173.14 182.09,173.14 181.4,173.82 179.8,173.82 179.37,173.39 177.38,173.39 177.1,173.67 176.45,173.67 176.16,173.96 173,173.96 172.29,173.26 172.29,172.08 169.85,169.65 168.02,169.65 166.63,168.26 162,168.26 161.73,168 161.73,165 161.12,164.39 154.38,164.39 152.76,162.78 150.86,162.78 149.89,161.81 147.36,161.81 137.33,161.81 135.98,163.16 122.21,163.16 121.2,162.15 120.45,162.15 120.21,162.39 114.89,162.39 114.54,162.75 111.77,162.75 111.56,162.96 v2(111.3,162.96)
  IN4 w0.102: v2(278.95,125.51) 277.88,126.58 277.88,130.52 277.9,130.53 277.9,132.13 277.88,132.14 277.88,133.88 278.43,134.43 278.43,139.55 278.6,139.71 278.6,146.47 277.87,147.19 277.87,164.6 279.1,165.84 279.1,169.8 279.68,170.37 279.68,172.35 278.89,173.14 v2(278.89,173.24) ; v2(111.3,162.96) 110.59,162.25 110.59,161.23 111.83,159.99 111.83,157.67 112.05,157.45 112.05,150.05 109.08,147.08 109.08,143.08 113.28,138.88 113.28,129.18 115.44,127.02 118.3,124.16 120.57,121.89 127.25,121.89 127.95,122.59 132.27,122.59 132.72,122.14 133.54,122.14 133.8,122.4 v2(133.8,122.5)
  BOTTOM w0.102: v2(133.8,122.5) 134.45,121.86 RC27.2 RC31.1
H_THERMTRIP#_R: length 11.7
  BOTTOM w0.102: JCPU1.AM35 139.44,115.21 137.78,115.21 137.33,115.66 136.99,115.66 135.69,116.96 134.48,118.18 RC31.2 133.73,119.81 v1(133.73,120.84)
HDD_DET#: length 322.5
  TOP w0.102: v2(115.67,52.86) 115.67,64.3 v1(116.04,64.67) 118.45,67.08 120.8,67.08 v2(120.94,66.94) ; v2(272.36,90.25) 271.76,90.25 RH11.1
  IN2 w0.127: v2(272.36,90.25) 272.36,90.3 272.17,90.49 268.34,90.49 268.29,90.44 267.2,90.44 266,91.64 262.25,91.64 v2(262,91.9) ; v2(190.6,69.71) 190.48,69.59 190.48,67.62 188.15,65.29 187.94,65.29 187.04,64.39 187.04,64.3 186.8,64.06 186.26,64.06 186.23,64.08 185.98,64.08 185.02,65.04 185.02,65.67 184.62,66.08 182.2,66.08 175.73,59.6 128.28,59.6 v2(120.94,66.94)
  IN3 w0.127: v2(262,91.9) 262,91.05 261.15,90.2 261.15,68.38 257.68,64.92 257.68,56.17 257.42,55.92 257.42,53.61 257.88,53.15 257.88,48.55 258.28,48.16 258.29,48.16 260.71,45.74 260.71,42.72 261.79,41.64 261.79,31.84 247.64,17.69 226.81,17.69 226.21,18.29 226.21,19.56 222.27,23.51 222.27,24.02 219.35,26.94 215.9,26.94 215,27.84 215,32.28 211.15,36.13 201.85,36.13 200.9,37.08 198,37.08 195.7,39.38 195.7,42 194.83,42.87 194.83,44.74 182.96,56.6 182.96,56.62 182.61,56.98 182.61,68.43 183.89,69.71 v2(190.6,69.71)
  BOTTOM w0.089: 196.14,69.03 196.43,69.33 196.72,69.33 196.74,69.35 196.83,69.35 196.95,69.46 197.34,69.46
  BOTTOM w0.102: 197.34,69.46 197.49,69.62 UH1.AT1 ; v2(190.6,69.71) RH36.1 190.78,68.47 191.66,68.47 191.74,68.55 193.15,68.55 193.36,68.34 194.1,68.34 194.2,68.44 194.22,68.44 194.22,68.44 195.22,68.44 195.74,68.96 196.06,68.96 196.14,69.03 ; JSATA1.12 115.17,44.16 115.67,44.65 v2(115.67,52.86)
HDD_FALL_INT: length 140.4
  TOP w0.102: RH106.1 195.16,56.09 195,55.93 195,55.56 194.5,55.06 194.5,54.08 193.12,52.71 193.12,51.51 v1(192.55,50.94) v2(192.55,49.71)
  IN2 w0.127: v2(192.55,49.71) 192.55,50.22 192.17,50.6 126.23,50.6 120.95,55.88 v2(120.95,57.81)
  IN3 w0.127: v2(120.95,57.81) 120.95,38.05 120.03,37.13 120.03,26.73 119.86,26.56 119.86,14.81 122.45,12.22 122.45,9.27 122.02,8.84 119.6,8.84 v2(118.98,8.22)
  BOTTOM w0.305: U88.11 v2(118.98,8.22) R503.2
HDMI_BUF: length 6
  TOP w0.102: U19.14 26.87,204.65 26.97,204.75 26.97,205.43 26.78,205.63 R79.2 26.78,206.76 27.24,207.21 27.24,208.5 v1(27.31,208.57) 27.31,208.95 R81.1
HDMI_CEC: length 13
  TOP w0.102: v1(15.22,205.33) 15.91,206.02 R73.2 15.49,206.39 v2(15.17,206.7)
  IN4 w0.102: JHDMI1.13 10.78,207.32 10.78,209.64 11.29,210.15 12.35,210.15 12.68,209.82 12.68,207.37 13.34,206.7 v2(15.17,206.7)
HDMI_EQ: length 6.3
  TOP w0.102: R82.1 24.19,208.93 v1(24.19,208.57) 24.19,207.25 R80.2 24.75,206.17 25.67,205.25 U19.17
HDMI_HPD_SINK: length 14.3
  TOP w0.102: v2(22.7,200.58) 22.73,200.56 U19.28 ; v2(18.14,200.82) v1(18.14,202.2) 18.14,206.69 17.43,207.4 R84.1
  IN1 w0.102: v2(22.7,200.58) 22.7,200.55 21.53,199.38 19.59,199.38 v2(18.14,200.82)
HDMI_HPD_SINK_R: length 10.9
  TOP w0.102: R84.2 v1(14.89,207.4) v2(14.22,207.4)
  IN1 w0.102: v2(14.22,207.4) 14.22,210.73 13.69,211.26 10.45,211.26 10.02,210.83 10.02,209.63 JHDMI1.19
HDMI_ISET: length 5.9
  TOP w0.102: R87.1 25.51,194.07 26.03,194.59 26.03,195.91 R85.2 v1(25.51,197.51) 25.51,198.3 25.67,198.46 U19.34
HDMI_PRE: length 6
  TOP w0.102: U19.16 26.07,206.38 R86.2 25.78,206.69 26.28,207.2 26.28,208.25 v1(25.99,208.55) 25.76,208.78 R88.1
HDMI_SCL_SINK: length 32
  TOP w0.102: U19.32 24.87,198.57 24.96,198.49 24.96,198.3 24.81,198.15 24.13,198.15 23.91,197.93 23.91,197.56 v2(23.73,197.38) 23.92,197.19 23.92,196.88 R69.2
  IN1 w0.102: v2(23.73,197.38) 23.73,197.12 23.4,196.79 17.56,196.79 13.72,200.62 13.72,209.84 12.64,210.92 10.99,210.92 10.78,210.71 10.78,208.32 JHDMI1.15
HDMI_SDA_SINK: length 31.5
  TOP w0.102: R70.2 24.13,196.8 24.13,197.19 v2(24.32,197.38) 24.14,197.56 24.14,197.84 24.22,197.92 24.9,197.92 25.19,198.2 25.19,198.49 25.27,198.57 U19.33
  IN1 w0.102: JHDMI1.16 11.01,208.69 11.01,210.61 11.09,210.69 12.55,210.69 13.5,209.75 13.5,200.53 17.47,196.56 23.49,196.56 v2(24.32,197.38)
HDMIB_PCH_HPD: length 322.7
  TOP w0.102: v2(103.55,150.58) 104.45,149.67 v1(104.88,149.67) 108.29,149.67 v2(108.44,149.82) ; U19.3 30.64,200.56 v2(30.98,200.22) 31.92,199.28 R75.1
  IN3 w0.089: 217.59,80.85 216.9,80.16 216.9,75.02 216.64,74.76 v2(216.64,74.71)
  IN3 w0.127: 217.59,80.85 218.23,81.5 218.23,83.78 215.91,86.11 214.37,86.11 213.85,86.63 213.85,88.91 213.22,89.55 212.45,89.55 212.07,89.17 204.81,89.17 202.93,87.29 202.93,87.08 202.93,87.08 202.93,86.46 200.31,83.83 197.59,83.83 196.83,84.59 183.75,84.59 176.39,91.96 176.39,99.43 174.18,101.64 174.18,113.3 173.88,113.59 173.88,122.62 v2(174.14,122.87)
  IN4 w0.102: v2(108.44,149.82) 108.15,149.53 108.15,142.86 111.87,139.14 111.87,120.5 110.52,119.15 110.52,117.79 110.76,117.55 111.17,117.55 111.45,117.83 115.21,117.83 116.3,116.74 116.81,116.74 118,117.93 120.11,117.93 122.08,119.9 126.15,119.9 126.72,119.33 133.42,119.33 133.76,119.67 137.35,119.67 137.55,119.67 137.58,119.7 139.04,119.7 139.62,120.28 141.71,120.28 141.94,120.05 143.42,120.05 144,120.64 144.91,120.64 145.42,120.13 146.16,120.13 146.69,120.66 148.6,120.66 149.45,119.81 151.72,119.81 151.89,119.65 158.87,119.65 160.17,118.35 170.34,118.35 174.14,122.15 v2(174.14,122.87) ; v2(30.98,200.22) 31.47,199.73 31.47,194.97 30.4,193.9 30.4,179.6 29.47,178.67 29.47,172.46 32.4,169.53 82.44,169.53 82.63,169.53 85.68,166.48 85.68,162.1 87.04,160.74 90.43,160.74 93.1,158.08 96.24,158.08 103.55,150.77 v2(103.55,150.58)
  BOTTOM w0.089: UH1.K40 216.64,74.14 v2(216.64,74.71)
HOST_DEB_TX: length 4
  BOTTOM w0.102: R853.1 325.97,159.65 326.33,160.02 v1(326.33,160.18) 326.33,161.5 326.79,161.96 JDEG2.8
HOST_DEBUG_RX: length 71.8
  TOP w0.102: v1(322.54,159.04) 322.54,158.1 v2(323.59,157.05) ; U51.B46 283.23,112.41 v2(283.62,112.02)
  IN3 w0.127: v2(323.59,157.05) 323.34,156.79 323.34,153.76 322.86,153.28 322.86,152.02 322.61,151.78 322.61,146.84 317.62,141.85 317.62,140.86 316.02,139.26 316.02,135.57 310.2,129.74 308.87,129.74 299.81,120.68 297.69,120.68 297.14,120.13 294.19,120.13 293.33,119.27 291.56,119.27 291.33,119.04 290.13,119.04 289.12,118.03 289.12,116.96 288.2,116.03 288.2,115.96 284.7,112.47 284.03,112.47 283.62,112.06 v2(283.62,112.02)
  BOTTOM w0.102: v2(323.59,157.05) 324.16,157.62 R855.2
HOST_DEBUG_TX: length 189
  TOP w0.102: U51.B44 283.74,113.41 v2(284.26,112.89)
  IN2 w0.127: v2(265.84,156.15) 273.59,156.15 276.64,159.19 276.64,164.76 278.27,166.38 278.27,167.56 281.08,170.38 287.24,170.38 288.27,171.42 288.27,173.71 289.84,175.27 290.79,175.27 291.3,174.76 293.81,174.76 295.44,173.13 300.58,173.13 301.45,172.26 302.89,172.26 303.51,172.88 308.81,172.88 309.1,172.59 314.21,172.59 321.52,165.28 321.52,161.67 v2(322.77,160.43)
  IN3 w0.127: v2(257.69,180.48) 259.35,180.48 262.36,177.47 262.89,177.47 264.71,175.65 264.71,174.06 264.32,173.67 264.32,156.65 264.83,156.15 v2(265.84,156.15) ; v2(284.26,112.89) 284.79,113.42 284.79,114.07 287.13,116.41 288.21,116.41 288.79,116.99 288.79,118.36 289.72,119.29 291.23,119.29 291.48,119.54 293.25,119.54 294.09,120.38 297.03,120.38 297.68,121.03 299.4,121.03 308.68,130.31 310.41,130.31 315.77,135.67 315.77,139.37 317.37,140.97 317.37,141.95 322.36,146.95 322.36,151.89 322.6,152.13 322.6,153.38 323.08,153.87 323.08,157.66 322.56,158.18 322.56,160.22 v2(322.77,160.43)
  BOTTOM w0.102: v2(322.77,160.43) 322.77,159.98 v1(322.96,159.79) 323.46,159.29 324.07,159.29 324.34,159.57 R853.2 324.34,159.75 R848.2 ; C595.1 257.05,176.76 JMINI2.16 257.05,180.21 257.32,180.48 v2(257.69,180.48)
HSYNC: length 5.2
  TOP w0.089: v1(216.1,74.68) 216.1,75.17 215.91,75.36 v2(215.91,75.38) 215.91,75.38 215.91,75.43 216.72,76.24 217.61,76.24 218.05,76.68 218.47,76.68 RH94.2
  BOTTOM w0.089: v2(215.91,75.38) 216.06,75.23 UH1.N42
HSYNC_BUF: length 169.9
  TOP w0.102: v2(185.94,177.19) 185.94,176.19 v1(185.69,175.94) 185.06,175.31 U6.20 ; v2(57.39,201.43) 57.5,201.55 JBTB1.5
  IN2 w0.127: v2(185.94,177.19) 186.05,177.3 186.05,177.93 185.19,178.79 185.19,179.76 183.78,181.17 181.42,181.17 180.71,181.87 179.51,181.87 178.12,180.48 172.31,180.48 171.27,179.44 171.27,177.68 165.93,172.34 165.62,172.34 164.37,171.09 159.1,171.09 158.26,170.26 156.36,170.26 155.59,169.48 150.38,169.48 147.4,166.51 146.41,166.51 145.46,167.46 138.98,167.46 137.6,166.08 119.68,166.08 118.88,166.88 107.97,166.88 107.26,166.17 102.31,166.17 101.32,165.18 91.9,165.18 86.45,170.64 85.99,170.64 81.49,175.13 72.72,175.13 65.6,182.24 63.15,182.24 59.93,185.47 59.93,198.77 57.39,201.31 v2(57.39,201.43)
HSYNC_DOCK: length 9.3
  TOP w0.102: v2(183.33,178.32) 183.46,178.19 185.51,178.19 185.99,177.71 ; 185.99,177.71 v1(185.99,177.71) ; 185.99,177.71 186.34,177.36 186.34,176.09 185.46,175.21 U6.19
  BOTTOM w0.102: v2(183.33,178.32) 183.7,178.69 183.7,179.34 184.25,179.89 JDOCK1.65
HW_GPS_DISABLE2#: length 237.8
  TOP w0.102: U46.B34 264.19,57.49 263.75,57.93 262.43,57.93 v2(261.74,58.61) 261.74,59.22 261.33,59.64 R798.2 ; v2(308.97,128.49) 309.13,128.64 316.39,128.64 316.86,129.11 R749.2
  IN1 w0.102: v2(349.32,213.92) 349.32,212.34 347.86,210.88 347.86,200.85 347.38,200.37 347.38,197.54 348.32,196.6 348.32,188.33 347.81,187.82 342.95,187.82 342,186.87 340.51,186.87 339.44,185.79 339.44,179.49 337.7,177.75 337.7,175.51 337.3,175.11 331,175.11 330.47,174.57 324.44,174.57 322.68,172.81 321.57,172.81 318.75,169.99 318.75,166.88 319.16,166.48 319.16,159.09 319.96,158.29 319.96,154.36 319.57,153.96 319.57,147.48 309.25,137.17 309.25,128.77 v2(308.97,128.49) 308.59,128.1 308.59,106.49 305.27,103.17 286.21,103.17 275.48,92.44 275.48,65.42 v2(273.88,63.82)
  BOTTOM w0.102: v2(349.32,213.92) 349.35,213.95 JMINI1.51 ; v2(273.88,63.82) 271.92,61.85 263.76,61.85 v1(263.13,61.22) 262.39,60.48 262.39,59.22 261.78,58.61 v2(261.74,58.61)
I2S_BCLK: length 5
  TOP w0.102: U74.16 339.98,166.38 340.23,166.13 340.23,165.71 R1668.2 339.94,165.44 339.47,164.97 v1(339.47,163.23)
I2S_DO: length 2.5
  TOP w0.102: R1097.2 340.74,165.68 v1(340.74,166.4) 340.48,166.66 U74.17
I2S_MCLK: length 2.6
  TOP w0.102: R1654.2 338.95,166.09 339.47,166.61 v1(339.47,166.63) 339.48,166.64 U74.15
ICLK_IREF: length 2.5
  TOP w0.089: RH163.1 211.87,82.7 v1(211.12,83.45)
  TOP w0.254: RH163.1 211.87,82.54 v2(212.28,82.13)
  BOTTOM w0.254: UH1.AM45 211.88,81.67 212.26,82.06 212.26,82.11 v2(212.28,82.13)
IMON: length 5
  TOP w0.102: v2(116.48,154.63) 117.38,154.63 v1(117.46,154.7)
  TOP w0.254: PR521.1 115.79,153.94 v2(116.48,154.63)
  BOTTOM w0.203: PU500.4 v2(116.48,154.63) 116.32,154.63 PR521.1
IMVP_PWRGD: length 317.2
  TOP w0.102: v4(114.03,152.92) 112.63,152.92 v1(112.31,152.59) 111.96,152.25 v2(111.1,152.25) ; U46.A62 270.94,46.82 271.11,46.65 271.11,45.56 v2(272.25,44.42)
  IN1 w0.102: v2(272.25,44.42) 272,44.18 272,38.7 271.39,38.09 v2(271.39,30.8)
  IN2 w0.127: v2(111.1,152.25) 111.1,151.69 107.18,147.78 107.18,139.93 111.36,135.75 111.36,116.46 110.16,115.25 110.16,85.93 111.11,84.98 116.61,84.98 117.38,84.21 117.38,80.62 117.97,80.02 117.97,69.79 117.43,69.26 117.43,54.01 127.31,44.13 127.31,32.19 128.66,30.85 191.02,30.85 200.57,40.4 205.47,40.4 215.18,30.68 227.34,30.68 227.91,31.25 229.49,31.25 231.28,29.47 231.28,27.18 234.95,23.51 239.43,23.51 241.77,25.84 243.3,25.84 243.56,25.59 253.2,25.59 255.38,27.77 259.37,27.77 261.22,29.63 263.11,29.63 263.52,30.04 270.38,30.04 271.14,30.8 v2(271.39,30.8)
  BOTTOM w0.254: PR519.1 v4(114.03,152.92) PR522.1
IMVP_VR_ON: length 316.3
  TOP w0.102: v2(271.38,48.71) 271.19,48.51 U46.B66
  TOP w0.254: PR511.1 112.14,151.9 v2(111.04,150.81)
  IN1 w0.102: v2(270.62,30.87) 271.12,31.37 271.12,38.13 271.78,38.79 271.78,44.77 272.23,45.22 272.23,46.29 271.38,47.14 v2(271.38,48.71)
  IN2 w0.127: v2(270.62,30.87) 270.04,30.29 263.41,30.29 263.03,29.91 261.14,29.91 259.54,28.31 255.34,28.31 255.06,28.59 249.77,28.59 247.05,25.87 243.68,25.87 243.45,26.1 241.66,26.1 239.42,23.86 234.95,23.86 231.53,27.28 231.53,29.58 229.6,31.51 227.65,31.51 227.08,30.94 215.31,30.94 205.6,40.65 200.46,40.65 190.91,31.1 128.76,31.1 127.57,32.3 127.57,44.24 117.69,54.12 117.69,69.15 118.26,69.72 118.26,80.09 117.63,80.72 117.63,84.33 116.73,85.23 111.36,85.23 110.43,86.16 110.43,114.82 111.64,116.03 111.64,135.83 108.31,139.16 108.31,148.19 110.93,150.81 v2(111.04,150.81)
  BOTTOM w0.102: v2(111.04,150.81) v1(110.4,150.81)
INT_SPK_L+:
  vias: v2(342.63,176.42) v2(342.65,175.81)
INT_SPK_L-:
  vias: v2(341.99,176.42) v2(341.99,175.78)
INT_SPK_R+:
  vias: v2(340.34,176.42) v2(340.34,175.78)
INT_SPK_R-:
  vias: v2(340.98,176.42) v2(341.03,175.83)
INT_SPKL_L+: length 392.1
  IN1 w1.016: 315.48,122.78 317.44,122.78 317.73,123.08 324.48,123.08 325.59,124.19 325.59,138.81 323.83,140.56 323.83,142.33
  IN2 w1.016: 343.05,182.79 342.82,183.02 341.6,183.02 341.49,183.12 340.44,183.12 340.44,183.12 338.89,183.12 338.85,183.16 337.8,183.16 337.08,183.16 337,183.15 336.98,183.15 336.61,183.15 331.27,177.81 326.93,177.81 324.71,175.59 324.71,169.37 326.75,167.32 326.75,159.64 327.19,159.21 327.19,155.75 325.73,154.29 323.96,154.29 322.58,152.91 322.58,151.12 323.08,150.62 323.08,144.73 323.53,144.28 ; 112.12,9.41 112.12,10.03 114.68,12.59 114.68,14.37 116.51,16.2 118.07,16.2 120.44,18.58 121.73,18.58 121.82,18.49 143.43,18.49 143.52,18.58 161.83,18.58 161.92,18.49 161.95,18.49 164.47,18.49 164.59,18.37 165.3,18.37 165.42,18.49 167.29,18.49 167.4,18.37 169.85,18.37 170.49,17.74 186.65,17.74 190.89,21.98 194.36,21.98 197.01,24.63 210.28,24.63 211.86,23.05 214.89,23.05 215.38,22.55 217.76,22.55 218.25,23.05 222.26,23.05 223.01,23.8 231.82,23.8 234.59,21.03 244.33,21.03 244.83,21.54 268.85,21.54 279.89,32.58 279.89,45.05 281.82,46.98 281.82,59.96 275.75,66.03 275.75,66.68 275.73,66.71 275.73,92.7 283.82,100.8 284.37,100.8 286.26,102.69 287.37,102.69 287.65,102.97 307.27,102.97 310.26,105.96 310.26,119.09 312.69,121.53 314.23,121.53
  vias: v1(343.95,180.05) v2(111.91,8.39) v2(112.5,8.41) v2(315.04,121.81) v2(315.72,121.73) v2(324.04,143.64) v2(324.06,143.01) v2(343.29,180.23) v2(343.29,179.62)
INT_SPKL_L-: length 388.1
  IN1 w1.016: 325.85,142.48 325.85,140.33 326.86,139.33 326.86,123.66 325,121.81 318.26,121.81 317.18,120.73
  IN2 w1.016: 341.51,181.52 341.3,181.52 340.97,181.85 338.36,181.85 338.32,181.89 337.15,181.89 337.14,181.89 331.8,176.54 330.74,176.54 330.74,176.54 327.52,176.54 325.98,175.01 325.98,169.96 328.02,167.92 328.02,160.29 328.46,159.85 328.46,155.22 326.26,153.02 324.48,153.02 323.85,152.39 323.85,151.65 324.35,151.14 324.35,145.83 325.09,145.1 ; 314.07,119.81 312.77,119.81 311.53,118.57 311.53,105.44 307.79,101.7 288.17,101.7 287.89,101.42 286.79,101.42 284.89,99.53 284.35,99.53 277,92.18 277,67.23 277.02,67.21 277.02,66.56 283.09,60.49 283.09,46.46 281.16,44.53 281.16,32.05 269.38,20.27 245.36,20.27 244.85,19.76 234.06,19.76 231.3,22.53 223.53,22.53 222.78,21.78 218.78,21.78 218.28,21.28 214.85,21.28 214.36,21.78 211.33,21.78 209.76,23.36 197.53,23.36 194.89,20.71 191.42,20.71 187.15,16.45 169.99,16.45 169.33,17.1 166.88,17.1 166.76,17.22 165.95,17.22 165.83,17.1 164.06,17.1 163.94,17.22 161.39,17.22 161.3,17.31 144.04,17.31 143.96,17.22 121.29,17.22 121.2,17.31 120.97,17.31 118.59,14.93 117.04,14.93 115.95,13.84 115.95,12.06 113.93,10.04 113.93,7.77 113.38,7.23
  vias: v1(342.26,180.27) v2(111.91,7.2) v2(112.5,7.19) v2(314.9,120.17) v2(315.49,120.17) v2(325.61,143.9) v2(325.61,143.32) v2(341.84,180.56) v2(341.84,179.97)
INT_SPKR_R+: length 388.6
  IN2 w1.016: 338.69,179.08 337.49,177.88 335.98,177.88 330.84,172.74 330.84,163.39 331.66,162.57 331.66,155.11 326.96,150.41 326.96,141.13 325.46,139.63 325.46,122.23 324.88,121.65 319.01,121.65 314.84,117.48 314.84,106.21 312.96,104.33 312.96,102.41 310.51,99.95 289.2,99.95 288.87,99.62 288.4,99.62 288.15,99.36 287.33,99.36 285.97,98 285,98 278.54,91.55 278.54,67.66 285.24,60.97 285.24,46.45 282.68,43.9 282.68,39.33 283.18,38.84 283.18,28.13 273.2,18.15 233.38,18.15 230.53,21.01 224.61,21.01 222.54,18.94 210.29,18.94 208.71,20.52 205.39,20.52 204.07,19.2 197.56,19.2 196.49,18.14 192.58,18.14 191,18.14 187.45,14.59 168.71,14.59 168.18,15.13 167.12,15.13 145.55,15.13 144.6,14.17 143.8,14.17 143.73,14.24 124.09,14.24 122.4,12.55 122.4,9.13 121.78,8.51 121.78,8.26 121.67,8.16 121.67,5.11 119.4,2.83 114.73,2.83 112.69,4.87
  vias: v1(338.46,180.28) v2(111.36,5.73) v2(112,5.73) v2(338.95,180.61) v2(338.95,179.97)
INT_SPKR_R-: length 390.3
  IN2 w1.016: 112.8,2.48 113.71,1.56 119.93,1.56 122.94,4.58 122.94,7.63 123.72,8.41 123.72,11.96 124.72,12.97 143.21,12.97 143.27,12.9 145.12,12.9 146.08,13.86 167.65,13.86 168.18,13.32 187.98,13.32 191.52,16.87 192.05,16.87 197.02,16.87 198.08,17.93 204.6,17.93 205.92,19.25 208.18,19.25 209.77,17.67 223.06,17.67 225.13,19.74 230,19.74 232.86,16.88 273.72,16.88 284.45,27.6 284.45,39.36 283.95,39.86 283.95,43.37 286.51,45.92 286.51,61.49 279.81,68.19 279.81,91.02 285.53,96.73 286.5,96.73 287.86,98.09 288.67,98.09 288.93,98.35 289.4,98.35 289.73,98.68 311.04,98.68 314.32,101.97 314.32,103.81 316.11,105.6 316.11,116.95 319.54,120.38 325.41,120.38 326.73,121.7 326.73,139.1 328.23,140.6 328.23,149.89 332.93,154.58 332.93,163.1 332.11,163.91 332.11,172.21 336.51,176.61 338.63,176.61 340.24,178.22 340.24,178.83
  vias: v1(340.5,180.28) v2(111.36,3.06) v2(112.12,3.06) v2(340.09,180.61) v2(340.09,179.97)
INTRUDER#: length 8.9
  IN1 w0.089: 210.59,60 v2(210.59,60.18)
  IN1 w0.102: 210.59,60 210.59,59.67 213.44,56.82 v2(213.59,56.82)
  BOTTOM w0.089: v2(210.59,60.18) 210.59,60.71 210.42,60.89 210.42,60.98 210.16,61.24 UH1.A8
  BOTTOM w0.102: RH43.2 212.57,56.82 v2(213.59,56.82) 213.87,56.82 214.33,56.36 v1(214.46,56.36)
IRQ_SERIRQ: length 286
  TOP w0.089: v2(201.99,71.77) 201.28,71.77 199.57,70.06 199.11,70.06 198.89,69.84 198.1,69.84 197.7,69.44 197.41,69.15 196.04,69.15 196.03,69.14
  TOP w0.102: U46.B21 270.69,56.84 270.39,56.55 v2(270.38,56.55) ; v2(300.1,129.99) U39.27 ; 196.03,69.14 195.4,68.51 194.47,68.51 193.04,67.07 192.76,67.07 RH168.2 ; v2(285.31,120.21) 285.31,120.08 285.72,119.68 U51.A28
  IN1 w0.102: v2(285.31,120.21) 285.24,120.21 284.53,120.93 284.53,121.51 285.05,122.03 285.05,124.23 286.43,125.62 286.43,127.57 286.32,127.68 286.32,128.04 286.58,128.31 293.91,128.31 294.32,128.71 298.12,128.71 298.56,129.16 299.27,129.16 v2(300.1,129.99) ; v2(278.37,42.05) 278.37,43.03 278.79,43.45 278.79,49.8 278.09,50.49 278.09,54.8 279.78,56.49 279.78,58.23 v2(279.5,58.51)
  IN2 w0.127: v2(279.5,58.51) 279.48,58.52 277.63,58.52 277.21,58.1 271.67,58.1 270.38,56.81 v2(270.38,56.55)
  IN3 w0.089: 198.05,64.84 200.46,67.25 200.46,69.5 202.26,71.3 202.26,71.51 v2(201.99,71.77)
  IN3 w0.127: 198.05,64.84 198.05,64.55 196.19,62.69 196.19,62.47 195.94,62.23 195.58,62.23 193.8,60.45 192.42,60.45 189.81,57.84 189.81,51.32 197.45,43.68 197.45,42.46 201.22,38.69 201.59,38.69 202.42,37.86 210.86,37.86 216.04,32.68 217.22,32.68 221.03,28.88 221.03,26.69 227.93,19.79 229.87,19.79 230.86,18.81 245.05,18.81 250.8,24.55 251.65,24.55 252.84,25.74 252.84,26.98 258.58,32.72 259.96,32.72 260.78,33.54 260.78,40.8 v2(260.55,41.03)
  IN4 w0.102: v2(285.31,120.21) 285.31,119.85 286.08,119.09 286.69,119.09 287.93,117.85 287.93,116.78 288.39,116.32 288.39,115.21 288.85,114.75 288.85,111.17 289.16,110.86 289.16,109.21 287.85,107.9 287.85,106.92 286.69,105.75 286.69,104.6 286.14,104.05 281.01,104.05 280.28,103.33 280.28,100.4 280.7,99.98 280.7,99.61 280.78,99.53 280.78,98.68 280.67,98.56 280.67,95.28 277.5,92.11 277.5,67 279.37,65.13 279.37,63.28 279.93,62.71 279.93,58.92 279.52,58.51 v2(279.5,58.51)
  BOTTOM w0.089: UH1.AL11 201.99,71.3 v2(201.99,71.77)
  BOTTOM w0.102: v2(278.37,42.05) 277.69,41.38 v1(276.21,41.38) 271.6,41.38 271.14,40.92 260.66,40.92 v2(260.55,41.03)
ISEN1: length 24.7
  TOP w0.102: v4(120.52,162.72) v1(120.52,163.45)
  TOP w0.254: v4(130.96,155.93) 131.02,155.93 131.54,155.41 132.16,155.41 PR557.1
  IN3 w0.254: v4(130.96,155.93) 130.28,155.93 128.84,157.38 127.53,157.38 127.12,157.8 123.21,157.8 122.64,157.23 120.57,157.23 v4(120.05,157.75)
  IN4 w0.254: v4(120.05,157.75) 120.52,158.21 v4(120.52,162.72)
  BOTTOM w0.203: v4(120.05,157.75) PU500.12
  BOTTOM w0.254: PC539.2 120.7,162.9 v4(120.52,162.72) ; v4(130.96,155.93) 131.02,155.93 131.95,155 PR557.1 133.45,155 PR553.2
ISEN1_VGA: length 18.1
  IN4 w0.254: v2(303.5,154.11) 303.46,154.15 303.46,156.07 305.89,158.49 310.09,158.49 311.12,159.52 v4(312.56,159.52)
  BOTTOM w0.203: PU600.11 312.04,159.76 312.28,159.52 v4(312.56,159.52)
  BOTTOM w0.254: v2(303.5,154.11) PR656.1 PR652.2 ; PC616.1 v1(313.29,158.89) 313.29,159.14 312.91,159.52 v4(312.56,159.52)
ISEN2: length 22.9
  TOP w0.102: v4(117.71,146.1) v1(117.71,145.43)
  TOP w0.254: PR546.1 118.36,146.75 v4(117.71,146.1)
  IN4 w0.254: v4(117.71,146.1) 116.57,146.1 115.18,147.48 115.18,148.61 117.64,151.06 117.64,155.87 119.24,157.47 v2(119.24,158.25)
  BOTTOM w0.203: PU500.11 119.65,157.41 119.57,157.49 119.57,157.92 v2(119.24,158.25) PC540.2
  BOTTOM w0.254: v4(117.71,146.1) 117.72,146.1 118.37,146.75 PR546.1 PR538.2
ISEN2_VGA: length 23.8
  IN3 w0.254: v4(312.59,155.16) 312.44,155.3 312.44,157.74 313.33,158.62 313.33,158.67 313.69,159.03 313.69,159.04 v4(313.93,159.27)
  IN4 w0.254: v2(305.51,155.03) 305.51,156.98 306.52,158 312.66,158 v4(313.93,159.27)
  BOTTOM w0.203: PU600.10 313.05,161.15 313.81,160.39 313.81,160.39 313.95,160.24 313.95,159.3 v4(313.93,159.27)
  BOTTOM w0.254: PR623.2 306.56,153.38 306.56,154.39 PR626.1 v1(306.05,155.03) v2(305.51,155.03) ; v4(312.59,155.16) PC615.1
ISEN3: length 20.7
  IN1 w0.254: v2(118.61,158.24) 118.61,158.13 119.83,156.91 122.36,156.91 122.86,157.42 125.57,157.42 126.66,158.5 128.06,158.5 128.62,159.07 129.83,159.07 130.28,158.61 v4(130.28,158.51)
  BOTTOM w0.102: v1(130.17,157.56) 130.17,157.96 130.28,158.08 v4(130.28,158.51)
  BOTTOM w0.203: PC544.2 118.22,158.52 118.5,158.24 v2(118.61,158.24) 118.61,158.13 119.24,157.5 119.24,157.36 119.25,157.34 PU500.10
  BOTTOM w0.254: PR510.1 PR518.2 PR516.2 130.28,159.07 v4(130.28,158.51)
ISUMN: length 102.7
  TOP w0.254: PR535.2 121.27,160.87 v4(121.52,161.12) ; v4(124.82,161) PR549.1 v1(127.24,160.24) 130.93,160.24 131.55,159.61 131.55,157.89 v4(131.11,157.44)
  IN1 w0.254: v2(136.38,132.98) 135.49,132.98 135.24,132.73 135.24,130.19 131.43,126.38 123.17,126.38 v2(122.16,127.39)
  IN2 w0.254: v2(122.16,127.39) 122.03,127.52 121.52,127.52 120.76,128.28 120.76,129.27 118.6,131.43 118.6,141.01 120.91,143.32 120.91,149.12 120.29,149.75 116.31,149.75 115.71,149.14 115.71,148.41 v2(115.68,148.39) ; v4(131.11,157.44) 131.54,157.44 133.9,155.08 v4(134.22,155.08)
  IN4 w0.254: v4(124.82,161) 124.68,160.86 123.33,160.86 122.32,161.86 121.89,161.86 121.52,161.49 v4(121.52,161.12) 121.65,161 121.65,158.76 120.96,158.07 120.96,157.47 120.4,156.91 119.21,156.91 118.08,155.78 118.08,150.96 115.68,148.56 v2(115.68,148.39)
  BOTTOM w0.254: PC539.1 120.48,161.99 120.1,162.37 119.77,162.37 PR545.1 118.32,161.99 PC547.1 PC544.1 PC540.1 ; PC539.1 121.52,161.73 v4(121.52,161.12) ; PC539.1 121.47,162.19 PR548.1 122.79,161.99 122.79,160.87 PC528.1 ; PR515.1 131.16,157.49 v4(131.11,157.44) ; v4(134.22,155.08) 134.22,154.01 PR556.2 ; v2(115.68,148.39) 117.09,146.98 117.09,145.99 117.76,145.31 PR544.2 ; v2(136.38,132.98) 136.71,132.65 PH501.1
ISUMP: length 42.3
  TOP w0.102: PR549.2 v1(124.82,158)
  TOP w0.254: PR549.2 123.57,159.32 PC538.2 123.31,159.58 PR551.2 122.44,159.55 122.44,158.99 v4(122.61,158.81)
  IN1 w0.254: v2(130.92,158.64) 128.87,160.69 127.99,160.69 127.23,159.92 125.75,159.92 124.94,159.12 122.92,159.12 v4(122.61,158.81)
  IN2 w0.254: v4(134.22,156.01) 134.18,155.97 133.79,155.97 131.12,158.64 v2(130.92,158.64)
  IN4 w0.254: v4(122.61,158.81) 122.61,157.08 121.69,156.15 121.69,154.53 120.95,153.78 120.34,153.78 118.84,152.29 118.84,149.73 118.35,149.24 118.35,147.83 v4(119.62,146.56)
  BOTTOM w0.203: PU500.15 121.25,157.26 121.28,157.29 121.28,157.91 122.18,158.81 v4(122.61,158.81) 122.61,159.37 PR551.2 123.31,159.58 PC538.2
  BOTTOM w0.254: PR536.1 120.12,146.05 v4(119.62,146.56) 119.87,146.81 PR558.1 ; v4(134.22,156.01) 133.88,156.35 PR552.1 ; v2(130.92,158.64) 131.24,158.64 PR514.1
JAPS1_4:
  vias: v1(302,112.65)
JAPS1_7: length 1.1
  TOP w0.102: R24.2 v1(301.79,115.56)
JETWAY_14M: length 4.4
  TOP w0.089: v2(218.26,72.33) 218.26,71.87 218.51,71.62 218.51,71.13 219.02,70.62 v1(219.44,70.62) 220.35,70.62 RH161.2
  BOTTOM w0.089: UH1.F39 218.29,72.3 v2(218.26,72.33)
JETWAY_CLK14M: length 173.6
  TOP w0.102: v2(292.95,138.93) U39.13 ; RH161.1 224.63,69.97 CH80.1 227.75,67.52 228.65,66.62 228.65,59.14 v1(228.65,59.13) 228.65,56.81 228.21,56.38 228.21,53.92 229.39,52.74 229.39,52.72 229.68,52.44 229.7,52.44 230.31,51.83 239.68,51.83 242.55,54.7 243.29,54.7 245.37,56.78 245.99,56.78 246.5,57.3 246.5,58.63 247.35,59.48 247.35,59.49 250.24,62.38 252.17,62.38 253.12,63.33 257.25,63.33 257.35,63.44 261.95,63.44 262.19,63.68 262.66,63.68 264.12,65.14 266.15,65.14 266.91,64.38 268.59,64.38 268.88,64.08 270.19,64.08 270.19,64.08 v2(270.42,64.08)
  IN2 w0.127: v2(279.36,138.39) 279.38,138.37 280.01,138.37 280.23,138.59 280.23,139.95 281.02,140.74 286.76,140.74 287.92,139.59 292.29,139.59 v2(292.95,138.93)
  IN4 w0.102: v2(279.36,138.39) 278.91,137.95 278.91,134.23 278.38,133.7 278.38,130.33 278.37,130.32 278.37,127.5 279.57,126.29 279.57,125.4 278.44,124.27 278.44,122.91 280.35,121.01 280.35,119.14 282.2,117.29 282.2,114.6 281.3,113.7 280.17,113.7 278.96,112.5 278.96,110.99 277.13,109.16 276.3,109.16 275.97,108.82 275.97,107.29 275.22,106.54 275.22,96.98 272.23,93.99 272.23,93.05 270.24,91.06 270.24,76.2 271.62,74.82 271.62,73.02 270.87,72.28 270.87,70.43 270.42,69.98 v2(270.42,64.08)
JTAG_CLK: length 80.2
  TOP w0.102: v2(285.63,110.01) 285.63,109.86 285.47,109.7 U51.B56
  IN3 w0.127: v2(325.87,163.82) 324.1,162.05 324.1,156.84 323.91,156.65 323.91,153.61 323.36,153.07 323.36,151.81 323.12,151.57 323.12,145.83 322.05,144.77 322.05,144.28 318.08,140.3 318.08,136.29 317.82,136.03 317.2,136.03 310.41,129.23 309.08,129.23 299.95,120.1 297.83,120.1 296.02,118.29 291.59,118.29 291.35,118.53 290.6,118.53 290.22,118.15 290.22,117.13 289.54,116.45 289.33,116.45 288.79,115.91 288.79,115.06 288.08,114.35 288.08,113.59 286.06,111.57 286.06,110.38 285.69,110.01 v2(285.63,110.01)
  BOTTOM w0.102: RPH2.3 325.58,164.41 325.87,164.12 v2(325.87,163.82) 326.42,163.82 326.56,163.96 JDEG2.4
JTAG_RST#: length 11.6
  TOP w0.102: JTAG1.1 289.31,99.61 C735.1 R836.1 288.48,101.33 R920.2 288.22,101.61 v1(288.22,102.62) 288.22,104.08 287.89,104.41 287.59,104.41 286.96,105.04 286.96,106.68 287.82,107.53 287.82,107.9 287.72,108 U51.A57
JTAG_TDI: length 94.6
  TOP w0.102: v2(284.59,107.76) 284.72,107.88 U51.A51
  IN3 w0.127: v2(284.59,107.76) 284.77,107.76 285.45,108.44 290.43,108.44 290.95,108.95 293.09,108.95 293.28,108.76 298.39,108.76 298.81,108.34 300.6,108.34 306.54,114.28 306.54,120.75 314.12,128.33 316.26,128.33 318.36,130.43 318.36,132.53 320.81,134.99 322.49,134.99 323.38,135.88 323.38,137.98 326.6,141.21 326.6,155.34 327.34,156.08 327.34,163.49 326.21,164.62 325.56,164.62 325.27,164.91 325.27,165.62 v2(325.85,166.2)
  BOTTOM w0.102: v2(284.59,107.76) 284.59,108.04 v1(284.36,108.27) ; JDEG2.2 326.82,164.96 326.54,165.24 326.54,165.9 326.23,166.2 v2(325.85,166.2) 325.46,165.81 325.46,165.47 325.4,165.41 RPH2.1
JTAG_TDO: length 86
  TOP w0.102: U51.B55 284.97,109.58 285.07,109.69 285.07,110.09 285.42,110.44 285.9,110.44 286.34,110.88 v2(286.49,110.88) ; v2(325.89,163.21) 325.83,163.21 325.1,162.48 v1(325.1,162.03)
  IN1 w0.102: v2(325.99,157.24) 325.05,158.18 325.05,162.47 325.79,163.21 v2(325.89,163.21)
  IN3 w0.127: v2(286.49,110.88) 287.07,111.45 287.7,111.45 288.78,112.54 288.78,114.2 290,115.42 290,116.19 290.23,116.42 295.66,116.42 296.08,116 302.32,116 305.85,119.53 305.85,120.93 313.76,128.84 316.05,128.84 317.8,130.59 317.8,132.77 320.35,135.32 320.35,138.21 325.18,143.04 325.18,144.69 325.33,144.84 325.33,146.95 325.99,147.61 v2(325.99,157.24)
  BOTTOM w0.102: RPH2.4 325.38,163.91 325.46,163.83 325.46,163.49 325.74,163.21 v2(325.89,163.21) 326.49,163.21 326.74,163.46 JDEG2.5
JTAG_TMS: length 92.1
  TOP w0.102: v2(285.57,107.73) 285.72,107.87 U51.A53
  IN3 w0.127: v2(325.88,165.04) 326.18,165.04 327.59,163.63 327.59,155.97 326.86,155.23 326.86,139.56 325.01,137.72 325.01,134.72 324.62,134.33 320.51,134.33 318.73,132.54 318.73,130.42 316.33,128.02 314.22,128.02 306.88,120.68 306.88,114.12 300.85,108.09 294.22,108.09 294.01,107.89 293.59,107.89 292.77,108.7 291.28,108.7 290.76,108.18 286.09,108.18 285.63,107.73 v2(285.57,107.73)
  BOTTOM w0.102: JDEG2.3 326.7,164.46 326.12,165.04 v2(325.88,165.04) 325.75,164.91 RPH2.2
KB_DET#: length 283.6
  TOP w0.102: v2(193.74,54.54) 192.98,54.54 v1(192.97,54.55) ; v2(316.94,138.62) JKB1.1
  IN1 w0.102: v2(304.45,140.73) 304.11,140.39 287.7,140.39 286.92,141.17 284.86,141.17 v2(283.76,142.27)
  IN2 w0.127: v2(261.07,137.77) 263.39,137.77 263.94,138.32 263.94,138.32 264.24,138.62 264.32,138.62 264.68,138.98 264.68,139.05 266.62,141 266.85,141 266.87,141.01 271.8,141.01 272.47,140.33 276.96,140.33 277.4,140.77 278.7,140.77 280.37,142.44 283.59,142.44 v2(283.76,142.27) ; v2(316.94,138.62) 315.24,138.62 313.86,139.99 312.85,139.99 312.38,139.99 312.23,139.84 310.03,139.84 309.87,139.99 308.68,139.99 308.37,139.67 305.39,139.67 304.45,140.61 v2(304.45,140.73)
  IN3 w0.089: v2(206.56,67.25) 206.56,67.75 205.35,68.95 204.6,68.95 202.54,66.9 202.54,66.6 200.24,64.29 200.24,63.9 199.61,63.28
  IN3 w0.127: 199.61,63.28 198.48,62.15 198.48,59.8 196.91,58.23 196.91,56.92 194.81,54.83 194.02,54.83 v2(193.74,54.54) 193.74,51.75 199.06,46.43 200.62,46.43 203.99,43.07 211.11,43.07 223.95,30.23 223.95,27.92 228.89,22.98 231.8,22.98 232.93,21.86 243.67,21.86 249.3,27.48 249.3,29.04 251.53,31.28 252.93,31.28 254.76,33.11 254.76,36.34 256.26,37.84 256.26,39.56 256.78,40.08 256.78,41.71 255.67,42.81 254.28,42.81 253.59,43.5 253.59,47.52 253.16,47.95 253.16,48.82 253.81,49.47 253.81,50.01 252.88,50.94 252.88,56.67 252.81,56.74 252.81,60.42 252.09,61.13 252.09,64.64 257.4,69.95 257.4,71.28 256.54,72.15 256.54,77.94 256.52,77.95 256.52,78.16 256.52,99.11 259.76,102.35 259.76,107.71 260.3,108.25 260.3,112.68 260.68,113.05 260.68,119.76 261.9,120.98 261.9,128.5 261.55,128.84 261.55,137.29 v2(261.07,137.77)
  BOTTOM w0.089: UH1.U12 206.56,67.58 v2(206.56,67.25)
  BOTTOM w0.102: v2(193.74,54.54) 194.65,54.54 RH212.1
LAN_ACTLED_YEL#: length 9.9
  TOP w0.102: v2(306.81,199.47) 306.62,199.66 U32.17 ; v2(308.77,202.96) 308.77,204.1 v1(309.66,204.99) 310.9,204.99 311.14,204.75 Q325.1
  IN4 w0.102: v2(306.81,199.47) 306.7,199.59 306.7,201.22 308.44,202.96 v2(308.77,202.96)
LAN_ACTLED_YEL#_Q: length 18.9
  TOP w0.102: Q325.6 311.14,205.86 310.93,205.65 308.85,205.65 v2(308.62,205.88)
  BOTTOM w0.102: R1166.1 296.53,210.6 297.73,209.4 297.73,208.37 298.66,207.44 v1(304.4,207.44) 308.12,207.44 308.62,206.95 v2(308.62,205.88)
LAN_DISABLE#_R: length 224
  TOP w0.102: v2(264.98,50.24) 264.98,50.38 264.55,50.81 264.18,50.81 264,50.64 U46.B47
  IN1 w0.102: v2(305.04,140.73) 304.63,141.13 304.28,141.13 303.76,140.61 287.8,140.61 287.01,141.4 285.3,141.4 v2(284.39,142.32)
  IN2 w0.127: v2(273.64,141.92) 274.06,141.5 276.03,141.5 277.22,142.7 284.26,142.7 284.39,142.57 v2(284.39,142.32) ; v2(319.65,191.46) 319.39,191.73 318.07,191.73 317.81,191.48 315.51,191.48 314.85,190.82 314.85,185.95 318.17,182.64 320.76,182.64 321.42,181.98 321.42,179.32 323.21,177.53 323.21,172.87 321.9,171.56 321.9,170.04 322.44,169.5 322.44,167.77 323.37,166.84 323.73,166.84 324.98,165.59 324.98,159.19 324.72,158.93 324.72,156.61 319.2,151.08 319.2,147.61 311.68,140.09 310.13,140.09 309.98,140.25 308.58,140.25 308.26,139.93 305.5,139.93 305.25,140.17 305.25,140.51 v2(305.04,140.73)
  BOTTOM w0.102: v2(319.65,191.46) 320.01,191.46 320.28,191.73 320.28,193.27 319.91,193.64 R549.2 R555.2 R557.1 316.72,194.52 U31.3 ; v2(273.64,141.92) 273.55,141.83 273.55,137.58 274.7,136.44 274.7,130.42 273.66,129.37 273.26,129.37 273.06,129.17 273.06,127.25 272.78,126.97 272.78,126.47 265.03,118.73 265.03,113.79 259.14,107.9 259.14,99.92 257.81,98.59 257.81,81.62 258.35,81.08 258.35,79.62 259.34,78.63 259.34,76.27 261.35,74.26 261.35,62.59 260.78,62.03 260.78,58.38 260.55,58.15 260.55,56.86 261.25,56.16 262.77,56.16 263.13,55.8 263.13,53.27 263.9,52.5 265.15,52.5 265.39,52.25 v1(265.39,51.57) 265.39,50.65 v2(264.98,50.24)
LAN_SMBCLK: length 337.2
  TOP w0.102: RH174.2 193.78,57.07 193.78,56.69 193.69,56.6 v2(193.29,56.6)
  IN1 w0.089: 203.69,64.51 204.19,65.01 204.87,65.01 205.31,65.45 205.31,65.6 v2(205.11,65.8)
  IN1 w0.102: 203.69,64.51 203.1,64.51 200.95,62.37 200.69,62.37 198,59.68 198,59.35 197.29,58.64 197.29,58.04 195.97,56.72 193.69,56.72 193.56,56.6 v2(193.29,56.6)
  IN4 w0.089: v2(205.11,65.8) 205.16,65.8 206.03,64.93 206.03,64.67 205.73,64.36 205.73,61.53 204.95,60.76 204.95,60.45 204.94,60.44
  IN4 w0.102: 204.94,60.44 204.94,60.32 205.27,60 205.27,59.37 205.47,59.17 205.47,57.64 207.94,55.17 208.25,54.86 208.25,53.84 208.92,53.16 209.65,53.16 210.25,52.57 224.31,52.57 224.92,53.17 227.45,53.17 227.94,52.69 227.94,52.33 228.23,52.04 239.71,52.04 241.01,50.74 241.21,50.74 242.36,49.59 242.36,45.65 243.29,44.72 244.31,44.72 245.63,43.4 246.49,43.4 247.66,42.23 252.61,42.23 254.43,44.04 255.41,44.04 256.32,44.95 256.32,53.83 257.26,54.77 257.26,71.05 256.08,72.23 256.08,87.29 256.66,87.88 256.66,92.14 261.22,96.7 261.22,97.07 264.07,99.92 264.07,100.74 264.74,101.42 264.74,103.15 266.15,104.56 266.15,111.26 266.65,111.77 266.65,115.49 266.85,115.68 266.85,117.26 266.44,117.67 266.44,121.43 266.2,121.67 266.2,127.78 266.98,128.55 266.98,129.16 266.77,129.37 266.77,138.09 266.36,138.51 266.36,146.13 267.03,146.79 267.03,150.7 267.33,151 267.33,165.74 266.09,166.98 266.09,167.61 265.21,168.5 265.21,172.86 266.01,173.66 266.01,174.71 267.61,176.3 268.19,176.3 268.47,176.59 268.47,177.65 269.76,178.93 277.89,178.93 278.06,178.76 290.79,178.76 291.68,177.88 293.02,177.88 293.37,177.52 294.58,177.52 295.25,176.86 301.7,176.86 303.78,174.78 312.75,174.78 314.14,176.16 320.03,176.16 321.67,177.8 325.66,177.8 325.89,178.04 325.89,183.56 326.37,184.04 326.37,184.76 327.36,185.75 327.36,194.82 326.91,195.27 326.91,196.73 327.95,197.77 327.95,199.45 327.05,200.35 324.93,200.35 323.23,202.06 322.66,202.06 v2(322.59,201.98)
  BOTTOM w0.089: v2(205.11,65.8) 205.11,66.49 UH1.U8
  BOTTOM w0.102: R551.1 313.55,206.01 v1(314.22,206.68) 315.7,206.68 316.6,207.58 319.3,207.58 320.28,206.6 320.28,204.32 321.29,203.3 322.94,203.3 323.29,202.96 323.29,202.44 323.02,202.17 322.78,202.17 v2(322.59,201.98)
LAN_SMBCLK_R: length 2.7
  BOTTOM w0.102: R551.2 313.55,203.94 v1(314.11,203.37) 314.31,203.17 314.31,202.01 U31.28
LAN_SMBDATA: length 333.8
  TOP w0.102: v2(193.74,56.15) 193.74,56.31 193.98,56.54 194.31,56.54 RH175.2
  IN1 w0.089: 203.84,64.34 203.91,64.42 203.91,64.43 204.28,64.8 204.94,64.8 205.21,65.07 205.35,65.07 v2(205.56,64.86)
  IN1 w0.102: v2(193.74,56.15) 193.74,56.42 193.82,56.5 196.06,56.5 197.52,57.95 197.52,58.54 198.23,59.25 198.23,59.59 200.78,62.14 201.05,62.14 203.19,64.28 203.78,64.28 203.84,64.34
  IN4 w0.089: v2(205.56,64.86) 205.51,64.81 205.51,61.62 204.71,60.83 204.71,60.46
  IN4 w0.102: v2(322.59,202.56) 322.83,202.32 323.29,202.32 325.03,200.58 327.14,200.58 328.18,199.55 328.18,197.68 327.13,196.63 327.13,195.37 327.59,194.91 327.59,185.66 326.6,184.66 326.6,183.94 326.12,183.46 326.12,177.94 325.75,177.57 321.76,177.57 320.12,175.93 314.23,175.93 312.85,174.55 303.68,174.55 301.6,176.63 295.15,176.63 294.49,177.29 293.28,177.29 292.92,177.65 291.58,177.65 290.69,178.54 277.96,178.54 277.8,178.7 269.85,178.7 268.7,177.55 268.7,176.49 268.29,176.08 267.7,176.08 266.24,174.61 266.24,173.56 265.44,172.76 265.44,168.59 266.32,167.71 266.32,167.07 267.56,165.84 267.56,150.91 267.25,150.6 267.25,146.7 266.59,146.03 266.59,138.6 267,138.19 267,129.46 267.2,129.26 267.2,128.46 266.43,127.69 266.43,121.77 266.67,121.53 266.67,117.76 267.08,117.36 267.08,115.59 266.88,115.39 266.88,111.67 266.38,111.17 266.38,104.47 264.97,103.06 264.97,101.32 264.3,100.65 264.3,99.83 261.45,96.98 261.45,96.61 256.89,92.05 256.89,87.78 256.31,87.2 256.31,72.32 257.49,71.14 257.49,54.68 256.55,53.74 256.55,44.86 255.51,43.81 254.52,43.81 252.71,42 247.56,42 246.4,43.17 245.53,43.17 244.21,44.49 243.19,44.49 242.13,45.56 242.13,49.49 241.11,50.51 240.92,50.51 239.62,51.81 228.14,51.81 228,51.94 227.71,52.24 227.71,52.59 227.35,52.95 225.01,52.95 224.4,52.34 210.16,52.34 209.56,52.93 208.83,52.93 208.02,53.74 208.02,54.76 205.24,57.54 205.24,59.07 205.04,59.28 205.04,59.91 204.71,60.23 204.71,60.46
  BOTTOM w0.089: v2(205.56,64.86) 205.38,65.04 UH1.R7
  BOTTOM w0.102: R552.1 315.58,206.24 316.69,207.35 319.21,207.35 320.05,206.51 v4(320.05,205.16) 320.05,204.22 321.2,203.07 322.85,203.07 323.06,202.86 323.06,202.53 322.93,202.4 322.75,202.4 v2(322.59,202.56)
LAN_SMBDATA_R: length 5
  BOTTOM w0.102: U31.31 315.52,202.67 315.27,202.92 315.27,204.1 R552.2 315.64,204.41 316.11,204.88 316.11,206.16 v1(316.37,206.41)
LAN_TEST_EN: length 2.6
  BOTTOM w0.102: U31.30 315.12,202.49 315.02,202.59 315.02,203.95 R561.1
LAN_TX0+: length 28
  TOP w0.089: v2(297.46,193.6) 297.56,193.7 297.56,194.06 297.14,194.47 297.14,195.1 R25.1
  IN1 w0.089: v2(307.93,200.1) 308.03,200.2 308.03,200.21 308.08,200.26 308.08,200.58 307.77,200.9 305.9,200.9 305.42,200.42 305.08,200.42 305.08,200.42 299.82,200.42 299.09,199.69 299.09,197.65 298.56,197.12 298.56,196.48 299.25,195.8 299.25,193.68 299.25,193.23 298.69,192.67 298.06,192.67 297.63,193.1 297.63,193.42 v2(297.46,193.6)
  BOTTOM w0.089: v2(307.93,200.1) 308.22,199.81 308.22,198.85 310.17,196.9 311.69,196.9 311.77,196.82 U31.13
LAN_TX0+R: length 5.5
  TOP w0.089: U32.2 299.12,199.59 299.23,199.48 299.23,198.18 298.41,197.36 v4(298.09,197.36) 297.78,197.36 297.29,196.87 297.29,196.48 R25.2
LAN_TX0-: length 28
  TOP w0.089: R45.1 297.68,195.44 297.51,195.44 297.44,195.37 297.44,194.59 297.85,194.18 297.85,193.79 v2(298.04,193.6)
  IN1 w0.089: v2(308.52,200.1) 308.34,200.28 308.34,200.69 307.87,201.16 305.8,201.16 305.31,200.67 305.19,200.67 299.71,200.67 298.84,199.8 298.84,197.76 298.31,197.22 298.31,196.38 298.99,195.69 298.99,193.58 298.99,193.34 298.58,192.93 298.17,192.93 297.89,193.21 297.89,193.44 v2(298.04,193.6)
  BOTTOM w0.089: v2(308.52,200.1) 308.52,198.97 310.29,197.19 311.81,197.19 311.83,197.22 U31.14
LAN_TX0-R: length 5.5
  TOP w0.089: U32.3 299.62,199.59 299.53,199.49 v4(299.53,198.81) 299.53,198.06 298.53,197.07 297.9,197.07 297.58,196.75 297.58,196.46 R45.2
LAN_TX1+: length 18.8
  TOP w0.089: R46.1 300.34,195.1 300.34,193.77 v2(300.3,193.72)
  IN1 w0.089: v2(300.3,193.72) 300.63,193.39 300.63,192.78 301.32,192.09 305.08,192.09 306.15,193.17 306.15,195.37 307.4,196.61 308.91,196.61 309.86,197.56 310.78,198.48 311.17,198.48 v2(311.39,198.26)
  BOTTOM w0.089: U31.17 311.55,198.42 v2(311.39,198.26)
LAN_TX1+R: length 4.6
  TOP w0.089: R46.2 300.49,196.48 v4(300.49,197.4) 300.49,197.65 301.21,198.37 301.21,199.53 301.12,199.62 U32.6
