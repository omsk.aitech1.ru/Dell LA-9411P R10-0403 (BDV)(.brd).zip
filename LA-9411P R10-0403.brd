# Allegro board LA-9411P R10-0403.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
PCIE_PRX_GLANTX_N2: length 261.7
  IN4 w0.089: 201.85,84.53 201.85,83.53 203.77,81.61 205.28,81.61 205.56,81.33 206.26,81.33 206.92,80.67 206.92,80.37 206.61,80.07 206.61,79.56 207.29,78.88 207.29,78.82 207.23,78.77 206.85,78.77 v2(206.81,78.81)
  IN4 w0.114: 201.85,84.53 201.85,85.4 202.58,86.13 202.59,86.13 203.13,86.67 203.13,87.46 204.22,88.56 205.56,88.56 206.2,89.19 210.18,89.19 215.22,94.23 218.7,94.23 220.71,92.22 220.71,90.58 224.71,86.58 224.71,86.18 227.75,83.13 235.05,83.13 235.45,83.53 237.05,83.53 237.34,83.82 239.15,83.82 240.43,82.54 243.54,82.54 244.83,83.82 248.45,83.82 254.2,89.57 254.2,93.85 262.8,102.44 262.8,104.07 263.42,104.69 263.42,105.65 263.42,108.49 263.56,108.63 263.56,109.38 264.31,110.14 264.31,113.89 264.66,114.24 264.66,120.62 264.44,120.85 264.44,132.1 265.08,132.75 265.08,136.9 264.71,137.27 264.71,137.78 265.64,138.7 265.64,146.68 266.26,147.31 266.26,149.87 265.11,151.03 265.11,162.2 264.78,162.53 264.78,167.57 264.49,167.86 264.49,173.22 265.29,174.02 265.29,176.33 268.63,179.67 277.58,179.67 278.9,180.99 285.76,180.99 287.24,179.51 291.25,179.51 292.06,178.7 294.9,178.7 295.3,178.29 295.3,177.93 295.65,177.58 302.39,177.58 304.05,175.92 312.87,175.92 313.87,176.92 319.63,176.92 321.28,178.57 323.71,178.57 325.05,179.91 325.05,185.97 326.61,187.53 326.61,193.57 325.23,194.96 325.23,198.82 323.29,200.76 322.92,200.76 322.74,200.59 322.63,200.59 322.55,200.51 v2(322.55,200.25)
  BOTTOM w0.089: UH1.AT31 206.71,78.71 v2(206.81,78.81)
  BOTTOM w0.102: v2(322.55,200.25) 322.18,200.63 321.96,200.63 C459.2
PCIE_PRX_GLANTX_N2_C: length 2.6
  BOTTOM w0.102: C459.1 320.41,200.59 320.24,200.59 320.19,200.55 v4(319.72,200.55) 319.43,200.55 319.4,200.52 319.07,200.52 318.97,200.42 U31.39
PCIE_PRX_GLANTX_P2: length 261.7
  IN4 w0.089: v2(207.23,78.38) 207.23,78.49 207.49,78.74 207.49,78.97 206.82,79.64 206.82,79.98 207.12,80.29 207.12,80.76 206.35,81.53 205.65,81.53 205.37,81.81 203.86,81.81 202.09,83.58 202.09,84.77
  IN4 w0.114: 202.09,84.77 202.09,85.32 202.67,85.9 202.69,85.9 203.36,86.58 203.36,87.37 204.32,88.33 205.66,88.33 206.29,88.96 210.28,88.96 215.32,94.01 218.6,94.01 220.48,92.13 220.48,90.48 224.48,86.48 224.48,86.08 227.66,82.91 235.15,82.91 235.54,83.3 237.14,83.3 237.43,83.59 239.05,83.59 240.34,82.31 243.64,82.31 244.92,83.59 248.55,83.59 254.43,89.47 254.43,93.75 263.03,102.35 263.03,103.97 263.65,104.6 263.65,105.55 263.65,108.39 263.79,108.53 263.79,109.29 264.54,110.05 264.54,113.8 264.89,114.15 264.89,120.71 264.66,120.94 264.66,132 265.31,132.65 265.31,136.99 264.94,137.36 264.94,137.68 265.87,138.61 265.87,146.59 266.49,147.21 266.49,149.97 265.34,151.12 265.34,162.3 265.01,162.63 265.01,167.67 264.71,167.96 264.71,173.12 265.51,173.92 265.51,176.23 268.72,179.44 277.67,179.44 279,180.76 285.67,180.76 287.14,179.29 291.16,179.29 291.97,178.47 294.8,178.47 295.07,178.2 295.07,177.83 295.56,177.35 302.29,177.35 303.95,175.69 312.96,175.69 313.97,176.69 319.72,176.69 321.38,178.35 323.81,178.35 325.28,179.82 325.28,185.87 326.84,187.43 326.84,193.67 325.46,195.05 325.46,198.91 323.38,200.99 v2(322.54,200.99)
  BOTTOM w0.089: v2(207.23,78.38) 207.14,78.29 UH1.AR31
  BOTTOM w0.102: v2(322.54,200.99) 322.39,200.84 322.09,200.84 322.07,200.86 C458.2
PCIE_PRX_GLANTX_P2_C: length 2.7
  BOTTOM w0.102: C458.1 320.2,200.8 320.15,200.8 320.12,200.77 319.36,200.77 319.32,200.73 319.07,200.73 318.97,200.82 U31.38
PCIE_PRX_MMITX_N8: length 68.9
  TOP w0.102: C571.1 249.08,54.3 248.73,54.65 248.58,54.65 v2(248.39,54.46)
  IN4 w0.102: v2(209.19,80.47) 209.19,80.86 209.22,80.89 209.22,81.33 209.84,81.95 211.01,81.95
  IN4 w0.114: v2(248.39,54.46) 248.74,54.81 248.91,54.81 248.98,54.74 248.98,53.84 248.33,53.19 246.43,53.19 245.52,52.27 244.27,52.27 244.02,52.52 244.02,54.3 242.85,55.48 242.85,55.64 242.83,55.66 242.83,68.62 242.53,68.93 242.18,68.93 242.01,68.76 241.83,68.76 241.6,68.98 241.6,69.16 241.77,69.33 241.77,69.68 241.4,70.06 241.04,70.06 240.58,69.59 240.4,69.59 240.17,69.82 240.17,70 240.64,70.46 240.64,70.86 239.61,71.89 235.83,71.89 235.14,71.21 228.6,71.21 224.79,75.02 224.03,75.02 220.52,78.52 216.67,78.52 213.6,81.6 212.37,81.6 212.37,81.6 212.21,81.6 211.86,81.95 211.01,81.95
  BOTTOM w0.089: v2(209.19,80.47) 209.19,79.9 UH1.AN38
PCIE_PRX_MMITX_N8_C: length 9.9
  TOP w0.102: C571.2 250.37,54.61 250.52,54.61 v2(250.78,54.36) ; v2(250.48,49.14) 250.74,48.87 250.74,48.41 250.72,48.39 U38.8
  IN1 w0.114: v2(250.48,49.14) 250.68,49.34 250.65,49.37 250.65,49.55 250.27,49.92 250.27,51.26 249.88,51.65 249.88,52.65 251.29,54.06 251.29,54.77 251.26,54.8 251.14,54.8 250.95,54.62 250.87,54.62 250.78,54.53 v2(250.78,54.36)
PCIE_PRX_MMITX_P8: length 68.8
  TOP w0.102: C569.1 249.08,55.18 248.76,54.86 248.56,54.86 v2(248.39,55.04)
  IN4 w0.102: v2(209.61,80.89) 209.43,81.06 209.43,81.24 209.93,81.74 210.91,81.74 210.91,81.73 210.98,81.73 210.99,81.72 211.01,81.72
  IN4 w0.114: 211.01,81.72 211.77,81.72 212.12,81.37 212.27,81.37 212.28,81.37 213.51,81.37 214.31,80.57 216.58,78.3 220.43,78.3 223.93,74.79 224.7,74.79 228.51,70.98 235.24,70.98 235.92,71.67 239.51,71.67 240.41,70.77 240.41,70.56 239.94,70.09 239.94,69.72 240.3,69.36 240.67,69.36 241.14,69.83 241.3,69.83 241.54,69.59 241.54,69.43 241.37,69.26 241.37,68.89 241.73,68.53 242.1,68.53 242.27,68.7 242.43,68.7 242.6,68.53 242.6,55.56 242.62,55.55 242.62,55.38 243.79,54.21 243.79,52.43 244.17,52.04 245.61,52.04 246.53,52.96 248.43,52.96 249.21,53.74 249.21,54.84 249,55.04 v2(248.39,55.04)
  BOTTOM w0.089: v2(209.61,80.89) 209.61,80.33 UH1.AN39
PCIE_PRX_MMITX_P8_C: length 9.9
  TOP w0.102: U38.7 251.12,48.44 250.95,48.6 250.95,49 v2(251.08,49.13) ; C569.2 250.43,54.83 250.58,54.83 v2(250.78,55.03)
  IN1 w0.114: v2(251.08,49.13) 250.96,49.25 250.96,49.38 250.88,49.46 250.88,49.64 250.5,50.01 250.5,51.35 250.11,51.75 250.11,52.56 251.52,53.97 251.52,54.86 251.35,55.03 v2(250.78,55.03)
PCIE_PRX_WLANTX_N3: length 169.2
  IN1 w0.114: v2(249.18,175.93) 249.18,176.56 251.89,179.27 251.94,179.27 255.97,183.3 256.87,183.3 258.2,184.63 258.2,185.53 258.43,185.76 v2(258.43,186.31)
  IN4 w0.089: 202.39,82.37 203.84,80.92 205.3,80.92 205.69,80.53 205.7,80.53 205.74,80.49 v2(206.5,80.49)
  IN4 w0.114: v2(249.18,175.93) 249.18,172.38 250.83,170.73 250.83,168.57 251.32,168.09 251.32,157.51 252.46,156.37 252.46,149.36 249.93,146.84 249.93,142.9 249.87,142.84 249.87,138.28 249.7,138.12 249.7,130.8 250.72,129.78 250.72,119.35 248.28,116.91 248.28,109.46 246.83,108.01 246.83,107.46 243.58,104.21 243.58,102.15 240.13,98.7 235.75,98.7 234.92,97.88 225.51,97.88 224.47,98.92 214.17,98.92 213.65,99.44 212.21,99.44 211.92,99.15 211.92,98.62 211.79,98.49 211.37,98.49 211.25,98.62 211.25,99.23 210.99,99.49 210.36,99.49 210.1,99.23 210.1,98.35 209.96,98.21 206.12,98.21 202.33,94.42 202.33,90.94 201.87,90.48 201.87,90.08 200.24,88.45 200.24,86.87 199.89,86.53 199.89,84.87 202.39,82.37
  BOTTOM w0.089: v2(206.5,80.49) 206.5,80.47 206.27,80.24 UH1.AW33
  BOTTOM w0.102: v2(258.43,186.31) 258.61,186.49 258.61,186.68 258.92,186.99 259.6,186.99 260.84,185.76 263.2,185.76 263.34,185.9 263.34,186.07 263.05,186.36 JMINI2.23
PCIE_PRX_WLANTX_P3: length 169.2
  IN1 w0.114: v2(249.82,175.93) 249.77,175.93 249.41,176.29 249.41,176.47 251.98,179.04 252.03,179.04 256.07,183.07 256.97,183.07 258.43,184.53 258.43,185.43 258.66,185.66 258.66,185.95 v2(259.01,186.31)
  IN4 w0.089: 202.6,82.49 202.61,82.48 202.61,82.45 203.93,81.13 205.38,81.13 205.8,80.71 206.03,80.71 206.09,80.77 v2(206.09,80.94)
  IN4 w0.114: v2(249.82,175.93) 249.77,175.93 249.41,175.58 249.41,172.47 251.06,170.82 251.06,168.67 251.54,168.19 251.54,157.61 252.69,156.46 252.69,149.27 250.16,146.74 250.16,142.81 250.1,142.74 250.1,138.19 249.93,138.02 249.93,130.9 250.95,129.88 250.95,119.26 248.51,116.81 248.51,109.37 247.06,107.92 247.06,107.37 243.81,104.11 243.81,102.06 240.23,98.48 235.84,98.48 235.02,97.65 225.41,97.65 224.37,98.69 214.08,98.69 213.56,99.21 212.3,99.21 212.15,99.06 212.15,98.52 211.89,98.26 211.28,98.26 211.02,98.52 211.02,99.14 210.89,99.26 210.46,99.26 210.33,99.14 210.33,98.25 210.06,97.98 206.21,97.98 202.56,94.33 202.56,90.84 202.1,90.38 202.1,89.99 200.47,88.35 200.47,86.78 200.12,86.44 200.12,84.97 202.6,82.49
  BOTTOM w0.089: UH1.AY33 205.82,80.67 v2(206.09,80.94)
  BOTTOM w0.102: JMINI2.25 263.85,186.35 263.56,186.05 263.56,185.81 263.29,185.55 260.75,185.55 259.52,186.78 259,186.78 258.82,186.6 258.82,186.5 v2(259.01,186.31)
PCIE_PRX_WPANTX_N6: length 212.9
  IN1 w0.114: v2(273.19,135.23) 273.19,135.34 273.85,136.01 273.85,141.1 273.17,141.78 273.17,143.3 270.35,146.12 270.35,148.73 270.89,149.26 270.89,155.94 270.75,156.08 270.75,168.08 271.06,168.4 271.06,171.37 272.63,172.94 272.63,173.88 274.37,175.62 277.59,175.62 277.88,175.91 289.89,175.91 290.58,176.61 301.49,176.61 305.5,180.62 306.29,180.62 306.36,180.56 v2(306.36,180.33)
  IN4 w0.114: v2(206.78,81.64) 206.87,81.72 206.87,81.95 206.65,82.16 204.82,82.16 203.31,83.67 203.31,85.45 204.22,86.36 204.49,86.36 206.52,88.39 210.74,88.39 215.72,93.37 217.22,93.37 217.63,92.96 218.88,92.96 219.9,91.95 219.9,90.36 223.93,86.32 223.93,85.89 227.41,82.41 236.91,82.41 238.03,81.29 238.88,81.29 239.36,81.76 245.85,81.76 246.71,82.63 246.77,82.63 v2(247.12,82.98)
  BOTTOM w0.089: v2(206.78,81.64) 207.03,81.89 UH1.AY38
  BOTTOM w0.102: v2(273.19,135.23) 273.24,135.28 273.24,135.53 272.95,135.82 272.8,135.82 271.74,134.76 271.74,134.25 269.4,131.9 269.4,130.64 267.08,128.32 267.08,127.35 260.39,120.66 254.87,120.66 252.05,117.84 252.05,116.54 248.12,112.6 248.12,111.48 246.68,110.05 246.68,99.23 248.09,97.83 248.09,86.09 246.88,84.88 246.88,83.07 246.97,82.98 v2(247.12,82.98) ; v2(306.36,180.33) 306.67,180.65 306.67,181.41 306.43,181.65 306.43,183.48 306.26,183.65 JMINI3.23
PCIE_PRX_WPANTX_P6: length 213
  IN1 w0.114: v2(306.94,180.33) 306.42,180.85 305.41,180.85 301.39,176.83 290.49,176.83 289.79,176.14 277.79,176.14 277.5,175.84 274.27,175.84 272.4,173.98 272.4,173.04 270.84,171.47 270.84,168.49 270.52,168.17 270.52,155.99 270.66,155.85 270.66,149.36 270.12,148.82 270.12,146.02 272.94,143.2 272.94,141.69 273.62,141.01 273.62,136.24 273.43,136.04 v2(273.3,136.04)
  IN4 w0.114: v2(207.51,82.14) 206.99,82.14 206.74,82.39 204.91,82.39 203.54,83.76 203.54,85.36 204.32,86.13 204.59,86.13 206.62,88.16 210.83,88.16 215.81,93.14 217.13,93.14 217.53,92.74 218.79,92.74 219.67,91.85 219.67,90.27 223.71,86.23 223.71,85.8 227.32,82.18 236.81,82.18 237.94,81.06 238.98,81.06 239.45,81.53 245.94,81.53 246.81,82.4 v2(247.12,82.4)
  BOTTOM w0.089: UH1.AW38 207.49,81.66 207.49,82.13 207.53,82.17 207.53,82.16 v2(207.51,82.14)
  BOTTOM w0.102: v2(247.12,82.4) 246.67,82.85 246.67,84.97 247.87,86.18 247.87,97.74 246.47,99.14 246.47,110.13 247.9,111.57 247.9,112.69 251.84,116.62 251.84,117.93 254.78,120.87 260.31,120.87 266.87,127.43 266.87,128.41 269.18,130.73 269.18,131.99 271.53,134.33 271.53,134.85 272.71,136.03 273.29,136.03 v2(273.3,136.04) ; v2(306.94,180.33) 306.88,180.39 306.88,181.5 306.64,181.74 306.64,183.24 307.06,183.65 JMINI3.25
PCIE_PTX_EMBRX_N4: length 104.4
  IN4 w0.114: v2(204.66,84.84) 204.67,84.82 205.95,84.82 206.23,84.54 206.83,84.54 207.63,85.34 213.73,85.34 214.47,86.08 216.75,86.08 218.75,84.08 218.75,83.71 221.66,80.8 222.37,80.8 224.78,78.38 226.23,78.38 231,73.61 234.3,73.61 236.37,75.67 236.37,76.83 236.98,77.44 238.98,77.44 240.71,75.72 240.71,73.91 245.45,69.18 245.45,57.16 245.85,56.76 v2(245.85,55.98)
  BOTTOM w0.089: UH1.BE36 205.03,82.79 204.88,82.94 204.88,83.88 205.05,84.05 205.05,84.9 204.97,84.98 204.8,84.98 v2(204.66,84.84)
  BOTTOM w0.102: v2(245.85,55.98) 245.85,55.38 245.66,55.19 242.94,55.19 240.22,52.47 240.22,47.5 239.4,46.68 239.4,41.73 237.96,40.29 237.96,37.64 237.5,37.19 232.33,37.19 231.57,36.43 229.56,36.43 229.15,36.02 229.15,35.43 229.26,35.32 229.89,35.32 229.99,35.42 229.99,35.55 C408.2
PCIE_PTX_EMBRX_N4_C: length 8.9
  BOTTOM w0.102: C408.1 231.09,35.36 232.34,35.36 233.62,36.65 235.91,36.65 236.72,35.84 236.72,35.36 237.28,34.81 JSATA2.23
PCIE_PTX_EMBRX_P4: length 104.4
  IN4 w0.114: v2(245.22,56.01) 245.39,56.01 245.45,56.07 245.45,56.24 245.63,56.41 245.63,56.66 245.22,57.07 245.22,69.08 240.48,73.82 240.48,75.62 238.89,77.22 237.07,77.22 236.6,76.74 236.6,75.58 234.4,73.38 230.91,73.38 226.13,78.16 224.68,78.16 222.27,80.57 221.57,80.57 218.52,83.61 218.52,83.98 216.65,85.85 214.57,85.85 213.83,85.11 207.73,85.11 206.93,84.32 206.13,84.32 205.85,84.59 205.04,84.59 v2(204.67,84.23)
  BOTTOM w0.089: UH1.BC36 205.53,82.15 205.2,82.47 204.92,82.47 204.68,82.71 204.68,84.21 v2(204.67,84.23)
  BOTTOM w0.102: C409.2 229.42,35.11 229.17,35.11 228.94,35.34 228.94,36.11 229.47,36.64 231.49,36.64 232.24,37.4 237.42,37.4 237.75,37.73 237.75,40.38 239.19,41.82 239.19,46.76 240.01,47.58 240.01,52.56 242.85,55.4 245.57,55.4 245.64,55.47 245.64,55.58 v2(245.22,56.01)
PCIE_PTX_EMBRX_P4_C: length 8.9
  BOTTOM w0.102: C409.1 231.09,35.15 232.42,35.15 233.71,36.44 235.82,36.44 236.51,35.75 236.51,35.28 236.94,34.85 236.94,34.32 JSATA2.22
PCIE_PTX_EXPRX_N7: length 145.1
  TOP w0.102: C647.1 279.41,36.86 279.13,36.86 v2(278.94,36.68)
  IN4 w0.102: v2(206.1,85.97) 206.37,85.97 206.45,86.05 206.5,86.11 206.5,86.12 206.63,86.25 206.7,86.25 206.71,86.26 206.73,86.26
  IN4 w0.114: v2(251.62,58.47) 251.27,58.11 249.25,58.11 246.19,61.18 246.19,70.35 241.47,75.06 241.47,76.72 240.03,78.17 236.25,78.17 235.62,77.54 235.62,76.04 233.94,74.36 231.56,74.36 226.8,79.12 225.2,79.12 217.08,87.24 213.15,87.24 212.17,86.26 206.73,86.26
  BOTTOM w0.089: v2(206.1,85.97) 206.32,85.97 206.35,85.95 206.35,85.7 206.24,85.6 206.04,85.6 205.99,85.55 205.99,85.49 206.13,85.36 206.13,85.3 205.99,85.17 205.99,84.23 206.04,84.19 206.17,84.19 206.2,84.16 UH1.BE40
  BOTTOM w0.102: v2(278.94,36.68) 279.25,36.99 280.49,36.99 283.12,34.35 283.12,29.42 279.45,25.76 261.67,25.76 259.14,28.28 257.84,28.28 255.82,30.3 255.82,34.44 256.94,35.56 256.94,37.62 257.75,38.43 257.75,44.22 257.25,44.73 257.25,46.83 256.65,47.43 256.65,50.83 256.03,51.45 256.03,53.02 252.32,56.73 252.32,57.49 252.04,57.77 252.04,58.06 v2(251.62,58.47)
PCIE_PTX_EXPRX_N7_C: length 11.5
  TOP w0.102: C647.2 281.24,36.97 281.5,36.97 281.52,36.95 282.07,36.95 282.09,36.97 v4(283.23,36.97) 283.8,36.97 286.17,34.6 286.17,33.57 287.07,32.66 288.82,32.66 288.93,32.56 JEXP1.21
PCIE_PTX_EXPRX_P7: length 145.1
  TOP w0.102: v2(278.94,37.26) 279.13,37.07 279.41,37.07 C648.1
  IN4 w0.102: v2(206.68,85.52) 206.66,85.53 206.66,85.97 206.73,86.03
  IN4 w0.114: 206.73,86.03 212.26,86.03 213.24,87.01 216.99,87.01 225.1,78.89 226.7,78.89 231.47,74.13 234.03,74.13 235.85,75.95 235.85,77.44 236.35,77.94 239.93,77.94 241.24,76.63 241.24,74.96 245.96,70.25 245.96,61.08 249.15,57.89 v2(251.62,57.89)
  BOTTOM w0.089: v2(206.68,85.52) 206.49,85.52 206.42,85.45 206.42,85.32 206.19,85.09 206.19,84.44 206.55,84.09 206.55,83.62 206.87,83.29 UH1.BC40
  BOTTOM w0.102: v2(278.94,37.26) 279.01,37.2 280.58,37.2 283.33,34.44 283.33,29.34 279.54,25.54 261.58,25.54 259.06,28.07 257.75,28.07 255.61,30.21 255.61,34.53 256.73,35.65 256.73,37.71 257.54,38.52 257.54,44.13 257.04,44.64 257.04,46.74 256.44,47.34 256.44,50.74 255.82,51.37 255.82,52.93 252.11,56.64 252.11,57.4 v2(251.62,57.89)
PCIE_PTX_EXPRX_P7_C: length 11.5
  TOP w0.102: JEXP1.23 288.91,33.06 288.73,32.87 287.16,32.87 286.38,33.65 286.38,34.51 286.38,34.68 283.88,37.18 283.52,37.18 283.5,37.2 282.96,37.2 282.94,37.18 v4(281.8,37.18) 281.03,37.18 C648.2
PCIE_PTX_GLANRX_N2: length 261.4
  IN4 w0.114: v2(201.13,86.66) 201.21,86.75 201.21,87.78 202.55,89.12 203.04,89.12 203.22,89.29 205.2,89.29 206.45,90.55 210.26,90.55 214.7,94.98 219.9,94.98 221.67,93.21 221.67,90.64 224.48,87.84 224.59,87.84 228.57,83.86 234.46,83.86 234.88,84.28 236.63,84.28 236.9,84.54 240.27,84.54 240.64,84.17 240.64,83.78 240.77,83.65 241.37,83.65 241.5,83.78 241.5,84.28 241.76,84.54 247.98,84.54 252.34,88.91 252.34,91.78 253.34,92.77 253.34,94.01 262.01,102.69 262.01,104.39 262.7,105.08 262.7,105.95 262.7,108.79 262.82,108.91 262.82,109.68 263.57,110.43 263.57,114.2 263.94,114.57 263.94,120.11 263.7,120.35 263.7,134.81 263.79,134.9 263.79,138.43 264.13,138.77 264.38,138.77 264.89,139.29 264.89,150.14 264.3,150.74 264.3,157.9 264.38,157.98 264.38,161.84 264.05,162.17 264.05,167.23 263.74,167.55 263.74,173.59 264.56,174.41 264.56,177.18 267.81,180.43 277.22,180.43 279.41,182.61 280.73,182.61 280.98,182.36 280.98,182.26 281.09,182.14 281.43,182.14 281.55,182.26 281.55,182.36 281.8,182.61 282.33,182.61 282.58,182.36 282.58,182.26 282.69,182.14 283.72,182.14 283.79,182.08 284.11,181.75 286.06,181.75 286.62,181.19 287.61,181.19 287.72,181.3 287.72,182.03 287.97,182.28 288.5,182.28 288.75,182.03 288.75,181.3 288.87,181.19 290.65,181.19 292.41,179.44 295.24,179.44 295.98,178.7 302.36,178.7 304.36,176.69 309.32,176.69 309.44,176.81 309.44,177.5 309.7,177.76 310.21,177.76 310.47,177.5 310.47,176.81 310.58,176.69 310.92,176.69 311.04,176.81 311.04,177.6 311.3,177.86 311.81,177.86 312.07,177.6 312.07,176.81 312.18,176.69 312.54,176.69 312.67,176.82 312.67,177.39 312.98,177.7 313.55,177.7 313.85,178 319.67,178 321.05,179.37 323.45,179.37 324.26,180.19 324.26,188.2 325.38,189.32 325.38,193.71 324.42,194.67 324.42,197.71 323.54,198.59 323.2,198.59 323.06,198.73 322.78,198.73 v2(322.56,198.51)
  BOTTOM w0.089: 203.32,84.77 203.32,84.76 203.33,84.75 203.33,84.69 203.33,84.68 203.33,83.62 203.61,83.34 203.61,83.17 203.85,82.92 203.85,82.38 203.97,82.26 203.97,81.99 204.19,81.77 204.19,81.61 204.3,81.5 204.38,81.5 UH1.BD33
  BOTTOM w0.102: v2(322.56,198.51) 322.39,198.68 322.05,198.68 C461.1 ; 203.32,84.77 203.32,85.44 202.12,86.64 201.79,86.64 201.34,87.08 201.13,87.08 200.99,86.94 200.99,86.8 v2(201.13,86.66)
PCIE_PTX_GLANRX_N2_C: length 2.9
  BOTTOM w0.102: U31.42 318.97,199.22 319.07,199.32 319.49,199.32 319.51,199.3 319.56,199.3 320.17,198.68 320.28,198.68 C461.2
PCIE_PTX_GLANRX_P2: length 261.5
  IN4 w0.114: v2(201.8,87.22) 201.6,87.22 201.44,87.38 201.44,87.68 202.65,88.89 203.14,88.89 203.32,89.06 205.29,89.06 206.55,90.32 210.36,90.32 214.79,94.75 219.8,94.75 221.45,93.11 221.45,90.54 224.38,87.61 224.5,87.61 228.48,83.63 234.55,83.63 234.97,84.05 236.72,84.05 236.99,84.32 240.17,84.32 240.42,84.07 240.42,83.69 240.68,83.43 241.47,83.43 241.73,83.69 241.73,84.19 241.85,84.32 248.08,84.32 252.57,88.81 252.57,91.69 253.56,92.68 253.56,93.92 262.24,102.59 262.24,104.29 262.93,104.98 262.93,105.85 262.93,108.69 263.05,108.82 263.05,109.58 263.8,110.33 263.8,114.11 264.17,114.48 264.17,120.21 263.93,120.45 263.93,134.72 264.02,134.8 264.02,138.34 264.23,138.54 264.47,138.54 265.12,139.19 265.12,150.23 264.52,150.83 264.52,157.81 264.61,157.89 264.61,161.94 264.28,162.26 264.28,167.32 263.97,167.64 263.97,173.49 264.79,174.32 264.79,177.08 267.91,180.2 277.32,180.2 279.5,182.38 280.63,182.38 280.75,182.27 280.75,182.16 281,181.91 281.53,181.91 281.78,182.16 281.78,182.27 281.89,182.38 282.23,182.38 282.35,182.27 282.35,182.16 282.6,181.91 283.62,181.91 284.02,181.52 285.96,181.52 286.52,180.96 287.7,180.96 287.95,181.21 287.95,181.94 288.07,182.05 288.41,182.05 288.52,181.94 288.52,181.21 288.77,180.96 290.56,180.96 292.31,179.21 295.14,179.21 295.88,178.47 302.26,178.47 304.27,176.47 309.42,176.47 309.67,176.71 309.67,177.41 309.79,177.53 310.11,177.53 310.24,177.41 310.24,176.71 310.49,176.47 311.02,176.47 311.27,176.71 311.27,177.51 311.39,177.63 311.71,177.63 311.84,177.51 311.84,176.71 312.09,176.47 312.64,176.47 312.9,176.73 312.9,177.29 313.08,177.47 313.64,177.47 313.95,177.77 319.77,177.77 321.14,179.15 323.54,179.15 324.49,180.1 324.49,188.11 325.61,189.22 325.61,193.8 324.65,194.77 324.65,197.8 323.63,198.82 323.29,198.82 323.15,198.96 322.75,198.96 v2(322.56,199.15)
  BOTTOM w0.089: UH1.BB33 205.12,80.99 204.8,81.31 204.8,81.7 204.59,81.9 204.34,81.9 204.16,82.08 204.16,82.37 204.05,82.49 204.05,83.01 203.81,83.25 203.81,83.43 203.53,83.7 203.53,84.75
  BOTTOM w0.102: 203.53,84.75 203.53,85.53 202.21,86.85 201.87,86.85 201.8,86.92 v2(201.8,87.22) ; C460.1 322,198.89 322.31,198.89 v2(322.56,199.15)
PCIE_PTX_GLANRX_P2_C: length 2.9
  BOTTOM w0.102: C460.2 320.33,198.89 320.26,198.89 319.64,199.51 319.59,199.51 319.58,199.53 319.07,199.53 318.97,199.62 U31.41
PCIE_PTX_MMIRX_N8: length 66.5
  TOP w0.102: C568.1 248.68,56.89 248.57,56.89 v2(248.39,57.07)
  IN4 w0.089: v2(207.41,83.79) 207.41,83.79 207.41,83.77 207.56,83.62 207.61,83.62 208.48,84.49 209.18,84.49 209.19,84.51 209.26,84.51 209.27,84.52 209.28,84.52
  IN4 w0.114: v2(248.39,57.07) 248.22,56.91 246.93,56.91 246.64,56.62 246.64,55.53 246.4,55.28 245.17,55.28 244.32,56.13 244.32,63.35 244.31,63.35 244.31,63.7 244.32,63.7 244.32,69.28 239.98,73.62 235.45,73.62 234.67,72.85 230.68,72.85 226.18,77.34 224.76,77.34 222.1,80 219.85,80 218,81.84 218,83.8 217.54,84.26 215.71,84.26 215.38,83.93 209.96,83.93 209.38,84.52 209.28,84.52
  BOTTOM w0.089: v2(207.41,83.79) 207.41,83.79 207.41,83.79 207.63,84.01 207.63,84.23 207.55,84.31 UH1.BD42
PCIE_PTX_MMIRX_N8_C: length 12.3
  TOP w0.102: v2(250.86,57.12) 250.64,56.91 250.38,56.91 C568.2 ; U38.5 251.92,48.5 251.87,48.54 251.79,48.54 251.73,48.6 251.73,48.78 251.81,48.87 251.99,48.87 252.09,48.97 252.09,49.11 v2(251.91,49.29)
  IN1 w0.114: v2(251.91,49.29) 251.97,49.35 251.97,52.51 252.59,53.13 252.59,56.3 251.77,57.12 v2(250.86,57.12)
PCIE_PTX_MMIRX_P8: length 66.5
  TOP w0.102: v2(248.39,56.49) 248.57,56.68 248.68,56.68 C567.1
  IN4 w0.089: 209.28,84.29 208.57,84.29 207.69,83.41 207.58,83.41 v2(207.36,83.2)
  IN4 w0.114: v2(248.39,56.49) 248.2,56.68 247.02,56.68 246.87,56.53 246.87,55.44 246.49,55.05 245.07,55.05 244.09,56.04 244.09,63.25 244.08,63.26 244.08,63.79 244.09,63.8 244.09,69.19 239.88,73.39 235.54,73.39 234.77,72.62 230.58,72.62 226.09,77.11 224.67,77.11 222.01,79.77 219.75,79.77 217.78,81.75 217.78,83.71 217.45,84.04 215.81,84.04 215.48,83.71 209.87,83.71 209.28,84.29
  BOTTOM w0.089: UH1.BD41 206.89,83.67 v2(207.36,83.2)
PCIE_PTX_MMIRX_P8_C: length 12.3
  TOP w0.102: v2(251.37,49.67) 251.37,49.42 251.49,49.3 251.49,49.17 251.52,49.14 U38.6 ; v2(250.87,56.44) 250.61,56.7 250.42,56.7 C567.2
  IN1 w0.114: v2(250.87,56.44) 250.87,56.62 250.97,56.72 251.04,56.72 251.21,56.9 251.67,56.9 252.36,56.2 252.36,53.22 251.74,52.6 251.74,49.7 251.62,49.58 251.46,49.58 v2(251.37,49.67)
PCIE_PTX_WLANRX_N3: length 164.5
  TOP w0.102: C596.1 266.38,188.07 266.38,187.1 266.21,186.93 266.21,186.03 266.04,185.85 266.01,185.85 v2(266,185.84)
  IN1 w0.114: v2(251.62,175.69) 251.27,176.04 251.27,176.69 252.9,178.33 252.9,178.7 256.15,181.94 257.1,181.94 261.43,186.27 266.17,186.27 266.4,186.04 266.4,185.88 266.31,185.79 266.05,185.79 v2(266,185.84)
  IN4 w0.114: v2(203.4,89.91) 203.15,89.91 203.06,90 203.06,90.25 203.3,90.49 203.3,93.89 206.61,97.21 210.47,97.21 210.59,97.09 210.59,96.65 210.85,96.39 211.35,96.39 211.62,96.65 211.62,97.09 211.73,97.21 212.54,97.21 213.27,97.93 224.09,97.93 225.13,96.89 239.69,96.89 244.56,101.76 244.56,103.77 249.3,108.51 249.3,114.78 251.72,117.21 251.72,130.38 251.11,130.99 251.11,138.49 251.62,139 251.62,142.23 251.11,142.74 251.11,146.42 253.5,148.81 253.5,156.81 252.83,157.49 252.83,160.44 252.64,160.63 252.64,168.22 251.82,169.03 251.82,173.35 251.27,173.91 251.27,175.33 v2(251.62,175.69)
  BOTTOM w0.102: UH1.BE34 204.46,82.35 204.24,82.56 204.24,83.18 204.1,83.32 204.1,83.4 203.84,83.66 203.84,84.12 204.01,84.29 204.01,85.85 203.57,86.3 203.54,86.3 203.07,86.77 203.07,86.79 202.31,87.56 202.31,89.74 202.66,90.08 203.23,90.08 v2(203.4,89.91)
PCIE_PTX_WLANRX_N3_C: length 4.8
  TOP w0.102: v2(266.23,190.5) 266.45,190.28 266.45,189.72 C596.2
  BOTTOM w0.102: JMINI2.31 266.25,188.51 266.54,188.8 266.54,189.6 266.42,189.73 266.42,190.31 v2(266.23,190.5)
PCIE_PTX_WLANRX_P3: length 164.5
  TOP w0.102: C598.1 266.59,187.93 266.59,187.01 266.42,186.85 266.42,186.39 v2(266.85,185.97)
  IN1 w0.114: v2(251.04,175.69) 251.04,176.78 252.67,178.42 252.67,178.79 256.05,182.17 257.01,182.17 261.34,186.5 266.31,186.5 v2(266.85,185.97)
  IN4 w0.114: v2(202.83,89.65) 202.83,90.34 203.07,90.58 203.07,93.99 206.52,97.43 210.57,97.43 210.82,97.19 210.82,96.75 210.94,96.62 211.26,96.62 211.39,96.75 211.39,97.19 211.64,97.43 212.45,97.43 213.17,98.16 224.18,98.16 225.22,97.12 239.59,97.12 244.33,101.85 244.33,103.87 249.07,108.6 249.07,114.88 251.49,117.3 251.49,130.28 250.88,130.89 250.88,138.59 251.39,139.1 251.39,142.13 250.88,142.64 250.88,146.51 253.27,148.9 253.27,156.72 252.6,157.39 252.6,160.34 252.41,160.53 252.41,168.12 251.6,168.94 251.6,173.26 251.04,173.82 v2(251.04,175.69)
  BOTTOM w0.089: 204.64,82.47 204.77,82.33 204.77,82.03 205.1,81.7 UH1.BC34
  BOTTOM w0.102: 204.64,82.47 204.45,82.65 204.45,83.26 204.31,83.4 204.31,83.49 204.05,83.75 204.05,84.03 204.22,84.2 204.22,85.94 v4(203.44,86.73) 202.52,87.64 202.52,89.14 202.6,89.22 202.78,89.22 202.83,89.17 202.95,89.17 203.06,89.27 203.06,89.42 v2(202.83,89.65)
PCIE_PTX_WLANRX_P3_C: length 4.8
  TOP w0.102: v2(266.81,190.5) 266.66,190.35 266.66,189.72 C598.2
  BOTTOM w0.102: v2(266.81,190.5) 266.63,190.31 266.63,189.82 266.76,189.69 266.76,188.8 267.05,188.51 JMINI2.33
PCIE_PTX_WPANRX_N6: length 210
  TOP w0.102: v2(309.51,180.59) 309.75,180.59 309.8,180.64 309.8,180.97 C617.1
  IN1 w0.114: v2(203.56,88.63) 203.56,88.6 203.32,88.84 203.32,88.94 203.46,89.08 203.99,89.08 204.18,89.27 205.26,89.27 208.75,92.76 209.17,92.76 209.5,92.42 209.87,92.42 210.27,92.82 210.27,93.19 209.82,93.64 209.82,93.82 210.04,94.04 210.22,94.04 210.62,93.64 210.97,93.64 211.46,94.13 211.46,94.48 210.64,95.29 210.64,95.45 210.88,95.7 211.05,95.7 211.86,94.88 212.21,94.88 212.59,95.26 212.59,95.61 211.77,96.42 211.77,96.59 212.02,96.83 212.18,96.83 212.99,96.01 213.34,96.01 213.72,96.39 213.72,96.74 212.9,97.56 212.9,97.72 213.15,97.96 213.31,97.96 214.12,97.14 214.48,97.14 214.85,97.52 214.85,97.87 214.04,98.69 214.04,98.85 214.28,99.09 214.44,99.09 215.26,98.28 215.61,98.28 216.23,98.9 217.38,98.9 217.62,99.15 217.62,99.81 217.75,99.94 218.07,99.94 218.2,99.81 218.2,99.15 218.44,98.9 224.68,98.9 225,99.22 226.73,99.22 226.95,99.01 235,99.01 235.95,98.06 242.51,98.06 246.55,102.1 247.77,102.1 247.97,101.89 v2(248.02,101.89) ; v2(309.51,180.59) 309.74,180.59 309.85,180.48 309.85,180.4 310,180.25 310,180.14 309.58,179.72 308.97,179.72 308.72,179.72 306.87,181.57 304.86,181.57 300.86,177.57 290.15,177.57 289.44,176.86 286.96,176.86 286.46,177.37 280.2,177.37 279.8,176.96 273.95,176.96 273.85,176.86 273.11,176.86 271.9,175.65 270.75,175.65 270.28,175.18 270.28,174.31 269.74,173.77 269.74,169.69 269.18,169.13 269.18,167.99 268.85,167.66 268.85,166.89 269.79,165.95 269.79,155.58 269.92,155.45 269.92,149.77 269.16,149.01 269.16,145.92 272.22,142.86 272.22,141.38 272.9,140.7 272.9,137.51 272.46,137.08 272.46,134.86 272.89,134.42 272.89,133.57 272.72,133.4 272.66,133.4 272.59,133.47 v2(272.46,133.6)
  BOTTOM w0.089: UH1.BC38 206.25,82.85 205.93,83.17 205.93,83.78 205.81,83.9 205.81,85.55 205.74,85.62
  BOTTOM w0.102: v2(203.56,88.63) 203.56,88.63 203.56,88.62 203.56,88.58 204.28,87.85 204.28,87.08 205.74,85.62 ; v2(248.02,101.89) 247.86,102.04 247.56,102.04 247.17,102.43 247.17,109.08 248.69,110.6 248.69,112.46 252.55,116.33 252.55,117.63 254.67,119.75 260.28,119.75 267.6,127.07 267.6,128.08 269.9,130.38 269.9,131.55 271.95,133.6 v2(272.46,133.6)
PCIE_PTX_WPANRX_N6_C: length 3.1
  TOP w0.102: v2(309.62,183.18) 309.85,182.95 309.85,182.58 C617.2
  BOTTOM w0.102: v2(309.62,183.18) 309.8,183.36 309.8,183.64 309.46,183.98 JMINI3.31
PCIE_PTX_WPANRX_P6: length 210
  TOP w0.102: v2(310.26,180.58) 310.02,180.83 310.02,180.92 310.38,181.29 C618.1
  IN1 w0.114: v2(247.98,102.48) 247.82,102.32 246.46,102.32 242.42,98.29 236.04,98.29 235.09,99.24 227.04,99.24 226.82,99.45 224.91,99.45 224.58,99.13 218.54,99.13 218.42,99.24 218.42,99.9 218.16,100.16 217.66,100.16 217.4,99.9 217.4,99.24 217.28,99.13 216.14,99.13 215.51,98.5 215.35,98.5 214.53,99.32 214.18,99.32 213.81,98.94 213.81,98.59 214.62,97.78 214.62,97.62 214.38,97.37 214.22,97.37 213.4,98.19 213.05,98.19 212.68,97.81 212.68,97.46 213.49,96.65 213.49,96.48 213.25,96.24 213.09,96.24 212.27,97.06 211.92,97.06 211.54,96.68 211.54,96.33 212.36,95.51 212.36,95.35 212.12,95.11 211.96,95.11 211.14,95.93 210.79,95.93 210.41,95.55 210.41,95.2 211.23,94.38 211.23,94.22 210.88,93.87 210.72,93.87 210.32,94.27 209.95,94.27 209.59,93.91 209.59,93.54 210.04,93.09 210.04,92.91 209.78,92.65 209.6,92.65 209.26,92.99 208.66,92.99 205.16,89.5 204.08,89.5 203.89,89.31 203.36,89.31 203.02,88.96 v2(203.02,88.32) ; v2(310.26,180.58) 310.23,180.55 310.23,180.05 309.67,179.49 309.07,179.49 308.63,179.49 306.77,181.34 304.95,181.34 300.95,177.34 290.25,177.34 289.54,176.63 286.87,176.63 286.36,177.14 280.3,177.14 279.89,176.73 274.04,176.73 273.94,176.63 273.2,176.63 272,175.42 270.84,175.42 270.51,175.09 270.51,174.21 269.97,173.68 269.97,169.6 269.41,169.04 269.41,167.89 269.08,167.56 269.08,166.99 270.02,166.05 270.02,155.68 270.15,155.55 270.15,149.68 269.39,148.91 269.39,146.01 272.45,142.95 272.45,141.48 273.13,140.8 273.13,137.42 272.69,136.98 272.69,134.95 273.12,134.52 273.12,133.48 272.82,133.17 272.61,133.17 v2(272.46,133.02)
  BOTTOM w0.089: UH1.BE38 205.73,83.48 205.73,83.7 205.61,83.81 205.61,85.45 205.59,85.47
  BOTTOM w0.102: v2(272.46,133.02) 272.09,133.39 272.03,133.39 270.11,131.47 270.11,130.29 267.81,128 267.81,126.98 260.37,119.54 254.76,119.54 252.76,117.54 252.76,116.24 248.9,112.38 248.9,110.51 247.38,108.99 247.38,102.52 247.64,102.26 247.76,102.26 v2(247.98,102.48) ; 205.59,85.47 204.07,86.99 204.07,87.76 203.61,88.23 203.46,88.23 203.4,88.16 203.4,87.99 203.28,87.87 203.08,87.87 203.02,87.93 v2(203.02,88.32)
PCIE_PTX_WPANRX_P6_C: length 3.1
  TOP w0.102: v2(310.26,183.18) 310.07,182.99 310.07,182.64 C618.2
  BOTTOM w0.102: JMINI3.33 310.26,184.04 310.02,183.79 310.02,183.43 v2(310.26,183.18)
PCIE_SATA_PRX_WANTX_N4: length 287.2
  TOP w0.102: v2(323.39,124.98) 323.58,125.17 323.58,125.44 C424.2
  IN1 w0.114: v2(274.19,120.93) 274.19,121.11 274.3,121.22 274.38,121.22 274.54,121.39 274.55,121.39 274.76,121.18 274.76,111.14 275.61,110.28 275.61,98.65 275.02,98.06 275.02,93.57 274.09,92.63 274.09,74.43 271.58,71.92 271.58,71.27 259.9,59.59 259.9,57.65 256.22,53.96 256.22,49.43 254.53,47.74 245.75,47.74 244.33,49.16 243.26,49.16 240.1,46 240.1,40.69 236.62,37.21 234.74,37.21 231.47,33.94 231.47,28.52 229.35,26.4 216.23,26.4 213.36,29.27 203.28,29.27 193.39,39.17 193.39,41.92 193.07,42.24 193.07,43.66 186.82,49.92 186.82,51.28 180.27,57.82 180.27,69.89 185.12,74.74 190.35,74.74 192.9,77.29 192.9,78.01 193.79,78.9 194.05,78.9 194.38,79.24 194.55,79.24 194.65,79.13 194.65,78.91 v2(194.47,78.73)
  IN2 w0.127: v2(274.19,120.93) 274.19,121.11 274.29,121.21 274.38,121.21 274.53,121.36 275.14,121.36 276.06,120.43 279.15,120.43 279.93,121.21 282.28,121.21 282.93,121.86 284.18,121.86 284.49,121.55 284.49,120.07 285.35,119.21 291.48,119.21 291.57,119.3 294.03,119.3 294.86,120.13 296.07,120.13 301.63,125.69 319.26,125.69 319.97,126.4 323.02,126.4 323.58,125.84 323.58,125.17 v2(323.39,124.98)
  BOTTOM w0.089: UH1.BD13 198.51,75.84 198.46,75.89 198.46,75.99 198.24,76.21 198.13,76.21 198.03,76.31 198.03,76.42 197.96,76.49 197.82,76.49 197.7,76.62 197.7,76.75 197.6,76.85 197.47,76.85 197.34,76.97 197.34,77.11 197.28,77.17
  BOTTOM w0.102: v2(194.47,78.73) 194.26,78.52 194.06,78.52 193.96,78.63 193.96,78.83 194.32,79.19 194.87,79.19 195.03,79.02 195.03,78.35 195.81,77.58 196.87,77.58 197.28,77.17
PCIE_SATA_PRX_WANTX_N4_C: length 2.3
  TOP w0.102: C424.1 323.58,127.16 323.58,127.43 323.26,127.75 323.26,128.07 323.11,128.21 U7.4
PCIE_SATA_PRX_WANTX_P4: length 287.3
  TOP w0.102: v2(323.97,124.98) 323.79,125.16 323.79,125.45 C422.2
  IN1 w0.114: v2(193.95,79.39) 193.95,79.39 192.67,78.1 192.67,77.38 190.25,74.97 185.03,74.97 180.04,69.98 180.04,57.73 186.59,51.18 186.59,49.82 192.85,43.57 192.85,42.15 193.16,41.83 193.16,39.07 203.19,29.04 213.27,29.04 216.14,26.17 229.45,26.17 231.69,28.42 231.69,33.85 234.83,36.98 236.72,36.98 240.33,40.6 240.33,45.9 243.36,48.93 244.24,48.93 245.66,47.51 254.63,47.51 256.45,49.33 256.45,53.87 260.13,57.55 260.13,59.5 271.8,71.17 271.8,71.82 274.32,74.33 274.32,92.54 275.25,93.47 275.25,97.96 275.84,98.55 275.84,110.38 274.99,111.23 274.99,121.27 274.65,121.61 v2(274.19,121.61)
  IN2 w0.127: v2(274.19,121.61) 275.24,121.61 276.17,120.69 279.05,120.69 279.82,121.46 282.17,121.46 282.82,122.11 284.29,122.11 284.74,121.66 284.74,120.18 285.45,119.47 291.37,119.47 291.46,119.56 293.92,119.56 294.75,120.38 295.97,120.38 301.53,125.95 319.16,125.95 319.87,126.66 323.13,126.66 323.83,125.95 323.83,125.12 v2(323.97,124.98)
  BOTTOM w0.089: 197.43,77.32 198.59,76.16 198.86,76.16 199.04,75.98 199.04,75.5 199.31,75.23 UH1.BB13
  BOTTOM w0.102: 197.43,77.32 196.96,77.79 195.89,77.79 195.25,78.43 195.25,79.11 194.95,79.4 193.96,79.4 v2(193.95,79.39)
PCIE_SATA_PRX_WANTX_P4_C: length 2.3
  TOP w0.102: U7.5 323.61,128.24 323.47,128.1 323.47,127.83 323.79,127.51 323.79,127.16 C422.1
PCIE_SATA_PTX_WANRX_N4: length 288.6
  TOP w0.102: C417.2 321.78,125.47 321.78,125.16 v2(321.97,124.98)
  IN1 w0.089: v2(200.63,74.45) 200.31,74.45 200.19,74.32 199.92,74.32 198.88,75.36 198.88,75.37 197.33,76.92 197.18,76.92 197.13,76.96 197.11,76.96 197.11,76.97
  IN1 w0.114: 197.11,76.97 196.93,77.15 195.3,77.15 194.18,76.03 193.65,76.03 191.49,73.88 186.01,73.88 181.16,69.03 181.16,63.96 181.86,63.26 181.86,57.45 188.13,51.18 188.13,49.97 193.99,44.11 193.99,42.54 194.24,42.28 194.24,39.63 203.71,30.16 213.78,30.16 216.63,27.32 229.05,27.32 230.42,28.69 230.42,34.59 234.09,38.26 236.43,38.26 239.23,41.06 239.23,46.41 240.55,47.73 240.55,49.31 242.06,50.83 246.42,50.83 248.62,48.63 253,48.63 253.51,49.14 254.65,49.14 255.3,49.79 255.3,54.25 259.04,57.99 259.04,59.97 260.35,61.28 260.35,61.51 260.14,61.72 260.14,62.2 260.57,62.63 260.94,62.63 261.23,62.33 261.4,62.33 261.64,62.58 261.64,62.74 261.32,63.06 261.32,63.43 261.68,63.78 262.05,63.78 262.37,63.46 262.53,63.46 262.77,63.71 262.77,63.87 262.41,64.23 262.41,64.59 262.77,64.95 263.14,64.95 263.5,64.6 263.66,64.6 263.9,64.84 263.9,65 263.53,65.37 263.53,65.74 263.89,66.1 264.26,66.1 264.63,65.73 264.79,65.73 265.03,65.97 265.03,66.13 264.64,66.53 264.64,66.9 265,67.26 265.37,67.26 265.76,66.86 265.92,66.86 266.17,67.1 266.17,67.26 265.77,67.66 265.77,68.03 266.13,68.39 266.5,68.39 266.89,67.99 267.05,67.99 267.3,68.23 267.3,68.4 267.04,68.65 267.04,69.04 271.85,73.85 272.27,73.85 272.4,73.98 272.4,74.56 272.27,74.69 271.47,74.69 271.2,74.95 271.2,75.69 271.47,75.95 272.68,75.95 272.8,76.08 272.8,77.3 272.68,77.43 271.75,77.43 271.51,77.67 271.51,91.28 274.17,93.94 274.17,98.41 274.48,98.72 274.48,106.34 273.95,106.87 273.95,110.64 273.6,110.98 273.6,119.2 273.79,119.39 273.83,119.39 v2(274.19,119.75)
  IN2 w0.127: v2(321.97,124.98) 321.8,125.15 321.8,125.52 321.55,125.77 320.3,125.77 319.59,125.06 302.23,125.06 295.49,118.31 291.88,118.31 291.65,118.54 285.07,118.54 283.35,120.27 280.26,120.27 279.79,119.8 276,119.8 275.81,119.61 274.33,119.61 v2(274.19,119.75)
  BOTTOM w0.089: UH1.AV15 200.73,74.55 v2(200.63,74.45)
PCIE_SATA_PTX_WANRX_N4_C: length 2.3
  TOP w0.102: U7.2 322.11,128.24 321.97,128.1 321.97,127.79 321.75,127.57 321.75,127.16 C417.1
PCIE_SATA_PTX_WANRX_P4: length 288.7
  TOP w0.102: v2(321.38,124.98) 321.57,125.17 321.57,125.41 C416.2
  IN1 w0.089: v2(200.16,74.92) 200.16,74.59 200.09,74.52 200,74.52 199.08,75.45 199.08,75.46 197.41,77.13 197.27,77.13
  IN1 w0.114: v2(274.19,119.16) 273.89,119.16 273.83,119.11 273.83,111.07 274.18,110.73 274.18,106.96 274.71,106.43 274.71,98.62 274.4,98.31 274.4,93.85 271.74,91.19 271.74,77.77 271.85,77.66 272.77,77.66 273.03,77.4 273.03,75.99 272.77,75.72 271.56,75.72 271.43,75.6 271.43,75.04 271.56,74.92 272.37,74.92 272.63,74.66 272.63,73.88 272.37,73.62 271.94,73.62 267.27,68.95 267.27,68.75 267.53,68.49 267.53,68.14 267.15,67.76 266.8,67.76 266.4,68.16 266.22,68.16 266,67.93 266,67.75 266.39,67.36 266.39,67.01 266.02,66.63 265.67,66.63 265.27,67.03 265.09,67.03 264.87,66.8 264.87,66.62 265.26,66.23 265.26,65.88 264.89,65.5 264.53,65.5 264.16,65.87 263.99,65.87 263.76,65.64 263.76,65.47 264.13,65.1 264.13,64.74 263.75,64.37 263.4,64.37 263.05,64.73 262.87,64.73 262.64,64.5 262.64,64.32 263,63.96 263,63.61 262.62,63.24 262.27,63.24 261.95,63.56 261.77,63.56 261.55,63.33 261.55,63.15 261.87,62.83 261.87,62.48 261.49,62.1 261.14,62.1 260.85,62.4 260.67,62.4 260.37,62.1 260.37,61.81 260.57,61.61 260.57,61.19 259.27,59.88 259.27,57.89 255.53,54.16 255.53,49.69 254.74,48.91 253.6,48.91 253.09,48.4 248.52,48.4 246.32,50.6 242.16,50.6 240.77,49.21 240.77,47.64 239.45,46.32 239.45,40.96 236.53,38.04 234.19,38.04 230.65,34.5 230.65,28.6 229.14,27.09 216.53,27.09 213.69,29.93 203.61,29.93 194.01,39.53 194.01,42.19 193.76,42.44 193.76,44.02 187.9,49.87 187.9,51.09 181.63,57.36 181.63,63.17 180.93,63.87 180.93,69.13 185.91,74.1 191.39,74.1 193.55,76.26 194.08,76.26 195.2,77.38 197.02,77.38 197.27,77.13
  IN2 w0.127: v2(321.38,124.98) 321.55,125.15 321.55,125.41 321.45,125.51 320.41,125.51 319.7,124.8 302.34,124.8 295.59,118.06 291.77,118.06 291.55,118.29 284.97,118.29 283.24,120.01 280.36,120.01 279.89,119.54 276.11,119.54 275.92,119.35 274.38,119.35 v2(274.19,119.16)
  BOTTOM w0.089: UH1.AW15 200.22,74.97 v2(200.16,74.92)
PCIE_SATA_PTX_WANRX_P4_C: length 2.3
  TOP w0.102: C416.1 321.54,127.16 321.54,127.66 321.76,127.88 321.76,128.12 321.61,128.27 U7.1
PCIE_VDDC_PWRGD: length 3
  TOP w0.102: v1(199.63,90.51) PR679.2
  TOP w0.254: PR679.2 198.48,91.57 198.37,91.68 PU602.4
PCIE_WAKE#: length 382.8
  TOP w0.102: v2(285.11,117.11) 285.1,117.11 284.44,116.45 283.15,116.45 283.12,116.41 U51.B38 ; v2(246.62,46.37) 247.14,45.84 U38.16 ; R759.2 280.27,118.61 v2(281.01,119.34) ; v2(278.37,57.31) v1(279.23,57.31) ; JEXP1.14 286.18,30.56 v2(286.24,30.62)
  IN1 w0.102: v2(278.37,57.31) 278.33,57.28 278.11,57.28 277.86,57.02 277.86,51.14 277.47,50.75 277.47,41.05 278.58,39.93 279.42,39.93 283.31,36.04 285.9,36.04 287.35,34.59 287.35,33.71 286.34,32.7 286.34,30.72 v2(286.24,30.62) 285.29,30.62 281.11,26.44 281.11,21.44 v2(280.88,21.21) ; v2(254.99,191.22) 255.44,191.68 273.62,191.68 274.04,191.26 290.24,191.26 290.55,190.96 v2(291.08,190.96) ; v2(251.21,26.71) 250.54,27.37 250.54,29.46 247.82,32.18 247.82,36.02 247.33,36.51 247.33,39.62 248.1,40.4 248.1,45.34 247.58,45.86 246.85,45.86 246.62,46.09 v2(246.62,46.37)
  IN2 w0.127: v2(283.45,169.43) 283.45,169.41 283.05,169.01 281.43,169.01 279.28,166.87 279.28,165.96 277.66,164.34 277.66,157.9 273.88,154.13 273.88,152.18 v2(274.06,152.01) ; JSATA2.27 238.23,42.21 239.98,43.95 244.2,43.95 v2(246.62,46.37)
  IN3 w0.127: v2(294.92,180.24) 294.05,179.37 292.63,179.37 290.71,177.46 290.71,176.56 288.93,174.78 288.93,171.09 287.7,169.86 283.88,169.86 v2(283.45,169.43) ; v2(285.11,117.11) 284.7,116.7 283.29,116.7 282.66,117.34 282.66,118.26 281.83,119.09 281.26,119.09 v2(281.01,119.34) 280.97,119.38 280.97,119.82 281.87,120.73 281.87,121.44 280.34,122.97 280.34,125.64 277.75,128.22 277.75,133.97 277.52,134.21 277.52,144.8 274.75,147.57 274.75,147.99 273.54,149.2 273.54,151.54 274.01,152.01 v2(274.06,152.01) ; v2(324.85,212.61) 324.21,211.98 322.44,211.98 321.29,213.12 317.74,213.12 313.04,208.42 312.13,208.42 311.94,208.61 306.5,208.61 305.04,207.15 297.29,207.15 295.77,205.63 295.77,193.34 293.39,190.96 v2(291.08,190.96)
  IN4 w0.102: v2(278.37,57.31) 278.07,57.61 278.07,59.49 278.48,59.9 278.48,61.44 278.14,61.79 277.62,61.79 277.38,62.03 277.38,63.92 275.72,65.58 275.72,92.85 277.94,95.06 277.94,99.13 277.33,99.74 277.33,104.73 278.24,105.64 278.24,106.37 279.86,107.99 282.1,107.99 282.76,108.65 283.75,108.65 284.88,109.78 284.88,110.73 285.57,111.42 285.83,111.42 286.48,112.07 286.48,114.24 285.82,114.9 285.82,116.12 285.11,116.83 v2(285.11,117.11)
  BOTTOM w0.102: v2(254.99,191.22) 254.59,190.83 253.14,190.83 251.05,188.74 JMINI2.1 ; v2(251.21,26.71) 251.4,26.71 253.18,24.93 256.19,24.93 257.77,23.36 258.94,23.36 260.42,21.87 279.29,21.87 279.95,21.21 v2(280.88,21.21) ; v2(324.85,212.61) 325.61,212.61 326.15,212.07 JMINI1.1 ; v2(291.08,190.96) 291.18,191.06 292.45,191.06 294.26,189.25 JMINI3.1 294.26,183 294.92,182.35 v2(294.92,180.24)
PCIECLKRQ6#: length 23.2
  TOP w0.102: v2(189.24,56.71) v1(189.9,56.71)
  IN2 w0.089: 198.04,64.84 200.99,67.79 v2(201.34,67.79)
  IN2 w0.127: 198.04,64.84 196.57,63.37 195.37,63.37 193.85,61.85 193.57,61.85 191.24,59.52 191.07,59.52 189.24,57.7 v2(189.24,56.71)
  BOTTOM w0.089: UH1.AE4 201.67,67.47 v2(201.34,67.79)
  BOTTOM w0.102: RH197.1 192.97,57.47 192.17,56.68 189.26,56.68 v2(189.24,56.71)
PCLK_80H: length 277.9
  TOP w0.102: v2(303.79,182.99) 303.79,171.83 304.31,171.31 306.08,171.31 307.23,172.47 v1(309.61,172.47) 314.6,172.47 316.43,170.64 317.61,170.64 317.74,170.76 321.17,170.76 v2(321.18,170.78) ; v2(327.77,136.61) 324.57,139.81 324.57,145.63 322.3,147.9 321.86,147.9 v2(321.84,147.88) ; v2(286.49,63.37) 284.68,63.37 282.39,65.66 273.2,65.66 272.72,65.18 272.72,64.63 272.18,64.1 272.01,64.1 271.04,63.12 268.48,63.12 268.19,63.41 266.49,63.41 265.76,64.15 264.58,64.15 263.14,62.71 262.61,62.71 262.37,62.47 257.91,62.47 256.64,61.2 253.35,61.2 252.52,60.38 249.6,60.38 248.32,59.09 248.32,59.08 247.47,58.23 247.47,56.8 246.97,56.3 246.97,54.89 246.46,54.38 245.57,54.38 243.38,52.18 241.48,52.18 240.11,50.81 229.26,50.81 227.8,52.27 227.8,52.31 227.72,52.39 227.72,52.4 227.25,52.86 227.25,53.52 227.25,57 227.63,57.38 227.63,63.65 226.68,64.6 226.68,65.3 226.27,65.71 226.27,66.79 224.07,68.99 222.03,68.99 221.74,68.7 221.15,68.7 221.14,68.71 RH159.1
  IN1 w0.102: v2(321.84,147.88) 322.22,148.26 322.22,157.2 321.64,157.78 321.64,168.28 321.76,168.41 321.76,169.3 321.18,169.89 v2(321.18,170.78)
  BOTTOM w0.102: v2(327.77,136.61) 327.77,136.31 327.16,135.7 327.16,121.2 325.89,119.93 319.77,119.93 316.68,116.84 316.68,103.94 314.22,101.47 313.83,101.47 310.5,98.15 288.62,98.15 287.51,97.04 284.51,97.04 280.28,92.81 280.28,68.1 285.01,63.37 v2(286.49,63.37) ; JMINI3.19 304.66,183.78 305.02,183.41 305.02,182.74 304.81,182.52 304.26,182.52 v2(303.79,182.99)
PD#A: length 2.9
  BOTTOM w0.102: R3688.1 325.7,191.15 v1(325.88,190.96) 326.22,190.63 U90.5
PD#B: length 3.4
  BOTTOM w0.102: R3720.1 335.52,215.66 336.15,216.29 337.55,216.29 337.81,216.56 U92.5
PD#C: length 4.4
  BOTTOM w0.102: U94.5 34.67,181.41 v1(34.51,181.25) 33.65,180.39 32.84,180.39 R3755.1
PD#D: length 4
  BOTTOM w0.102: R3775.1 337.82,193.89 338.15,193.57 v1(338.15,193.38) 338.15,192.32 338.82,191.64 U95.5
PECI_EC: length 355.5
  TOP w0.102: v2(275.06,109.52) 275.06,108.6 v1(275.34,108.32) 276.79,106.87 278.39,106.87 279.18,107.66 R952.2
  IN1 w0.089: 136,106.43 137.23,106.43 v2(137.73,105.92)
  IN1 w0.102: v2(106.54,150.53) 106.54,150.27 107.91,148.89 107.91,147.61 109.58,145.94 109.58,141.12 112.38,138.33 112.38,124.18 118.73,117.83 118.73,114.86 120.87,112.72 121.58,112.72 123.25,111.05 123.25,109.6 126.14,106.71 134.25,106.71 134.53,106.43 136,106.43
  IN2 w0.127: v2(275.43,170.51) 276.26,171.34 276.26,171.92 275.06,173.13 273.73,173.13 273.39,173.47 268.23,173.47 267.51,174.19 266.83,174.19 266.61,174.41 262.17,174.41 261.46,175.12 261.46,175.51 260.85,176.12 256.1,176.12 255.63,175.65 253.22,175.65 252.51,176.36 248.88,176.36 248.76,176.25 247.38,176.25 247.34,176.21 238.52,176.21 237.58,175.27 224.75,175.27 224.7,175.32 224.6,175.32 224.14,175.78 223.71,175.78 223.71,175.78 206.27,175.78 205.3,174.82 204.25,174.82 203.76,174.32 200.53,174.32 197.47,171.26 195.13,171.26 194.73,170.85 193.25,170.85 192.27,171.83 184.3,171.83 183.19,170.73 183.19,170.22 180.01,167.03 180.01,166.2 179.73,165.93 178.85,165.93 178.33,166.45 176.72,166.45 175.39,165.11 174.1,165.11 169.51,160.52 165.77,160.52 164.6,161.68 160.32,161.68 159.67,162.33 156.33,162.33 154.45,160.45 149.49,160.45 148.94,159.89 147.38,159.89 147.24,160.03 146.41,160.03 145.88,159.5 137.16,159.5 135.06,161.59 129,161.59 126.91,159.5 117.62,159.5 116.59,158.47 111.01,158.47 110.77,158.23 103.15,158.23 102.09,159.3 100.11,159.3 98.62,160.79 93.82,160.79 v2(92.95,159.92)
  IN4 w0.102: v2(275.06,109.52) 275.6,110.06 275.6,110.41 276.84,111.66 276.84,113.04 277.22,113.42 277.22,120.63 276.03,121.83 276.03,134.18 276.91,135.06 276.91,140.18 277.07,140.34 277.07,145.84 276.35,146.56 276.35,165.29 277.36,166.31 277.36,168.33 275.43,170.26 v2(275.43,170.51) ; v2(106.54,150.53) 106.27,150.53 106.17,150.63 104.28,150.63 104.1,150.81 104.1,151.01 96.46,158.65 94.01,158.65 92.95,159.71 v2(92.95,159.92)
  BOTTOM w0.102: v2(137.73,105.92) JCPU1.AR27
PECI_EC_R: length 8.1
  TOP w0.102: U51.A48 281.74,110.16 281.61,110.03 281.61,109.84 281.5,109.74 281.32,109.74 281.2,109.62 281.2,109.5 281.33,109.37 281.54,109.37 281.85,109.07 281.85,108.48 281.01,107.64 280.63,107.64 280.54,107.56 280.54,107.35 280.65,107.24 281.16,107.24 281.3,107.1 v1(281.3,106.96) 281.3,106.79 281.15,106.65 280.66,106.65 280.49,106.82 C290.1 R952.1
PEG_B_CLKRQ#: length 7.6
  TOP w0.102: RPH8.4 199.49,60.51 199.88,60.9 200.29,60.9 200.44,61.05 v2(200.84,61.05)
  BOTTOM w0.089: 201.28,62.12 201.28,62.3 202.33,63.35 202.33,63.58 202.46,63.72 202.46,63.74 203.05,64.33 203.05,64.59 203.23,64.77 203.63,64.77 UH1.U4
  BOTTOM w0.102: 201.28,62.12 201.28,61.95 200.84,61.52 v2(200.84,61.05)
PEG_COMP: length 6.1
  TOP w0.089: v2(168.73,101.92) 168.86,101.92 v1(169.43,102.49)
  TOP w0.305: v2(168.73,101.92) 168.17,101.35 168.17,100.38 166.82,99.03 RC1.2
  BOTTOM w0.305: v2(168.73,101.92) 168.26,101.45 JCPU1.E23
PEG_CRX_GTX_C_N0: length 20.8
  TOP w0.102: 223.29,116.22 223.29,116.24 223.27,116.26 223.27,116.6 223.34,116.66 223.34,118.62 223.71,119 223.71,122.01 223.46,122.26 223.18,122.26 v2(223.05,122.4)
  TOP w0.127: CV2.1 218.21,109.85 218.21,110.35 217.89,110.67 217.39,110.67 217.27,110.79 217.27,111.44 217.39,111.57 v4(217.74,111.57) 218.21,111.57 218.59,111.95 218.59,113.39 219.11,113.91 219.78,113.91 221.45,115.57 221.9,115.57 222.03,115.44 222.03,115.05 222.31,114.77 223,114.77 223.29,115.05 223.29,116.22
  BOTTOM w0.127: v2(223.05,122.4) 222.65,122 UV1.Y32
PEG_CRX_GTX_C_N1: length 20.7
  TOP w0.127: v2(221.77,121.54) 222.3,121.54 222.54,121.31 222.54,119.58 222.12,119.16 222.12,117.59 221.09,116.56 220.56,116.56 220.18,116.18 220.18,116.08 216.37,112.27 v4(216.37,110.49) 216.37,107.49 216.96,106.9 217.38,106.9 217.66,106.62 217.66,106.31 CV3.1
  BOTTOM w0.102: v2(221.77,121.54) 221.31,122 UV1.W32
PEG_CRX_GTX_C_N2: length 20.2
  TOP w0.102: v2(220.61,121.54) 220.66,121.49 221.08,121.49 221.32,121.25 221.32,118.35 219.18,116.22
  TOP w0.127: CV6.1 214.35,106.35 214.35,106.58 215.15,107.38 215.15,108.18 214.67,108.66 214.67,111.7 219.18,116.22
  BOTTOM w0.102: UV1.U32 220.15,122 v2(220.61,121.54)
PEG_CRX_GTX_C_N3: length 20
  TOP w0.102: 217.62,116.72 217.94,117.04 218.23,117.04 220.42,119.23 220.42,120.14 219.88,120.68 219.88,123.48 220.24,123.84 220.4,123.84 220.53,123.97 v2(220.53,123.98)
  TOP w0.127: 217.62,116.72 v4(215.72,114.82) 213.56,112.66 213.56,111.76 213.32,111.52 212.78,111.52 212.49,111.24 212.49,110.66 212.78,110.38 212.94,110.38 213.01,110.3 213.01,109.8 CV8.1
  BOTTOM w0.102: v2(220.53,123.98) 220.11,124.4 UV1.U29
PEG_CRX_GTX_C_N4: length 21.6
  TOP w0.102: v2(219.43,121.99) 219.03,121.6 219.03,121.55 219.03,120.78 219.64,120.17 219.64,119.35 218.67,118.38 217.34,118.38 216.43,117.47 216.43,116.75 216.42,116.74 216.42,116.71
  TOP w0.127: CV10.1 210.7,106.32 210.7,106.63 211.56,107.49 211.56,111.79 v4(213.23,113.45) 216.42,116.64 216.42,116.71
  BOTTOM w0.102: v2(219.43,121.99) 219.42,122 UV1.T32
PEG_CRX_GTX_C_N5: length 21.8
  TOP w0.102: v2(219.4,123.95) 219.31,123.86 218.79,123.86 218.58,123.65 218.58,120.32 219.01,119.89 219.01,119.55 218.96,119.5
  TOP w0.127: 218.96,119.5 218.62,119.16 215.73,119.16 215.19,118.62 215.19,116.56 209.66,111.04 209.66,109.75 CV12.1
  BOTTOM w0.102: UV1.T29 218.96,124.4 v2(219.4,123.95)
PEG_CRX_GTX_C_N6: length 22.7
  TOP w0.102: 217.7,120.62 217.7,121.09 218.16,121.55 218.16,121.76 v2(218.16,121.77)
  TOP w0.127: CV15.1 207.37,106.32 207.37,106.76 207.63,107.01 208.53,107.01 208.75,107.23 208.75,107.7 208.38,108.07 208.38,110.86 213.55,116.03 213.55,117.96 215.36,119.77 216.85,119.77 217.7,120.62
  BOTTOM w0.102: UV1.P32 217.93,122 218.16,121.77 v2(218.16,121.77)
PEG_CRX_GTX_C_N7: length 22.3
  TOP w0.102: 212.02,117.82 212.02,117.83 212.03,117.84 212.03,119.13 213.28,120.37 216.27,120.37 217.38,121.49 217.38,123.6 217.63,123.85 v2(218.17,123.85)
  TOP w0.127: 212.02,117.82 v4(212.02,116.24) 212.02,115.65 206.42,110.04 206.42,109.82 CV17.1
  BOTTOM w0.102: v2(218.17,123.85) 217.65,124.37 UV1.P29
PEG_CRX_GTX_C_P0: length 20.7
  TOP w0.102: v2(223.04,121.57) 223.04,121.91 223.15,122.02 223.36,122.02 223.47,121.91 223.47,119.1 223.1,118.72 223.1,116.76 223.03,116.7 223.03,116.26 223.02,116.24 223.02,116.22
  TOP w0.127: 223.02,116.22 223.02,115.16 222.89,115.04 222.42,115.04 222.3,115.16 222.3,115.55 222.01,115.84 221.34,115.84 219.67,114.17 219,114.17 218.32,113.5 218.32,112.06 218.1,111.84 217.28,111.84 217,111.55 217,110.68 217.28,110.4 217.78,110.4 217.94,110.24 217.94,109.78 CV1.1
  BOTTOM w0.127: UV1.Y33 222.66,121.2 v2(223.04,121.57)
PEG_CRX_GTX_C_P1: length 20.7
  TOP w0.127: v2(221.8,120.81) 221.8,120.98 222.1,121.28 222.19,121.28 222.27,121.2 222.27,119.69 221.85,119.27 221.85,117.7 220.98,116.83 220.45,116.83 219.91,116.29 219.91,116.19 216.1,112.38 216.1,107.38 216.85,106.63 217.27,106.63 217.39,106.51 217.39,106.41 CV4.1
  BOTTOM w0.102: v2(221.8,120.81) 221.8,120.99 221.6,121.2 UV1.W33
PEG_CRX_GTX_C_P2: length 20.2
  TOP w0.102: 218.99,116.41 219,116.42 219.02,116.42 219.08,116.47 219.1,116.47 221.08,118.45 221.08,121.15 220.98,121.25 220.91,121.25 220.8,121.13 220.67,121.13 220.6,121.06 v2(220.6,120.93)
  TOP w0.127: 218.99,116.41 214.4,111.81 v4(214.4,110.49) 214.4,108.55 214.88,108.07 214.88,107.49 214.08,106.69 214.08,106.43 CV5.1
  BOTTOM w0.102: UV1.U33 220.05,121.21 220.18,121.34 220.26,121.34 220.6,121 v2(220.6,120.93)
