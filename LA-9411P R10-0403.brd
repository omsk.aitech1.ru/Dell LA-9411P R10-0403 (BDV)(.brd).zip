# Allegro board LA-9411P R10-0403.brd (continued)
## Footprints (pads in the part's own frame, mm; a bottom-side part is the same pattern mirrored in y, then rotated) (continued)
MMBT3904WT1G_SC70-3
  oval 0.711x0.889 smd: 1(0,0) 2(0.65,1.9) 3(-0.65,1.9)
MMBT3906WT1G_SC70-3
  rect 0.813x0.914 smd: 1(0.65,-1.9) 2(1.3,0) 3(0,0)
MMST3904-7-F_SOT323-3
  oval 0.711x0.889 smd: 1(0,0) 2(0.65,1.9) 3(-0.65,1.9)
MURAT_BLM18BB221SN1D_2P
  rect 0.66x1.041 smd: 1(0,0) 2(1.2,0)
MURAT_BLM18BD102SN1D_L0603_2P
  rect 0.66x1.041 smd: 1(0,0) 2(1.2,0)
MURAT_BLM18BD601SN1D_2P
  rect 0.61x0.711 smd: 1(0,0) 2(1.3,0)
MURAT_BLM18PG181SN1D_L0603_2P
  rect 0.66x1.041 smd: 1(0,0) 2(1.2,0)
MURAT_BLM21PG600SN1D_L0805_2P
  rect 0.991x1.753 smd: 1(0,0) 2(1.5,0)
MURAT_DLW21SN121SQ2L_4P
  rect 0.889x0.406 smd: 1(0,0) 2(1.7,0) 3(1.7,0.8) 4(0,0.8)
MURAT_DLW21SN900HQ2L_0805_4P
  rect 0.889x0.356 smd: 1(0,0) 2(1.7,0) 3(1.7,0.85) 4(0,0.85)
MURAT_DLW21SN900SQ2L_0805_4P
  rect 0.889x0.356 smd: 1(0,0) 2(1.7,0) 3(1.7,0.85) 4(0,0.85)
NTR4502PT1G_SOT23-3
  oval 1.016x1.524 smd: 1(0,0) 2(0.965,2.083) 3(-0.965,2.083)
OCTEK_BTJ-06LDFB_6P
  round 1.194 hole 0.787: 1(0,0) 2(1.5,0) 3(3,0) 4(4.5,0) 5(6,0) 6(7.5,0)
  oval 1.295x2.896 hole 0.711x2.311: 7(-1.95,0) 8(9.45,0)
OCTEK_BTJ-09WKFB_9P
  round 1.397 hole 0.991: 1(0,0) 2(2,0) 3(4,0) 4(6,0) 5(8,0) 6(10,0) 7(12,0) 8(14,0) 9(16,0)
  oval 1.753x3.607 hole 0.991x2.845: 10(19.125,0) 11(-3.125,0)
OZ777FJ2LN_QFN48_6X6
  oval 0.203x0.889 smd: 1(0,0) 2(0.4,0) 3(0.8,0) 4(1.2,0) 5(1.6,0) 6(2,0) 7(2.4,0) 8(2.8,0) 9(3.2,0) 10(3.6,0) 11(4,0) 12(4.4,0) 25(4.4,6.1) 26(4,6.1) 27(3.6,6.1) 28(3.2,6.1) 29(2.8,6.1) 30(2.4,6.1) 31(2,6.1) 32(1.6,6.1) 33(1.2,6.1) 34(0.8,6.1) 35(0.4,6.1) 36(0,6.1)
  oval 0.889x0.203 smd: 13(5.25,0.85) 14(5.25,1.25) 15(5.25,1.65) 16(5.25,2.05) 17(5.25,2.45) 18(5.25,2.85) 19(5.25,3.25) 20(5.25,3.65) 21(5.25,4.05) 22(5.25,4.45) 23(5.25,4.85) 24(5.25,5.25) 37(-0.85,5.25) 38(-0.85,4.85) 39(-0.85,4.45) 40(-0.85,4.05) 41(-0.85,3.65) 42(-0.85,3.25) 43(-0.85,2.85) 44(-0.85,2.45) 45(-0.85,2.05) 46(-0.85,1.65) 47(-0.85,1.25) 48(-0.85,0.85)
  rect 4.343x4.343 smd: 49(2.2,3.05)
PDS5100H-13_POWERDI5-3
  rect 4.851x3.353 smd: 1(0,0)
  rect 1.397x1.397 smd: 2(3.982,-0.92) 3(3.982,0.92)
PDTA114EU_SC70-3
  oval 0.61x0.559 smd: 1(0,0) 2(-0.65,-1.85) 3(0.65,-1.85)
PI3C3125LEX_TSSOP14
  oval 0.381x1.626 smd: 1(0,0) 2(0.65,0) 3(1.3,0) 4(1.95,0) 5(2.6,0) 6(3.25,0) 7(3.9,0) 8(3.9,5.8) 9(3.25,5.8) 10(2.6,5.8) 11(1.95,5.8) 12(1.3,5.8) 13(0.65,5.8) 14(0,5.8)
PI3L720ZHEX_TQFN42_9X3P5
  oval 0.254x1.041 smd: 1(0,0) 2(0.5,0) 3(1,0) 4(1.5,0) 5(2,0) 6(2.5,0) 7(3,0) 8(3.5,0) 9(4,0) 10(4.5,0) 11(5,0) 12(5.5,0) 13(6,0) 14(6.5,0) 15(7,0) 16(7.5,0) 17(8,0) 22(8,3.45) 23(7.5,3.45) 24(7,3.45) 25(6.5,3.45) 26(6,3.45) 27(5.5,3.45) 28(5,3.45) 29(4.5,3.45) 30(4,3.45) 31(3.5,3.45) 32(3,3.45) 33(2.5,3.45) 34(2,3.45) 35(1.5,3.45) 36(1,3.45) 37(0.5,3.45) 38(0,3.45)
  oval 1.041x0.254 smd: 18(8.475,0.975) 19(8.475,1.475) 20(8.475,1.975) 21(8.475,2.475) 39(-0.475,2.475) 40(-0.475,1.975) 41(-0.475,1.475) 42(-0.475,0.975)
  rect 7.544x2.057 smd: 43(4,1.725)
PI3V713-AZLEX_TQFN32_6X3
  oval 0.203x0.813 smd: 1(0,0) 2(0.4,0) 3(0.8,0) 4(1.2,0) 5(1.6,0) 6(2,0) 7(2.4,0) 8(2.8,0) 9(3.2,0) 10(3.6,0) 11(4,0) 17(4,3.177) 18(3.6,3.177) 19(3.2,3.177) 20(2.8,3.177) 21(2.4,3.177) 22(2,3.177) 23(1.6,3.177) 24(1.2,3.177) 25(0.8,3.177) 26(0.4,3.177) 27(0,3.177)
  oval 0.813x0.203 smd: 12(5.088,0.789) 13(5.088,1.189) 14(5.088,1.589) 15(5.088,1.989) 16(5.088,2.389) 28(-1.089,2.389) 29(-1.089,1.989) 30(-1.089,1.589) 31(-1.089,1.189) 32(-1.089,0.789)
  rect 5.004x2.007 smd: 33(2,1.589)
PMST3904_SOT323-3
  oval 0.508x0.559 smd: 1(0,0) 2(-0.65,-1.85) 3(0.65,-1.85)
PS8401ATQFN40GTR-A3_TQFN40_5X5
  oval 0.203x1.016 smd: 1(0,0) 2(0.4,0) 3(0.8,0) 4(1.2,0) 5(1.6,0) 6(2,0) 7(2.4,0) 8(2.8,0) 9(3.2,0) 10(3.6,0) 21(3.6,4.975) 22(3.2,4.975) 23(2.8,4.975) 24(2.4,4.975) 25(2,4.975) 26(1.6,4.975) 27(1.2,4.975) 28(0.8,4.975) 29(0.4,4.975) 30(0,4.975)
  oval 1.016x0.203 smd: 11(4.288,0.688) 12(4.288,1.088) 13(4.288,1.488) 14(4.288,1.888) 15(4.288,2.288) 16(4.288,2.688) 17(4.288,3.088) 18(4.288,3.488) 19(4.288,3.888) 20(4.288,4.288) 31(-0.688,4.288) 32(-0.688,3.888) 33(-0.688,3.488) 34(-0.688,3.088) 35(-0.688,2.688) 36(-0.688,2.288) 37(-0.688,1.888) 38(-0.688,1.488) 39(-0.688,1.088) 40(-0.688,0.688)
  rect 3.607x3.607 smd: 41(1.8,2.488)
PS8710BTQFN24GTR-A0_TQFN24_4X4
  oval 0.254x1.041 smd: 1(0,0) 2(0.5,0) 3(1,0) 4(1.5,0) 5(2,0) 6(2.5,0) 13(2.5,3.95) 14(2,3.95) 15(1.5,3.95) 16(1,3.95) 17(0.5,3.95) 18(0,3.95)
  oval 1.041x0.254 smd: 7(3.225,0.725) 8(3.225,1.225) 9(3.225,1.725) 10(3.225,2.225) 11(3.225,2.725) 12(3.225,3.225) 19(-0.725,3.225) 20(-0.725,2.725) 21(-0.725,2.225) 22(-0.725,1.725) 23(-0.725,1.225) 24(-0.725,0.725)
  rect 2.108x2.108 smd: 25(1.25,1.975)
PS_HPF05052-061000R_6P
  oval 0.305x1.499 smd: 1(0,0) 2(0.5,0) 3(1,0) 4(1.5,0) 5(2,0) 6(2.5,0)
  rect 2.489x1.905 smd: 7(-2.15,-3.4) 8(4.65,-3.4)
PS_HPF05052-081000R_8P
  oval 0.305x1.499 smd: 1(0,0) 2(0.5,0) 3(1,0) 4(1.5,0) 5(2,0) 6(2.5,0) 7(3,0) 8(3.5,0)
  rect 2.489x1.905 smd: 9(5.65,-3.4) 10(-2.15,-3.4)
PS_HPF10052-04M000R_4P
  oval 0.356x1.295 smd: 1(0,0) 2(1,0) 3(2,0) 4(3,0)
  rect 2.489x1.905 smd: 5(-2.65,-3.3) 6(5.65,-3.3)
PS_HPW10003-08MR2_8P
  oval 0.61x1.499 smd: 1(0,0) 2(1,0) 3(2,0) 4(3,0) 5(4,0) 6(5,0) 7(6,0) 8(7,0)
  rect 1.194x1.803 smd: 9(-1.6,2.5) 10(8.6,2.5)
R0402_0OHM
  rect 0.508x0.559 smd: 1(0,0) 2(0.914,0)
R0603_0OHM
  rect 0.635x0.889 smd: 1(0,0) 2(1.397,0)
R0805_0OHM
  rect 0.813x1.397 smd: 1(0,0) 2(1.702,0)
R_0402
  rect 0.508x0.559 smd: 1(0,0) 2(0.914,0)
R_0603
  rect 0.635x0.889 smd: 1(0,0) 2(1.397,0)
R_0805
  rect 0.813x1.397 smd: 1(0,0) 2(1.702,0)
R_1206
  rect 1.016x1.651 smd: 1(0,0) 2(2.667,0)
R_1206_4P-D
  custom 0.445x0.445 smd: 1(0,0) 4(5.004,0)
  custom 0.114x0.114 smd: 2(1.194,0) 3(3.81,0)
RB717F_SOT323-3
  oval 0.711x0.889 smd: 1(0,0) 2(0.65,1.9) 3(-0.65,1.9)
RB751V40_SC76-2
  rect 0.61x0.61 smd: 1(0,0) 2(2.2,0)
RB751VM-40TE-17_SOD323-2
  rect 0.787x0.889 smd: 1(0,0) 2(2.1,0)
RHU002N06_SOT323-3
  oval 0.813x0.914 smd: 1(0,0) 2(0.65,1.6) 3(-0.65,1.6)
RP_0804_8P4R
  oval 0.66x0.254 smd: 1(0,0) 2(0,-0.5) 3(0,-1) 4(0,-1.5) 5(1.15,-1.5) 6(1.15,-1) 7(1.15,-0.5) 8(1.15,0)
RT8207MZQW_WQFN20_3X3
  oval 0.203x0.889 smd: 1(0,0) 2(0.4,0) 3(0.8,0) 4(1.2,0) 5(1.6,0) 11(1.6,3.1) 12(1.2,3.1) 13(0.8,3.1) 14(0.4,3.1) 15(0,3.1)
  oval 0.889x0.203 smd: 6(2.35,0.75) 7(2.35,1.15) 8(2.35,1.55) 9(2.35,1.95) 10(2.35,2.35) 16(-0.75,2.35) 17(-0.75,1.95) 18(-0.75,1.55) 19(-0.75,1.15) 20(-0.75,0.75)
  rect 1.702x1.702 smd: 21(0.8,1.55)
RT9818A-44GU3_SC70-3
  oval 0.61x0.787 smd: 1(0,0) 2(-0.65,-1.9) 3(0.65,-1.9)
RTD2136S-CG_QFN48_6X6
  oval 0.203x1.041 smd: 1(0,0) 2(0.4,0) 3(0.8,0) 4(1.2,0) 5(1.6,0) 6(2,0) 7(2.4,0) 8(2.8,0) 9(3.2,0) 10(3.6,0) 11(4,0) 12(4.4,0) 25(4.4,5.95) 26(4,5.95) 27(3.6,5.95) 28(3.2,5.95) 29(2.8,5.95) 30(2.4,5.95) 31(2,5.95) 32(1.6,5.95) 33(1.2,5.95) 34(0.8,5.95) 35(0.4,5.95) 36(0,5.95)
  oval 1.041x0.203 smd: 13(5.175,0.775) 14(5.175,1.175) 15(5.175,1.575) 16(5.175,1.975) 17(5.175,2.375) 18(5.175,2.775) 19(5.175,3.175) 20(5.175,3.575) 21(5.175,3.975) 22(5.175,4.375) 23(5.175,4.775) 24(5.175,5.175) 37(-0.775,5.175) 38(-0.775,4.775) 39(-0.775,4.375) 40(-0.775,3.975) 41(-0.775,3.575) 42(-0.775,3.175) 43(-0.775,2.775) 44(-0.775,2.375) 45(-0.775,1.975) 46(-0.775,1.575) 47(-0.775,1.175) 48(-0.775,0.775)
  rect 3.962x3.962 smd: 49(2.2,2.975)
SAMTE_BSH-030-01-L-D-A_60P
  round 1.016 hole 1.016 unplated: (-2.81,5.53) (17.316,5.53)
  oval 0.279x2.261 smd: 1(0,0) 2(0,5.728) 3(0.5,0) 4(0.5,5.728) 5(1,0) 6(1,5.728) 7(1.5,0) 8(1.5,5.728) 9(2,0) 10(2,5.728) 11(2.5,0) 12(2.5,5.728) 13(3,0) 14(3,5.728) 15(3.5,0) 16(3.5,5.728) 17(4,0) 18(4,5.728) 19(4.5,0) 20(4.5,5.728) 21(5,0) 22(5,5.728) 23(5.5,0) 24(5.5,5.728) 25(6,0) 26(6,5.728) 27(6.5,0) 28(6.5,5.728) 29(7,0) 30(7,5.728) 31(7.5,0) 32(7.5,5.728) 33(8,0) 34(8,5.728) 35(8.5,0) 36(8.5,5.728) 37(9,0) 38(9,5.728) 39(9.5,0) 40(9.5,5.728) 41(10,0) 42(10,5.728) 43(10.5,0) 44(10.5,5.728) 45(11,0) 46(11,5.728) 47(11.5,0) 48(11.5,5.728) 49(12,0) 50(12,5.728) 51(12.5,0) 52(12.5,5.728) 53(13,0) 54(13,5.728) 55(13.5,0) 56(13.5,5.728) 57(14,0) 58(14,5.728) 59(14.5,0) 60(14.5,5.728)
SANTA_196003-1_22P
  round 1.6 hole 1.6 unplated: (-32.47,-3) (0.72,-3)
  oval 0.889x2.388 smd: 1(0,0) 2(-1.27,0) 3(-2.54,0) 4(-3.81,0) 5(-5.08,0) 6(-6.35,0) 7(-7.62,0) 8(-13.97,0) 9(-15.24,0) 10(-16.51,0) 11(-17.78,-0.5) 12(-19.05,0) 13(-20.32,0) 14(-21.59,0) 15(-22.86,0) 16(-24.13,0) 17(-25.4,0) 18(-26.67,0) 19(-27.94,-0.5) 20(-29.21,0) 21(-30.48,0) 22(-31.75,0)
  oval 1.803x3.277 hole 0.991x2.489: 23(-34.585,-2.24) 24(2.835,-2.24)
SANTA_373130-1_9P
  round 0.991 hole 0.711: 1(0,0) 2(-2.5,0) 3(-4.5,0) 4(-7,0) 5(-7.5,-1.5) 6(-5.5,-1.5) 7(-3.5,-1.5) 8(-1.5,-1.5) 9(0.5,-1.5)
  oval 1.397x3.2 hole 0.787x2.591: 10(4.35,-2.38) 13(-11.35,-2.38)
  oval 1.397x2.388 hole 0.787x1.803: 11(4.35,-9.48) 12(-11.35,-9.48)
SDMK0340L-7-F_SOD323-2
  rect 1.346x0.66 smd: 1(0,0) 2(2.4,0)
SHORTPADS
  custom 0.19x0.19 smd: 1(-0.483,0) 2(0.483,0)
SI3993CDV-T1-GE3_TSOP6
  oval 0.508x1.422 smd: 1(0,0) 2(0.95,0) 3(1.9,0) 4(1.9,2.44) 5(0.95,2.44) 6(0,2.44)
SI4164DY-T1-GE3_SO8
  oval 0.635x1.727 smd: 1(0,0) 2(1.27,0) 3(2.54,0) 4(3.81,0) 5(3.81,5.285) 6(2.54,5.285) 7(1.27,5.285) 8(0,5.285)
SI4835BDY-T1-E3_SO8
  oval 0.635x1.727 smd: 1(0,0) 2(1.27,0) 3(2.54,0) 4(3.81,0) 5(3.81,5.285) 6(2.54,5.285) 7(1.27,5.285) 8(0,5.285)
SI4835DDY-T1-GE3_SO8
  oval 0.635x1.727 smd: 1(0,0) 2(1.27,0) 3(2.54,0) 4(3.81,0) 5(3.81,5.285) 6(2.54,5.285) 7(1.27,5.285) 8(0,5.285)
SINGA_2SJ3080-001111F_6P-T
  oval 0.991x1.803 hole 0.61x1.397: 1(0,0) 2(-9.55,5.5) 3(0,7.8) 4(-9.55,8.4) 5(-9.55,0) 6(-9.55,2.75) 7(0,4.1)
SIR472DP-T1-GE3_POWERPAK8-5
  oval 0.61x1.27 smd: 1(0,0) 2(1.27,0) 3(2.54,0) 4(3.81,0)
  custom 1.105x1.105 smd: 5(1.905,3.36)
SIRA06DP-T1-GE_POWERPAKSO-8-5
  oval 0.61x1.27 smd: 1(0,0) 2(1.27,0) 3(2.54,0) 4(3.81,0)
  custom 1.105x1.105 smd: 5(1.905,3.715)
SIRA14DP-T1GE3_POWERPAK-SO8-5
  oval 0.61x1.27 smd: 1(0,0) 2(1.27,0) 3(2.54,0) 4(3.81,0)
  custom 1.105x1.105 smd: 5(1.905,3.715)
SIS412DN-T1-GE3_POWERPAK8-5
  oval 0.406x0.991 smd: 1(0,0) 2(0.66,0) 3(1.32,0) 4(1.98,0)
  custom 0.559x0.559 smd: 5(0.99,2.247)
SIS472DN-T1_POWERPAK1212-8-5
  oval 0.406x0.991 smd: 1(0,0) 2(0.66,0) 3(1.32,0) 4(1.98,0)
  custom 0.559x0.559 smd: 5(0.99,2.248)
SLG55584AVTR_TDFN8_2X2
  oval 0.254x0.914 smd: 1(0,0) 2(0.5,0) 3(1,0) 4(1.5,0) 5(1.5,2.075) 6(1,2.075) 7(0.5,2.075) 8(0,2.075)
  rect 1.6x0.889 smd: 9(0.75,1.038)
SN74LVC1G07DCKR_SC70-5
  oval 0.381x0.864 smd: 1(0,0) 2(0.65,0) 3(1.3,0) 4(1.3,1.74) 5(0,1.74)
SSM3K7002FU_SC70-3
  oval 0.508x0.991 smd: 1(0,0) 2(0.65,1.9) 3(-0.65,1.9)
SW_SKRBAAE010_4P
  rect 0.889x1.219 smd: 1(0,0) 2(3.9,0) 3(0,4.075) 4(3.9,4.075)
SY8033BDBC_DFN10_3X3
  oval 0.305x0.559 smd: 1(0,0) 2(0.5,0) 3(1,0) 4(1.5,0) 5(2,0) 6(2,2.7) 7(1.5,2.7) 8(1,2.7) 9(0.5,2.7) 10(0,2.7)
  rect 2.591x1.753 smd: 11(1,1.35)
SY8036DBC_DFN10_3X3
  oval 0.254x0.889 smd: 1(0,0) 2(0.5,0) 3(1,0) 4(1.5,0) 5(2,0) 6(2,3.1) 7(1.5,3.1) 8(1,3.1) 9(0.5,3.1) 10(0,3.1)
  rect 2.388x1.575 smd: 11(1,1.55)
T-SOL_156-1000302606_18P-T
  round 1.194 hole 1.194 unplated: (-17,-26.6) (3,-26.6)
  oval 0.711x1.397 smd: 1(0,0) 2(-1.5,0) 3(-4.5,0) 4(-9,0) 5(-10.5,0) 6(-13.5,0) 7(-15,0) 8(-16.5,0) 9(1.5,0) 17(-12,0) 18(-18,0)
  oval 1.803x1.702 smd: 10(-12.95,-26.755) 13(-2.45,-26.755)
  oval 0.787x1.397 smd: 11(-2.575,-20.24) 12(-4.075,-20.24) 14(-8.55,-20.24) 15(-10.075,-20.24) 16(-11.575,-20.24)
  rect 1.092x1.245 smd: 19(4.8,0.075) 20(-5.65,0.075) 21(-19.25,0.075)
  rect 1.194x1.803 smd: 22(6.85,-14.9) 23(6.85,-27.85) 24(-20.85,-21.4) 25(-20.85,-27.85)
T-SOL_159-1000302602_10P-T
  round 0.889 hole 0.889 unplated: (2.885,-1.425) (3.075,-14.375)
  oval 0.508x1.245 smd: 1(0,0) 2(-1.4,0) 3(-2.8,0) 4(-4.2,0) 5(-0.7,0) 6(-2.1,0) 7(-3.5,0) 8(-4.9,0) 9(-5.6,0) 10(0.7,0)
  rect 0.889x1.397 smd: 11(3.355,0.075) 18(-6.755,0.075)
  rect 0.381x1.6 smd: 12(5.11,-2.475)
  rect 0.381x1.499 smd: 13(5.11,-9.325) 16(-9.22,-9.325)
  rect 1.092x1.092 smd: 14(4.745,-15.145) 15(-8.855,-15.145)
  rect 0.381x1.245 smd: 17(-9.22,-3.085)
TAIMA_IH-115-F_24P
  oval 0.762x2.057 smd: 1(0,0) 2(1.27,0) 3(2.54,0) 4(3.81,0) 5(5.08,0) 6(6.35,0) 7(7.62,0) 8(8.89,0) 9(10.16,0) 10(11.43,0) 11(12.7,0) 12(13.97,0) 13(13.97,9.365) 14(12.7,9.365) 15(11.43,9.365) 16(10.16,9.365) 17(8.89,9.365) 18(7.62,9.365) 19(6.35,9.365) 20(5.08,9.365) 21(3.81,9.365) 22(2.54,9.365) 23(1.27,9.365) 24(0,9.365)
TAIYO_CBC2012T4R7M_2P
  rect 0.711x1.448 smd: 1(0,0) 2(1.5,0)
TAIYO_FBMJ4516HS720NT_2P
  rect 1.549x1.854 smd: 1(0,0) 2(3.95,0)
TAIYO_NRS4018T1R0NDGJ_2P
  rect 1.194x3.708 smd: 1(0,0) 2(2.8,0)
TC7SET04FU_SSOP5
  oval 0.381x1.321 smd: 1(0,0) 2(0.65,0) 3(1.3,0) 4(1.3,1.8) 5(0,1.8)
TC7SH08FU_SSOP5
  oval 0.406x0.787 smd: 1(0,0) 2(0.65,0) 3(1.3,0) 4(1.3,1.9) 5(0,1.9)
TE_2041528-1_13P-T
  round 1.295 hole 0.889: 1(0,0) 2(1.02,-1.1) 3(2.04,0) 4(3.06,-1.1) 5(4.08,0) 6(5.1,-1.1) 7(6.12,0) 8(7.14,-1.1) 9(-3.38,1.4) 10(-2.235,-0.1) 11(8.25,1.4) 12(9.395,-0.1) 13(10.54,1.4)
  oval 1.753x3.15 hole 0.991x2.388: 14(-5.95,-11.6) 15(13.09,-11.6)
TOKO_FDSD0420-H-1R0M-P3T_2P
  rect 1.702x2.388 smd: 1(0,0) 2(3.5,0)
TOKO_FDSD0630-H-1R0M-P3_2P
  rect 2.159x3.505 smd: 1(0,0) 2(5.85,0)
TOKO_FDSD0630-H-2R2M-P3_2P
  rect 2.159x3.505 smd: 1(0,0) 2(5.85,0)
TOKO_FDUE0640J-H_4P
  custom 0.686x0.686 smd: 1(0,0) 4(9.271,0)
  rect 2.362x0.508 smd: 2(1.448,0) 3(7.823,0)
TOKO_FDUE1040D-H-1R0M-P3_2P
  rect 3.81x3.988 smd: 1(0,0) 2(9.2,0)
TOKO_FDVE1040-H-2R2M-P3_2P
  rect 3.81x3.988 smd: 1(0,0) 2(9.2,0)
TP0610K-T1-E3_SOT23-3
  oval 1.016x1.524 smd: 1(0,0) 2(0.965,2.083) 3(-0.965,2.083)
TPC12
  round 0.305 smd: 1(0,0)
TPS2231MRGPR-2_QFN20_4X4
  oval 0.279x0.838 smd: 1(0,0) 2(0.5,0) 3(1,0) 4(1.5,0) 5(2,0) 11(2,3.95) 12(1.5,3.95) 13(1,3.95) 14(0.5,3.95) 15(0,3.95)
  oval 0.838x0.279 smd: 6(2.975,0.975) 7(2.975,1.475) 8(2.975,1.975) 9(2.975,2.475) 10(2.975,2.975) 16(-0.975,2.975) 17(-0.975,2.475) 18(-0.975,1.975) 19(-0.975,1.475) 20(-0.975,0.975)
  rect 2.21x2.21 smd: 21(1,1.975)
TPS22966DPUR_SON14_2X3
  oval 0.203x0.762 smd: 1(0,0) 2(0.4,0) 3(0.8,0) 4(1.2,0) 5(1.6,0) 6(2,0) 7(2.4,0) 8(2.4,2.05) 9(2,2.05) 10(1.6,2.05) 11(1.2,2.05) 12(0.8,2.05) 13(0.4,2.05) 14(0,2.05)
  rect 2.489x0.889 smd: 15(1.2,1.025)
TPS51212DSCR_SON10_3X3
  oval 0.279x0.838 smd: 1(0,0) 2(0.5,0) 3(1,0) 4(1.5,0) 5(2,0) 6(2,2.95) 7(1.5,2.95) 8(1,2.95) 9(0.5,2.95) 10(0,2.95)
  custom 0.412x0.412 smd: 11(1,1.475)
TPS51225CRUKR_QFN20_3X3
  oval 0.203x0.889 smd: 1(0,0) 2(0.4,0) 3(0.8,0) 4(1.2,0) 5(1.6,0) 11(1.6,3.1) 12(1.2,3.1) 13(0.8,3.1) 14(0.4,3.1) 15(0,3.1)
  oval 0.889x0.203 smd: 6(2.35,0.75) 7(2.35,1.15) 8(2.35,1.55) 9(2.35,1.95) 10(2.35,2.35) 16(-0.75,2.35) 17(-0.75,1.95) 18(-0.75,1.55) 19(-0.75,1.15) 20(-0.75,0.75)
  rect 1.702x1.702 smd: 21(0.8,1.55)
TVNST52302AB0_SOT523-3
  oval 0.508x0.559 smd: 1(0,0) 2(-0.5,-1.4) 3(0.5,-1.4)
TYCO_1-2041070-0_10P
  oval 0.305x1.295 smd: 1(0,0) 2(-0.5,0) 3(-1,0) 4(-1.5,0) 5(-2,0) 6(-2.5,0) 7(-3,0) 8(-3.5,0) 9(-4,0) 10(-4.5,0)
  rect 2.489x1.905 smd: 11(-6.65,3.3) 12(2.15,3.3)
TYCO_1-2041070-6_16P
  oval 0.305x1.295 smd: 1(0,0) 2(-0.5,0) 3(-1,0) 4(-1.5,0) 5(-2,0) 6(-2.5,0) 7(-3,0) 8(-3.5,0) 9(-4,0) 10(-4.5,0) 11(-5,0) 12(-5.5,0) 13(-6,0) 14(-6.5,0) 15(-7,0) 16(-7.5,0)
  rect 2.489x1.905 smd: 17(2.15,3.3) 18(-9.65,3.3)
TYCO_2-2013290-1_204P
  round 1.092 hole 1.092 unplated: (-65.05,-4.1)
  round 1.6 hole 1.6 unplated: (1.75,-4.1)
  oval 0.356x2.007 smd: 1(0,0) 2(-0.3,-8.2) 3(-0.6,0) 4(-0.9,-8.2) 5(-1.2,0) 6(-1.5,-8.2) 7(-1.8,0) 8(-2.1,-8.2) 9(-2.4,0) 10(-2.7,-8.2) 11(-3,0) 12(-3.3,-8.2) 13(-3.6,0) 14(-3.9,-8.2) 15(-4.2,0) 16(-4.5,-8.2) 17(-4.8,0) 18(-5.1,-8.2) 19(-5.4,0) 20(-5.7,-8.2) 21(-6,0) 22(-6.3,-8.2) 23(-6.6,0) 24(-6.9,-8.2) 25(-7.2,0) 26(-7.5,-8.2) 27(-7.8,0) 28(-8.1,-8.2) 29(-8.4,0) 30(-8.7,-8.2) 31(-9,0) 32(-9.3,-8.2) 33(-9.6,0) 34(-9.9,-8.2) 35(-10.2,0) 36(-10.5,-8.2) 37(-10.8,0) 38(-11.1,-8.2) 39(-11.4,0) 40(-11.7,-8.2) 41(-12,0) 42(-12.3,-8.2) 43(-12.6,0) 44(-12.9,-8.2) 45(-13.2,0) 46(-13.5,-8.2) 47(-13.8,0) 48(-14.1,-8.2) 49(-14.4,0) 50(-14.7,-8.2) 51(-15,0) 52(-15.3,-8.2) 53(-15.6,0) 54(-15.9,-8.2) 55(-16.2,0) 56(-16.5,-8.2) 57(-16.8,0) 58(-17.1,-8.2) 59(-17.4,0) 60(-17.7,-8.2) 61(-18,0) 62(-18.3,-8.2) 63(-18.6,0) 64(-18.9,-8.2) 65(-19.2,0) 66(-19.5,-8.2) 67(-19.8,0) 68(-20.1,-8.2) 69(-20.4,0) 70(-20.7,-8.2) 71(-21,0) 72(-21.3,-8.2) 73(-24,0) 74(-24.3,-8.2) 75(-24.6,0) 76(-24.9,-8.2) 77(-25.2,0) 78(-25.5,-8.2) 79(-25.8,0) 80(-26.1,-8.2) 81(-26.4,0) 82(-26.7,-8.2) 83(-27,0) 84(-27.3,-8.2) 85(-27.6,0) 86(-27.9,-8.2) 87(-28.2,0) 88(-28.5,-8.2) 89(-28.8,0) 90(-29.1,-8.2) 91(-29.4,0) 92(-29.7,-8.2) 93(-30,0) 94(-30.3,-8.2) 95(-30.6,0) 96(-30.9,-8.2) 97(-31.2,0) 98(-31.5,-8.2) 99(-31.8,0) 100(-32.1,-8.2) 101(-32.4,0) 102(-32.7,-8.2) 103(-33,0) 104(-33.3,-8.2) 105(-33.6,0) 106(-33.9,-8.2) 107(-34.2,0) 108(-34.5,-8.2) 109(-34.8,0) 110(-35.1,-8.2) 111(-35.4,0) 112(-35.7,-8.2) 113(-36,0) 114(-36.3,-8.2) 115(-36.6,0) 116(-36.9,-8.2) 117(-37.2,0) 118(-37.5,-8.2) 119(-37.8,0) 120(-38.1,-8.2) 121(-38.4,0) 122(-38.7,-8.2) 123(-39,0) 124(-39.3,-8.2) 125(-39.6,0) 126(-39.9,-8.2) 127(-40.2,0) 128(-40.5,-8.2) 129(-40.8,0) 130(-41.1,-8.2) 131(-41.4,0) 132(-41.7,-8.2) 133(-42,0) 134(-42.3,-8.2) 135(-42.6,0) 136(-42.9,-8.2) 137(-43.2,0) 138(-43.5,-8.2) 139(-43.8,0) 140(-44.1,-8.2) 141(-44.4,0) 142(-44.7,-8.2) 143(-45,0) 144(-45.3,-8.2) 145(-45.6,0) 146(-45.9,-8.2) 147(-46.2,0) 148(-46.5,-8.2) 149(-46.8,0) 150(-47.1,-8.2) 151(-47.4,0) 152(-47.7,-8.2) 153(-48,0) 154(-48.3,-8.2) 155(-48.6,0) 156(-48.9,-8.2) 157(-49.2,0) 158(-49.5,-8.2) 159(-49.8,0) 160(-50.1,-8.2) 161(-50.4,0) 162(-50.7,-8.2) 163(-51,0) 164(-51.3,-8.2) 165(-51.6,0) 166(-51.9,-8.2) 167(-52.2,0) 168(-52.5,-8.2) 169(-52.8,0) 170(-53.1,-8.2) 171(-53.4,0) 172(-53.7,-8.2) 173(-54,0) 174(-54.3,-8.2) 175(-54.6,0) 176(-54.9,-8.2) 177(-55.2,0) 178(-55.5,-8.2) 179(-55.8,0) 180(-56.1,-8.2) 181(-56.4,0) 182(-56.7,-8.2) 183(-57,0) 184(-57.3,-8.2) 185(-57.6,0) 186(-57.9,-8.2) 187(-58.2,0) 188(-58.5,-8.2) 189(-58.8,0) 190(-59.1,-8.2) 191(-59.4,0) 192(-59.7,-8.2) 193(-60,0) 194(-60.3,-8.2) 195(-60.6,0) 196(-60.9,-8.2) 197(-61.2,0) 198(-61.5,-8.2) 199(-61.8,0) 200(-62.1,-8.2) 201(-62.4,0) 202(-62.7,-8.2) 203(-63,0) 204(-63.3,-8.2)
  rect 3.505x4.597 smd: 205(1.15,7.9) 206(-64.45,7.9)
TYCO_2-2013311-1_204P
  round 1.092 hole 1.092 unplated: (-65.05,-4.1)
  round 1.6 hole 1.6 unplated: (1.75,-4.1)
  oval 0.356x2.007 smd: 1(0,0) 2(-0.3,-8.2) 3(-0.6,0) 4(-0.9,-8.2) 5(-1.2,0) 6(-1.5,-8.2) 7(-1.8,0) 8(-2.1,-8.2) 9(-2.4,0) 10(-2.7,-8.2) 11(-3,0) 12(-3.3,-8.2) 13(-3.6,0) 14(-3.9,-8.2) 15(-4.2,0) 16(-4.5,-8.2) 17(-4.8,0) 18(-5.1,-8.2) 19(-5.4,0) 20(-5.7,-8.2) 21(-6,0) 22(-6.3,-8.2) 23(-6.6,0) 24(-6.9,-8.2) 25(-7.2,0) 26(-7.5,-8.2) 27(-7.8,0) 28(-8.1,-8.2) 29(-8.4,0) 30(-8.7,-8.2) 31(-9,0) 32(-9.3,-8.2) 33(-9.6,0) 34(-9.9,-8.2) 35(-10.2,0) 36(-10.5,-8.2) 37(-10.8,0) 38(-11.1,-8.2) 39(-11.4,0) 40(-11.7,-8.2) 41(-12,0) 42(-12.3,-8.2) 43(-12.6,0) 44(-12.9,-8.2) 45(-13.2,0) 46(-13.5,-8.2) 47(-13.8,0) 48(-14.1,-8.2) 49(-14.4,0) 50(-14.7,-8.2) 51(-15,0) 52(-15.3,-8.2) 53(-15.6,0) 54(-15.9,-8.2) 55(-16.2,0) 56(-16.5,-8.2) 57(-16.8,0) 58(-17.1,-8.2) 59(-17.4,0) 60(-17.7,-8.2) 61(-18,0) 62(-18.3,-8.2) 63(-18.6,0) 64(-18.9,-8.2) 65(-19.2,0) 66(-19.5,-8.2) 67(-19.8,0) 68(-20.1,-8.2) 69(-20.4,0) 70(-20.7,-8.2) 71(-21,0) 72(-21.3,-8.2) 73(-24,0) 74(-24.3,-8.2) 75(-24.6,0) 76(-24.9,-8.2) 77(-25.2,0) 78(-25.5,-8.2) 79(-25.8,0) 80(-26.1,-8.2) 81(-26.4,0) 82(-26.7,-8.2) 83(-27,0) 84(-27.3,-8.2) 85(-27.6,0) 86(-27.9,-8.2) 87(-28.2,0) 88(-28.5,-8.2) 89(-28.8,0) 90(-29.1,-8.2) 91(-29.4,0) 92(-29.7,-8.2) 93(-30,0) 94(-30.3,-8.2) 95(-30.6,0) 96(-30.9,-8.2) 97(-31.2,0) 98(-31.5,-8.2) 99(-31.8,0) 100(-32.1,-8.2) 101(-32.4,0) 102(-32.7,-8.2) 103(-33,0) 104(-33.3,-8.2) 105(-33.6,0) 106(-33.9,-8.2) 107(-34.2,0) 108(-34.5,-8.2) 109(-34.8,0) 110(-35.1,-8.2) 111(-35.4,0) 112(-35.7,-8.2) 113(-36,0) 114(-36.3,-8.2) 115(-36.6,0) 116(-36.9,-8.2) 117(-37.2,0) 118(-37.5,-8.2) 119(-37.8,0) 120(-38.1,-8.2) 121(-38.4,0) 122(-38.7,-8.2) 123(-39,0) 124(-39.3,-8.2) 125(-39.6,0) 126(-39.9,-8.2) 127(-40.2,0) 128(-40.5,-8.2) 129(-40.8,0) 130(-41.1,-8.2) 131(-41.4,0) 132(-41.7,-8.2) 133(-42,0) 134(-42.3,-8.2) 135(-42.6,0) 136(-42.9,-8.2) 137(-43.2,0) 138(-43.5,-8.2) 139(-43.8,0) 140(-44.1,-8.2) 141(-44.4,0) 142(-44.7,-8.2) 143(-45,0) 144(-45.3,-8.2) 145(-45.6,0) 146(-45.9,-8.2) 147(-46.2,0) 148(-46.5,-8.2) 149(-46.8,0) 150(-47.1,-8.2) 151(-47.4,0) 152(-47.7,-8.2) 153(-48,0) 154(-48.3,-8.2) 155(-48.6,0) 156(-48.9,-8.2) 157(-49.2,0) 158(-49.5,-8.2) 159(-49.8,0) 160(-50.1,-8.2) 161(-50.4,0) 162(-50.7,-8.2) 163(-51,0) 164(-51.3,-8.2) 165(-51.6,0) 166(-51.9,-8.2) 167(-52.2,0) 168(-52.5,-8.2) 169(-52.8,0) 170(-53.1,-8.2) 171(-53.4,0) 172(-53.7,-8.2) 173(-54,0) 174(-54.3,-8.2) 175(-54.6,0) 176(-54.9,-8.2) 177(-55.2,0) 178(-55.5,-8.2) 179(-55.8,0) 180(-56.1,-8.2) 181(-56.4,0) 182(-56.7,-8.2) 183(-57,0) 184(-57.3,-8.2) 185(-57.6,0) 186(-57.9,-8.2) 187(-58.2,0) 188(-58.5,-8.2) 189(-58.8,0) 190(-59.1,-8.2) 191(-59.4,0) 192(-59.7,-8.2) 193(-60,0) 194(-60.3,-8.2) 195(-60.6,0) 196(-60.9,-8.2) 197(-61.2,0) 198(-61.5,-8.2) 199(-61.8,0) 200(-62.1,-8.2) 201(-62.4,0) 202(-62.7,-8.2) 203(-63,0) 204(-63.3,-8.2)
  rect 4.699x6.807 smd: 205(5.7,7.2) 206(-69,7.2)
TYCO_2-2041070-0_20P-T
  oval 0.305x1.295 smd: 1(0,0) 2(-0.5,0) 3(-1,0) 4(-1.5,0) 5(-2,0) 6(-2.5,0) 7(-3,0) 8(-3.5,0) 9(-4,0) 10(-4.5,0) 11(-5,0) 12(-5.5,0) 13(-6,0) 14(-6.5,0) 15(-7,0) 16(-7.5,0) 17(-8,0) 18(-8.5,0) 19(-9,0) 20(-9.5,0)
  rect 2.489x1.905 smd: 21(-11.65,3.3) 22(2.15,3.3)
TYCO_2-2129116-3_31P-T
  round 0.94 hole 0.94 unplated: (-20.88,-4.825) (2.12,-4.825)
  round 0.991 hole 0.61: 1(0,0) 2(-1.27,0) 3(-2.54,0) 4(-3.81,0) 5(-5.08,0) 6(-6.35,0) 7(-7.62,0) 8(-13.83,-0.2) 9(-14.83,-1.2) 10(-15.83,-0.2) 11(-16.83,-1.2) 12(-17.83,-0.2) 13(-18.83,-1.2) 14(-0.379,-3.9) 15(-1.179,-1.5) 16(-1.979,-2.7) 17(-2.779,-3.9) 18(-3.579,-1.5) 19(-4.379,-2.7) 20(-5.18,-3.9) 21(-5.98,-1.5) 22(-6.78,-2.7) 23(-7.58,-3.9) 24(-8.38,-1.5) 25(-13.38,-2.7) 26(-14.18,-3.9) 27(-14.98,-2.7) 28(-15.78,-3.9) 29(-16.58,-2.7) 30(-17.38,-3.9) 31(-18.181,-2.7)
  oval 1.194x2.438 hole 0.508x1.753: 32(2.12,-1.8) 33(-20.88,-1.8)
W25Q32FVSSIQ_SO8
  oval 0.635x1.676 smd: 1(0,0) 2(1.27,0) 3(2.54,0) 4(3.81,0) 5(3.81,7.25) 6(2.54,7.25) 7(1.27,7.25) 8(0,7.25)
W25Q64FVSSIQ_SO8
  oval 0.635x1.676 smd: 1(0,0) 2(1.27,0) 3(2.54,0) 4(3.81,0) 5(3.81,7.25) 6(2.54,7.25) 7(1.27,7.25) 8(0,7.25)
WGI217LM-QPN9-A2_QFN48_6X6
  oval 0.203x1.041 smd: 1(0,0) 2(0.4,0) 3(0.8,0) 4(1.2,0) 5(1.6,0) 6(2,0) 7(2.4,0) 8(2.8,0) 9(3.2,0) 10(3.6,0) 11(4,0) 12(4.4,0) 25(4.4,5.95) 26(4,5.95) 27(3.6,5.95) 28(3.2,5.95) 29(2.8,5.95) 30(2.4,5.95) 31(2,5.95) 32(1.6,5.95) 33(1.2,5.95) 34(0.8,5.95) 35(0.4,5.95) 36(0,5.95)
  oval 1.041x0.203 smd: 13(5.175,0.775) 14(5.175,1.175) 15(5.175,1.575) 16(5.175,1.975) 17(5.175,2.375) 18(5.175,2.775) 19(5.175,3.175) 20(5.175,3.575) 21(5.175,3.975) 22(5.175,4.375) 23(5.175,4.775) 24(5.175,5.175) 37(-0.775,5.175) 38(-0.775,4.775) 39(-0.775,4.375) 40(-0.775,3.975) 41(-0.775,3.575) 42(-0.775,3.175) 43(-0.775,2.775) 44(-0.775,2.375) 45(-0.775,1.975) 46(-0.775,1.575) 47(-0.775,1.175) 48(-0.775,0.775)
  rect 2.997x2.997 smd: 49(2.2,2.975)
Y_7V27000011_4P
  rect 1.397x1.194 smd: 1(0,0) 2(2.2,0) 3(2.2,1.7) 4(0,1.7)
Y_Q13FC1350000_2P
  rect 0.991x1.803 smd: 1(0,0) 2(2.5,0)
Y_Q22FA2380049900_4P
  rect 1.397x1.194 smd: 1(0,0) 2(2.2,0) 3(2.2,1.6) 4(0,1.6)
Y_X3G025000DI1H-H_4P
  rect 1.397x1.194 smd: 1(0,0) 2(2.2,0) 3(2.2,1.7) 4(0,1.7)

## Nets
0.75V_DDR_VTT_ON: PR208.1 R790.2 U46.A60
1.05V_A_PWRGD: PR300.1 PU300.1 U51.B28
1.05V_RUN_ENABLE: C773.1 Q52.3 Q63.4 R930.2 R1611.1
1.5VSP_FB: PC402.2 PR402.2 PR405.1 PU400.6
1.5VSP_LX: PL401.1 PR401.1 PU400.2 PU400.3
1.5VSP_VIN: PC400.1 PC401.1 PJP400.1 PU400.8 PU400.9 PU400.10
1.8V_PWRGD: PR685.2 PU603.4
1.8VSP_FB: PC671.2 PR687.2 PR689.1 PU603.6
1.8VSP_LX: PL604.1 PR686.2 PU603.2 PU603.3
1.8VSP_VIN: PC669.1 PC670.1 PJP611.1 PU603.8 PU603.9 PU603.10
1.35V_B+: PC202.1 PC203.1 PC204.1 PC205.1 PJP200.1 PQ201.5 PR205.1
1.35V_FB: PC211.1 PR204.1 PR207.2 PU200.6
1.35V_SUS_PWRGD: PR209.2 PU200.10 RC9.2 RC14.2 RC103.2 U51.B9
3.3V_RUN_GFX_ON: QH3.2 U46.A55
3V_5V_EN: PC120.1 PR110.2 PU100.6 PU100.20
+0.9V_LAN: C462.1 C463.1 C466.1 C467.1 C468.1 C469.1 C1177.1 L29.2 R548.1 U31.8 U31.11 U31.16 U31.22 U31.37 U31.40 U31.43 U31.46 U31.47
+0.675V_DDR_VTT: CD17.1 CD18.1 CD19.1 CD20.1 CD39.1 CD40.1 CD41.1 CD42.1 JDIMM1.203 JDIMM1.204 JDIMM2.203 JDIMM2.204 PJP202.1 R927.1
+0.675V_P: PC207.1 PC208.1 PJP202.2 PU200.2 PU200.20
+1.2V_LDO: C1505.2 C1506.2 C1507.2 L47.2 U38.10 U38.41
+1.2V_LDO_OZ: C561.2 C562.2 C1508.2 C1509.2 C1510.2 L47.1 U38.1 U38.28 U38.31 U38.36
+1.2V_OZ_AUX_LDO: C564.2 C801.2 U38.12
+1.05V_+1.5V_RUN: CH26.1 CH31.1 CH32.1 CH33.1 CH52.1 RH165.2 RH233.1 RH235.1 UH1.AF34 UH1.AK26 UH1.AK28 UH1.AN11 UH1.BB44 UH1.BE22
+1.5V_CARD: C637.1 C638.1 C645.1 JEXP1.10 JEXP1.12 U41.11 U41.13
+1.05V_M: CH28.1 CH29.1 CH30.1 PJP301.1 PJP302.1 Q63.5 Q63.6 Q63.7 Q63.8 R548.2 RH234.1 RH236.2 RH239.1 UH1.AA18 UH1.L17 UH1.R18 UH1.U18 UH1.U20 UH1.U22 UH1.U24 UH1.V18 UH1.V20 UH1.V22 UH1.V24 UH1.Y18 UH1.Y20 UH1.Y22
+1.05V_MP: PC301.1 PJP301.2 PJP302.2 PL301.2 PR306.1
+1.05V_RUN: C772.1 CH21.1 CH22.1 CH23.1 CH24.1 CH25.1 CH34.1 CH35.1 CH36.1 CH37.1 CH38.1 CH47.1 CH50.1 JXDP2.40 PR527.1 Q63.1 Q63.2 Q63.3 R866.2 R925.1 R931.1 R1179.1 RC27.1 RC53.1 RC54.1 RC55.1 RC57.1 RC60.1 RC85.1 RC86.2 RC99.2 RC105.2 RH206.1 RH235.2 RH243.1 RH244.1 RH246.1 UH1.AA24 UH1.AA26 UH1.AD20 UH1.AD22 UH1.AD24 UH1.AD26 UH1.AD28 UH1.AE18 UH1.AE20 UH1.AE22 UH1.AE24 UH1.AE26 UH1.AG18 UH1.AG20 UH1.AG22 UH1.AG24 UH1.AK18 UH1.AK20 UH1.AK22 UH1.AM18 UH1.AM20 UH1.AM22 UH1.AN34 UH1.AN35 UH1.AP22 UH1.AR22 UH1.AT22 UH1.U30 UH1.U35 UH1.U36 UH1.V28 UH1.V30 UH1.Y26 UH1.Y30
+1.5V_RUN: C635.1 LH1.1 PJP2.1 PJP401.1 RH51.1 RH57.2 RH96.1 RH98.2 RH99.1 RH100.1 RH163.2 RH188.1 RH192.1 RH233.2 U41.12 U41.14 UH1.AW40
+1.05V_RUN_CHG: Q70.1 R925.2
+1.5V_RUN_HDMI: C340.1 C342.1 C344.1 C354.1 C355.1 PJP2.2 U19.12 U19.19 U19.20 U19.31 U19.40
+1.05V_RUN_VCC: RH241.1 RH246.2
+1.5V_RUNP: PC402.1 PC403.1 PC404.1 PC405.1 PJP401.2 PL401.2 PR402.1
+1.05VSP_B+: PC302.1 PC303.1 PC304.1 PC305.1 PJP300.2 PQ301.5
+1.8V_MPLL_PVDD: CV215.1 CV216.1 CV219.1 LV17.1 UV1.H7 UV1.H8
+1.8V_RUN_CARD: C560.2 C579.1 C580.1 C1511.2 JSD1.14 R831.1 U38.24
+1.8V_RUN_GFX: CV51.1 CV63.1 CV64.1 CV65.1 CV116.1 CV117.1 CV118.1 CV119.1 CV198.1 CV201.1 CV203.1 CV226.1 CV227.1 LV16.1 LV17.2 LV18.2 LV19.1 LV20.1 PJP612.1 RV68.1 RV237.1 RV239.1 RV241.1 RV244.1 UV1.AB37 UV1.AC33 UV1.AD34 UV1.AF34 UV1.AG34 UV1.AH34 UV1.AJ34 UV1.AL38 UV1.AM32 UV1.AM37
+1.8V_RUN_GFX_VDDR4: CV60.1 CV61.1 CV62.1 LV20.2 UV1.AD12 UV1.AF11 UV1.AF12 UV1.AF13 UV1.AF15 UV1.AG11 UV1.AG13 UV1.AG15
+1.8V_RUNP: PC671.1 PC672.1 PC673.1 PC674.1 PJP612.2 PL604.2 PR687.1
+1.8V_SPLL_PVDD: CV220.1 CV221.1 CV222.1 LV18.1 UV1.AM10
+1.35V_CPU_VDDQ: CC22.1 CC23.1 CC24.1 CC25.1 CC26.1 CC27.1 CC28.1 CC29.1 CC30.1 CC31.1 CC32.1 CC33.1 CC34.1 CC35.1 CC36.1 CC37.1 CC38.1 CC39.1 CC40.1 CC41.1 CC42.1 CC43.1 CC44.1 CC45.1 CC46.1 CC135.1 JCPU1.AB2 JCPU1.AB5 JCPU1.AB8 JCPU1.AB11 JCPU1.AE2 JCPU1.AE5 JCPU1.AE8 JCPU1.AE11 JCPU1.AH11 JCPU1.K11 JCPU1.N8 JCPU1.N11 JCPU1.T2 JCPU1.T5 JCPU1.T8 JCPU1.T11 JCPU1.W2 JCPU1.W5 JCPU1.W8 JCPU1.W11 PJP5.2 PJP6.2 QC6.1 QC6.2 QC6.3 R926.1 RC6.1 RC84.1
+1.35V_CPU_VDDQ_CHG: Q71.1 R926.2
+1.35V_MEM: CC22.2 CC23.2 CD3.1 CD4.1 CD5.1 CD6.1 CD7.1 CD8.1 CD9.1 CD10.1 CD11.1 CD12.1 CD13.1 CD14.1 CD25.1 CD26.1 CD27.1 CD28.1 CD29.1 CD30.1 CD31.1 CD32.1 CD33.1 CD34.1 CD35.1 CD36.1 JDIMM1.75 JDIMM1.76 JDIMM1.81 JDIMM1.82 JDIMM1.87 JDIMM1.88 JDIMM1.93 JDIMM1.94 JDIMM1.99 JDIMM1.100 JDIMM1.105 JDIMM1.106 JDIMM1.111 JDIMM1.112 JDIMM1.117 JDIMM1.118 JDIMM1.123 JDIMM1.124 JDIMM2.75 JDIMM2.76 JDIMM2.81 JDIMM2.82 JDIMM2.87 JDIMM2.88 JDIMM2.93 JDIMM2.94 JDIMM2.99 JDIMM2.100 JDIMM2.105 JDIMM2.106 JDIMM2.111 JDIMM2.112 JDIMM2.117 JDIMM2.118 JDIMM2.123 JDIMM2.124 PJP5.1 PJP6.1 PJP203.1 PJP204.1 QC6.5 QC6.6 QC6.7 QC6.8 QV1.5 QV1.6 QV1.7 QV1.8 RD2.1 RD15.1 RD19.1 RD22.1
+1.35V_MEM_GFX: C783.1 CV18.1 CV19.1 CV21.1 CV24.1 CV26.1 CV28.1 CV30.1 CV32.1 CV34.1 CV36.1 CV38.1 CV40.1 CV41.1 CV42.1 CV43.1 CV44.1 CV45.1 CV46.1 CV47.1 CV48.1 CV130.1 CV131.1 CV133.1 CV134.1 CV135.1 CV137.1 CV138.1 CV139.1 CV140.1 CV141.1 CV142.1 CV143.1 CV144.1 CV145.1 CV146.1 CV147.1 CV148.1 CV149.1 CV150.1 CV151.1 CV152.1 CV153.1 CV154.1 CV155.1 CV156.1 CV157.1 CV158.1 CV159.1 CV162.1 CV163.1 CV168.1 CV170.1 CV173.1 CV176.1 CV177.1 CV178.1 CV179.1 CV180.1 CV181.1 CV182.1 CV185.1 CV188.1 CV189.1 CV191.1 CV192.1 CV199.1 CV200.1 CV202.1 CV208.1 CV209.1 CV217.1 CV218.1 CV237.1 CV238.1 CV280.1 CV281.1 CV283.1 CV284.1 CV285.1 CV286.1 CV287.1 CV288.1 CV290.1 CV291.1 CV292.1 CV293.1 CV294.1 CV295.1 CV296.1 CV297.1 CV298.1 CV299.1 CV301.1 CV302.1 CV303.1 CV304.1 CV305.1 CV306.1 CV307.1 CV308.1 CV309.1 CV310.1 CV311.1 CV312.1 CV313.1 CV315.1 CV316.1 CV318.1 CV319.1 CV320.1 CV322.1 CV323.1 CV325.1 CV328.1 CV330.1 CV333.1 CV350.1 CV352.1 CV354.1 CV356.1 QV1.1 QV1.2 QV1.3 RV1.1 RV3.1 RV6.1 RV8.1 RV10.1 RV12.1 RV14.1 RV16.1 RV19.1 RV21.1 RV23.1 RV27.1 RV28.1 RV31.1 RV32.1 RV109.1 RV119.1 RV129.1 RV139.1 RV140.1 RV145.1 RV148.1 RV153.1 RV155.1 RV177.1 RV182.1 RV183.1 RV185.1 RV187.2 RV188.2 RV189.2 RV190.2 RV191.1 RV193.1 RV195.1 RV197.1 RV203.1 RV206.2 RV208.2 RV209.2 RV210.2 UV1.AC7 UV1.AD11 UV1.AF7 UV1.AG10 UV1.AJ7 UV1.AK8 UV1.AL9 UV1.G11 UV1.G14 UV1.G17 UV1.G20 UV1.G23 UV1.G26 UV1.G29 UV1.H10 UV1.J7 UV1.J9 UV1.K8 UV1.K11 UV1.K13 UV1.L7 UV1.L12 UV1.L16 UV1.L21 UV1.L23 UV1.L26 UV1.M11 UV1.N11 UV1.P7 UV1.R11 UV1.U7 UV1.U11 UV1.Y7 UV1.Y11 UV3.B1 UV3.B3 UV3.B12 UV3.B14 UV3.C5 UV3.C10 UV3.D1 UV3.D3 UV3.D11 UV3.D12 UV3.D13 UV3.D14 UV3.E5 UV3.E10 UV3.F1 UV3.F3 UV3.F12 UV3.F14 UV3.G1 UV3.G2 UV3.G4 UV3.G11 UV3.G13 UV3.G14 UV3.H3 UV3.H12 UV3.J1 UV3.K3 UV3.K12 UV3.L1 UV3.L2 UV3.L4 UV3.L11 UV3.L13 UV3.L14 UV3.M1 UV3.M3 UV3.M12 UV3.M14 UV3.N5 UV3.N10 UV3.P1 UV3.P2 UV3.P3 UV3.P11 UV3.P12 UV3.P14 UV3.R5 UV3.R10 UV3.T1 UV3.T3 UV3.T12 UV3.T14 UV4.B1 UV4.B3 UV4.B12 UV4.B14 UV4.C5 UV4.C10 UV4.D1 UV4.D3 UV4.D11 UV4.D12 UV4.D13 UV4.D14 UV4.E5 UV4.E10 UV4.F1 UV4.F3 UV4.F12 UV4.F14 UV4.G1 UV4.G2 UV4.G4 UV4.G11 UV4.G13 UV4.G14 UV4.H3 UV4.H12 UV4.K3 UV4.K12 UV4.L1 UV4.L2 UV4.L4 UV4.L11 UV4.L13 UV4.L14 UV4.M1 UV4.M3 UV4.M12 UV4.M14 UV4.N5 UV4.N10 UV4.P1 UV4.P2 UV4.P3 UV4.P11 UV4.P12 UV4.P14 UV4.R5 UV4.R10 UV4.T1 UV4.T3 UV4.T12 UV4.T14 UV5.B1 UV5.B3 UV5.B12 UV5.B14 UV5.C5 UV5.C10 UV5.D1 UV5.D3 UV5.D11 UV5.D12 UV5.D13 UV5.D14 UV5.E5 UV5.E10 UV5.F1 UV5.F3 UV5.F12 UV5.F14 UV5.G1 UV5.G2 UV5.G4 UV5.G11 UV5.G13 UV5.G14 UV5.H3 UV5.H12 UV5.J1 UV5.K3 UV5.K12 UV5.L1 UV5.L2 UV5.L4 UV5.L11 UV5.L13 UV5.L14 UV5.M1 UV5.M3 UV5.M12 UV5.M14 UV5.N5 UV5.N10 UV5.P1 UV5.P2 UV5.P3 UV5.P11 UV5.P12 UV5.P14 UV5.R5 UV5.R10 UV5.T1 UV5.T3 UV5.T12 UV5.T14 UV6.B1 UV6.B3 UV6.B12 UV6.B14 UV6.C5 UV6.C10 UV6.D1 UV6.D3 UV6.D11 UV6.D12 UV6.D13 UV6.D14 UV6.E5 UV6.E10 UV6.F1 UV6.F3 UV6.F12 UV6.F14 UV6.G1 UV6.G2 UV6.G4 UV6.G11 UV6.G13 UV6.G14 UV6.H3 UV6.H12 UV6.K3 UV6.K12 UV6.L1 UV6.L2 UV6.L4 UV6.L11 UV6.L13 UV6.L14 UV6.M1 UV6.M3 UV6.M12 UV6.M14 UV6.N5 UV6.N10 UV6.P1 UV6.P2 UV6.P3 UV6.P11 UV6.P12 UV6.P14 UV6.R5 UV6.R10 UV6.T1 UV6.T3 UV6.T12 UV6.T14 UV7.B1 UV7.B3 UV7.B12 UV7.B14 UV7.C5 UV7.C10 UV7.D1 UV7.D3 UV7.D11 UV7.D12 UV7.D13 UV7.D14 UV7.E5 UV7.E10 UV7.F1 UV7.F3 UV7.F12 UV7.F14 UV7.G1 UV7.G2 UV7.G4 UV7.G11 UV7.G13 UV7.G14 UV7.H3 UV7.H12 UV7.J1 UV7.K3 UV7.K12 UV7.L1 UV7.L2 UV7.L4 UV7.L11 UV7.L13 UV7.L14 UV7.M1 UV7.M3 UV7.M12 UV7.M14 UV7.N5 UV7.N10 UV7.P1 UV7.P2 UV7.P3 UV7.P11 UV7.P12 UV7.P14 UV7.R5 UV7.R10 UV7.T1 UV7.T3 UV7.T12 UV7.T14 UV8.B1 UV8.B3 UV8.B12 UV8.B14 UV8.C5 UV8.C10 UV8.D1 UV8.D3 UV8.D11 UV8.D12 UV8.D13 UV8.D14 UV8.E5 UV8.E10 UV8.F1 UV8.F3 UV8.F12 UV8.F14 UV8.G1 UV8.G2 UV8.G4 UV8.G11 UV8.G13 UV8.G14 UV8.H3 UV8.H12 UV8.K3 UV8.K12 UV8.L1 UV8.L2 UV8.L4 UV8.L11 UV8.L13 UV8.L14 UV8.M1 UV8.M3 UV8.M12 UV8.M14 UV8.N5 UV8.N10 UV8.P1 UV8.P2 UV8.P3 UV8.P11 UV8.P12 UV8.P14 UV8.R5 UV8.R10 UV8.T1 UV8.T3 UV8.T12 UV8.T14 UV9.B1 UV9.B3 UV9.B12 UV9.B14 UV9.C5 UV9.C10 UV9.D1 UV9.D3 UV9.D11 UV9.D12 UV9.D13 UV9.D14 UV9.E5 UV9.E10 UV9.F1 UV9.F3 UV9.F12 UV9.F14 UV9.G1 UV9.G2 UV9.G4 UV9.G11 UV9.G13 UV9.G14 UV9.H3 UV9.H12 UV9.J1 UV9.K3 UV9.K12 UV9.L1 UV9.L2 UV9.L4 UV9.L11 UV9.L13 UV9.L14 UV9.M1 UV9.M3 UV9.M12 UV9.M14 UV9.N5 UV9.N10 UV9.P1 UV9.P2 UV9.P3 UV9.P11 UV9.P12 UV9.P14 UV9.R5 UV9.R10 UV9.T1 UV9.T3 UV9.T12 UV9.T14 UV10.B1 UV10.B3 UV10.B12 UV10.B14 UV10.C5 UV10.C10 UV10.D1 UV10.D3 UV10.D11 UV10.D12 UV10.D13 UV10.D14 UV10.E5 UV10.E10 UV10.F1 UV10.F3 UV10.F12 UV10.F14 UV10.G1 UV10.G2 UV10.G4 UV10.G11 UV10.G13 UV10.G14 UV10.H3 UV10.H12 UV10.K3 UV10.K12 UV10.L1 UV10.L2 UV10.L4 UV10.L11 UV10.L13 UV10.L14 UV10.M1 UV10.M3 UV10.M12 UV10.M14 UV10.N5 UV10.N10 UV10.P1 UV10.P2 UV10.P3 UV10.P11 UV10.P12 UV10.P14 UV10.R5 UV10.R10 UV10.T1 UV10.T3 UV10.T12 UV10.T14
+1.35V_MEM_GFX_CHG: QV11.1 RV182.2
+1.35V_MEN_P: PC201.1 PC211.2 PC214.1 PC216.1 PJP201.1 PJP203.2 PJP204.2 PL201.1 PR204.2 PU200.5
+3.3V_ALW: C1.1 C288.1 C720.1 C725.1 C726.1 C756.1 C778.1 CV87.1 JKB1.4 PC733.2 PC801.2 PC802.2 PC804.2 PC805.2 PJP63.2 PJP65.1 PJP100.2 PJP102.2 PJP400.2 PJP611.2 PR2.1 PR6.1 PR11.2 PR24.1 PR119.2 PR209.1 PR300.2 PR720.1 PR748.1 PR801.1 PR807.1 PR810.1 PR868.2 PR878.1 PR880.1 PR895.1 PU702.8 PU704.5 PU801.5 PU802.5 PU803.5 PU804.5 R24.1 R51.1 R52.2 R418.1 R420.1 R515.1 R755.2 R759.1 R760.1 R761.1 R762.1 R763.1 R768.1 R769.1 R771.1 R774.1 R776.1 R778.1 R796.1 R798.1 R800.1 R805.1 R814.1 R817.1 R818.1 R820.1 R827.1 R828.1 R834.1 R838.1 R839.1 R841.1 R847.1 R848.1 R849.1 R850.1 R854.1 R855.1 R856.1 R864.1 R871.1 R872.1 R875.1 R920.1 R932.1 R937.1 R940.1 R1125.1 R1162.1 R1171.1 R1183.1 R1630.2 RC4.1 RH238.1 RH247.1 RPH2.5 RPH2.6 RPH2.7 RPH2.8 U1.2 U9.5 U50.5 U54.5 U55.5 U58.5 U100.1 U100.2 U100.6 U100.7 U101.1 U101.2 U101.6 U101.7 U102.1 U102.2 U102.6 U102.7 U103.1 U103.2 U103.6 U103.7 U104.1 U104.2 U104.6 U104.7 UV14.5
+3.3V_ALW2: CH11.1 PC114.2 PC808.2 PC810.2 PC812.2 PC818.2 PR103.1 PR726.1 PR733.1 PR747.1 PR800.2 PR808.1 PR816.2 PR819.2 PR823.2 PR824.2 PR829.1 PR846.1 PR848.1 PR849.1 PR862.1 PR864.1 PR875.1 PR894.1 PU100.3 PU805.5 PU806.5 PU807.5 PU809.5 R509.1 R874.2 R909.1 RC97.1 RV81.2 UH2.5
+3.3V_ALW2_C2: PR848.2 PU808.4
+3.3V_ALW_5048: C705.1 C706.1 C707.1 C708.1 C709.1 C710.1 PJP63.1 U46.A17 U46.A43 U46.A54 U46.B5 U46.B30
+3.3V_ALW_PCH: C717.1 C718.1 C760.1 CH2.1 CH43.1 CH45.1 CH51.1 JAPS1.1 JMDC1.6 JXDP2.43 JXDP2.44 PJP68.1 PJP70.1 PJP72.1 PJP74.1 R17.1 R510.1 R513.1 R514.1 R1622.2 R1624.2 RC11.1 RC12.1 RH35.1 RH41.1 RH46.1 RH73.1 RH75.1 RH78.1 RH122.2 RH128.2 RH166.1 RH167.1 RH169.1 RH170.1 RH171.1 RH172.2 RH173.2 RH197.2 RH211.1 RH212.2 RH213.2 RH222.2 RH237.1 RH240.1 RPH1.5 RPH1.6 RPH1.7 RPH1.8 RPH3.5 RPH3.6 RPH3.7 RPH3.8 RPH8.5 RPH8.6 RPH8.7 RPH9.5 RPH9.6 RPH9.7 RPH9.8 U103.13 U103.14 UH1.A26 UH1.AJ30 UH1.AJ32 UH1.R20 UH1.R22 UH1.R24 UH1.R26 UH1.R28 UH1.U26
+3.3V_ALW_PCH_JTAG: RH46.2 RH48.1 RH50.1 RH52.1
+3.3V_ALW_VTR: C759.1 C774.1 C776.1 C777.1 C780.1 C781.1 C782.1 PJP65.2 U51.A11 U51.A26 U51.A41 U51.A52 U51.B3 U51.B35
+3.3V_CARD: C640.1 C641.1 C649.1 JEXP1.24 JEXP1.26 U41.3 U41.5
+3.3V_CARDAUX: C642.1 C643.1 C646.1 JEXP1.16 U41.15
+3.3V_LAN: C472.1 C473.1 C474.1 C475.1 C478.1 C481.1 C482.1 C1167.1 C1178.1 JLOM1.9 JLOM1.12 R154.1 R545.1 R546.1 R549.1 R553.1 R556.1 R558.1 RH174.1 RH175.1 U15.5 U32.1 U32.4 U32.8 U32.14 U32.21 U32.30 U32.39 U102.8 U102.9
+3.3V_LAN_OUT: C464.1 R154.2 U31.4 U31.5 U31.15 U31.19 U31.29
+3.3V_M: C454.1 CH59.1 JSPI1.16 R837.1 RH185.1 U102.13 U102.14 UH1.AD12
+3.3V_OZ_IO_LDO: C566.2 C800.2 U38.25
+3.3V_PCIE_FLASH: C449.1 C621.1 C622.1 C623.1 C624.2 C625.2 C626.1 JMINI3.2 JMINI3.24 JMINI3.39 JMINI3.41 JMINI3.52 U100.8 U100.9
+3.3V_PCIE_WWAN: C400.1 C401.1 C412.1 C451.1 C610.1 C611.1 C612.1 C613.1 C614.1 C615.1 C1176.1 JMINI1.2 JMINI1.24 JMINI1.39 JMINI1.41 JMINI1.52 Q77.2 R550.1 R554.1 R560.1 R563.1 R564.1 R565.1 R567.1 R719.2 R724.2 R727.2 U7.10 U7.20 U101.8 U101.9
+3.3V_RP1: C1527.1 C1528.1 C1529.1 C1530.1 C1537.1 PJP66.2 PJP68.2 R3703.1 R3704.1 R3705.1 R3706.1 R3707.1 R3708.1 R3709.1 R3723.1 R3724.1 R3725.1 R3726.1 U92.1 U92.13
+3.3V_RP2: C1512.1 C1513.1 C1514.1 C1515.1 C1522.1 PJP69.2 PJP70.2 R3673.1 R3674.1 R3675.1 R3676.1 R3677.1 R3678.1 R3679.1 R3692.1 R3693.1 R3694.1 R3695.1 U90.1 U90.13
+3.3V_RP3: C1538.1 C1552.1 C1557.1 C1558.1 C1559.1 PJP73.2 PJP74.2 R3758.1 R3762.1 R3767.1 R3768.1 R3769.1 R3771.1 R3772.1 R3774.1 R3777.1 R3778.1 R3780.1 U95.1 U95.13
+3.3V_RP4: C1542.1 C1544.1 C1545.1 C1548.1 C1549.1 PJP71.2 PJP72.2 R3733.1 R3735.1 R3737.1 R3738.1 R3739.1 R3744.1 R3746.1 R3747.1 R3750.1 R3752.1 R3754.1 U94.1 U94.13
+3.3V_RTC_LDO: PD3.3 PR103.2
+3.3V_RUN: C25.1 C26.1 C27.1 C28.1 C29.1 C31.1 C32.1 C51.1 C301.1 C356.1 C366.1 C447.1 C573.1 C574.1 C578.1 C581.1 C634.1 C1501.2 C1502.2 C1503.2 C1504.2 CC21.1 CD21.1 CD22.1 CD43.1 CD44.1 CH10.1 CH12.1 CH27.1 CH48.1 CH49.1 CH65.1 JDIMM1.199 JDIMM2.199 JLVDS1.37 JUSH1.8 L45.2 PJP53.1 PJP60.1 PJP61.1 PJP64.1 PJP66.1 PJP67.1 PJP69.1 PJP71.1 PJP73.1 PJP80.2 PR400.1 PR519.2 PR620.1 PR627.1 PR679.1 PR685.1 PR691.2 PR692.1 Q23.3 QH4.2 QH4.5 QV5.2 R30.1 R38.1 R61.1 R65.1 R72.1 R73.1 R79.1 R80.1 R85.1 R86.1 R159.1 R160.1 R415.1 R416.1 R501.1 R502.1 R503.1 R508.1 R516.1 R737.2 R739.2 R772.1 R777.1 R780.1 R782.1 R799.1 R822.1 R829.1 R894.1 R1062.1 R1066.1 R1081.1 R1082.1 R1099.1 R1100.1 R1118.1 R1161.1 R1169.1 R1197.1 R1530.1 R1539.1 R1700.1 RC52.1 RD12.2 RH34.1 RH36.2 RH37.1 RH40.1 RH88.1 RH89.1 RH90.1 RH93.1 RH125.1 RH133.1 RH168.1 RH193.1 RH194.1 RH198.2 RH199.1 RH200.1 RH201.1 RH202.2 RH203.2 RH204.2 RH205.2 RH207.2 RH208.2 RH224.1 RH225.2 RH228.2 RH229.1 RH242.1 RH245.1 RH254.2 RH255.1 RH256.1 RH257.1 RH258.2 RH328.1 RPH4.5 RPH4.6 RPH4.7 RPH4.8 RPH6.5 RPH6.6 RPH6.7 RV33.1 U6.4 U6.23 U6.29 U6.32 U19.11 U19.37 U20.14 U23.14 U38.11 U38.13 U38.23 U38.42 U41.2 U41.4 U101.13 U101.14 UC2.5 UC3.5 UH1.AE14 UH1.AF12 UH1.AG14 UH1.AK30 UH1.AK32 UH1.L24 UH1.M31 UH1.R30 UH1.R32 UH3.5
+3.3V_RUN_CARD: C559.2 C570.1 C572.1 JSD1.4 R826.1 U38.22
+3.3V_RUN_DVDD: C952.1 C953.1 C984.1 C994.1 PJP60.2 U74.3 U74.9
+3.3V_RUN_EDP: PJP67.2 R105.2 R107.2 R110.1 R3881.2 R3882.2 U26.3 U26.8
+3.3V_RUN_FFS: C387.1 C388.1 PJP53.2 U88.1 U88.7 U88.8 U88.14
+3.3V_RUN_GFX: C771.1 LV30.1 PR602.2 PR604.2 PR606.2 PR608.2 PR611.2 PR613.2 QV4.3 RV29.1 RV41.2 RV57.1 RV79.1 RV84.2 RV86.1 RV87.1 RV95.1 RV96.1 RV97.1 RV102.1 RV103.1 RV141.1 U103.8 U103.9
+3.3V_RUN_GFX_VDDR3: CV49.1 CV50.1 CV58.1 CV59.1 LV30.2 UV1.AF23 UV1.AF24 UV1.AG23 UV1.AG24
+3.3V_RUN_HDD: C399.1 C402.1 JSATA1.8 JSATA1.9 PJP64.2 R1635.1
+3.3V_RUN_HDD_R: JSATA1.10 R516.2 R1635.2
+3.3V_RUN_OZVCC: C575.1 C576.1 C577.1 L45.1 U38.9 U38.27
+3.3V_RUN_TPM: C44.1 C45.1 C550.1 C551.1 C552.1 C553.1 PJP61.2 U39.5 U39.10 U39.19 U39.24
+3.3V_SPI: C746.1 C1216.1 JSPI1.15 R3664.1 R3665.1 R3666.1 R3668.1 RH185.2 U52.8 U53.8
+3.3V_SUS: C53.1 C633.1 C765.1 JUSH1.11 JUSH1.12 JUSH1.13 R585.1 R589.1 R731.1 R732.1 U41.17 U104.8 U104.9
+3.3V_TP: C755.1 JTP1.5 R902.1 R903.1 R1161.2 R1162.2
+3.3V_VCCPRTCSUS: CH53.1 RH240.2 RH247.2 UH1.K8
+3.3V_VTR: C739.1 C775.1 R834.2 R837.2 U51.A22
+3.3V_VTR_ADC: C736.1 C757.1 R839.2 U51.A58
+3.3V_WLAN: C446.1 C603.1 C604.1 C605.1 C606.2 C607.2 C608.1 JMINI2.2 JMINI2.24 JMINI2.39 JMINI2.41 JMINI2.52 Q89.2 Q124.2 Q124.5 R705.2 R718.2 R720.2 R725.2 R728.2 R729.2 U100.13 U100.14
+3VALWP: PC101.1 PJP100.1 PJP102.1 PL101.1 PR100.1
+5V_ALW: C675.1 C676.1 C715.1 C719.1 C723.1 C998.1 C1004.1 C1525.1 C1526.1 C1540.1 C1541.1 JBTB1.18 JLED2.1 JLVDS1.1 PC213.1 PC308.1 PC724.1 PC725.1 PJP101.2 PJP103.2 PJP609.2 PR14.1 PR203.1 PR520.2 PR530.2 PR635.2 PR645.2 PR723.2 PR843.2 PU1.5 PU200.12 PU300.7 PU701.8 Q75.3 Q79.3 Q80.3 Q82.3 Q86.3 R752.1 R816.2 R957.2 R1614.2 R1629.1 U2.5 U48.2 U48.3 U49.2 U49.3 U91.2 U91.3 U93.2 U93.3 U100.4 U101.4 U102.4 U103.4 U104.4 U105.1 U105.2 U105.4 U105.6 U105.7
+5V_ALW2: PC118.1 PU100.13
+5V_HDD: C395.1 C396.1 JSATA1.14 JSATA1.15 JSATA1.16 PJP3.1 R506.1
+5V_HDMI_DDC: D2.1 R67.2 R69.1 R70.1
+5V_MOD: C397.1 C398.1 C423.1 JSATA2.9 JSATA2.10 JSATA2.25 U105.8 U105.9
+5V_RUN: C7.1 C30.1 C52.1 C365.1 C369.1 C758.1 C761.1 C1001.1 D1.1 D2.2 JBTB1.28 JBTB1.30 JFAN1.1 JKB1.5 JUSH1.7 L77.2 PJP3.2 PJP81.1 PR501.2 PR641.2 R67.1 R845.1 R846.1 R851.1 R852.1 U6.16 U21.5 U24.5 U89.1 U105.13 U105.14
+5V_USB_CHG_PWR: C651.1 C654.1 JUSB1.1 U48.6 U48.7 U48.8
+5V_USB_PWR2_3: C1523.1 C1524.1 C1539.1 JUSB2.1 JUSB3.1 U91.6 U91.7 U91.8 U93.6 U93.7 U93.8
+5V_USB_PWR4: C667.1 C668.1 JUSB4.1 U49.6 U49.7 U49.8
+5VALWP: PC102.1 PJP101.1 PJP103.1 PL102.2 PR101.1 PU100.14
+AVCC33: C106.1 C107.1 C108.1 R3882.1 U27.5
+DVCC33: C113.1 C114.1 C115.1 C116.1 C117.1 R3881.1 U27.18 U27.22
+DVDD_CORE: C954.1 U74.1
+VCC_CORE: JCPU1.AA26 JCPU1.AA28 JCPU1.AA30 JCPU1.AA32 JCPU1.AA34 JCPU1.AB25 JCPU1.AB26 JCPU1.AB27 JCPU1.AB28 JCPU1.AB29 JCPU1.AB30 JCPU1.AB31 JCPU1.AB32 JCPU1.AB33 JCPU1.AB34 JCPU1.AB35 JCPU1.AC26 JCPU1.AC28 JCPU1.AC30 JCPU1.AC32 JCPU1.AC34 JCPU1.AD25 JCPU1.AD26 JCPU1.AD27 JCPU1.AD28 JCPU1.AD29 JCPU1.AD30 JCPU1.AD31 JCPU1.AD32 JCPU1.AD33 JCPU1.AD34 JCPU1.AD35 JCPU1.AE26 JCPU1.AE28 JCPU1.AE30 JCPU1.AE32 JCPU1.AE34 JCPU1.AF25 JCPU1.AF26 JCPU1.AF27 JCPU1.AF28 JCPU1.AF29 JCPU1.AF30 JCPU1.AF31 JCPU1.AF32 JCPU1.AF33 JCPU1.AF34 JCPU1.AF35 JCPU1.AG26 JCPU1.AG28 JCPU1.AG30 JCPU1.AG32 JCPU1.AG34 JCPU1.AH25 JCPU1.AH26 JCPU1.AH27 JCPU1.AH28 JCPU1.AH29 JCPU1.AH30 JCPU1.AH31 JCPU1.AH32 JCPU1.AH33 JCPU1.AH34 JCPU1.AH35 JCPU1.AJ25 JCPU1.AJ26 JCPU1.AJ27 JCPU1.AJ28 JCPU1.AJ29 JCPU1.AJ30 JCPU1.AJ31 JCPU1.AJ32 JCPU1.AJ33 JCPU1.AJ34 JCPU1.AJ35 JCPU1.F25 JCPU1.G25 JCPU1.H25 JCPU1.J25 JCPU1.K25 JCPU1.K26 JCPU1.L25 JCPU1.M25 JCPU1.N25 JCPU1.P25 JCPU1.R25 JCPU1.T25 JCPU1.U25 JCPU1.U26 JCPU1.V25 JCPU1.V26 JCPU1.W26 JCPU1.W27 JCPU1.Y25 JCPU1.Y26 JCPU1.Y27 JCPU1.Y28 JCPU1.Y29 JCPU1.Y30 JCPU1.Y31 JCPU1.Y32 JCPU1.Y33 JCPU1.Y34 JCPU1.Y35 PC900.1 PC901.1 PC902.1 PC903.1 PC904.1 PC905.1 PC906.1 PC907.1 PC908.1 PC909.1 PC910.1 PC911.1 PC912.1 PC913.1 PC914.1 PC915.1 PC916.1 PC917.1 PC918.1 PC919.1 PC920.1 PC921.1 PC922.1 PC923.1 PC924.1 PC925.1 PC926.1 PC935.1 PC936.1 PC937.1 PC938.1 PC939.1 PC940.1 PC941.1 PC942.1 PC943.1 PL501.1 PL502.1 PL503.1 RC91.1
+VCCADAC: CH18.1 CH19.1 CH20.1 LH1.2 UH1.P45
+VCCIO2PCH: CC137.1 CH60.1 CH61.1 CH62.1 RC105.1 RC106.2 UH1.AJ12 UH1.AJ14
+VCCIO2PCH_R: JCPU1.A23 RC106.1
+VCCIO_OUT: CC17.1 CC18.1 JCPU1.AN35 JXDP1.43 JXDP1.44 PC548.2 PR500.2 PR503.2 PR504.2 R55.1 RC28.1 RC29.1 RC74.2 RC86.1 RC87.1 RC90.1 RV78.1
+VCCST: CC47.1 CC48.1 JCPU1.AK31 RC99.1
+VDD_MEM15_REFDA: CV275.1 RV145.2 RV146.1 UV1.L18
+VDD_MEM15_REFDB: CV279.1 RV152.1 RV155.2 UV1.Y12
+VDD_MEM15_REFSA: CV274.1 RV147.1 RV148.2 UV1.L20
+VDD_MEM15_REFSB: CV278.1 RV153.2 RV154.1 UV1.AA12
+VDDA_AVDD: C955.1 C957.1 L77.1 U74.27
+VDDA_AVDD2: C956.1 C968.1 PJP80.1 U74.38
+VDDA_PVDD: C958.1 C959.1 C960.1 C961.1 PJP81.2 U74.39 U74.45
+VDDC_CT: CV54.1 CV55.1 CV56.1 LV19.2 UV1.AF26 UV1.AF27 UV1.AG26 UV1.AG27
