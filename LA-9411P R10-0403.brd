# Allegro board LA-9411P R10-0403.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
PLTRST_USH#: length 197.3
  TOP w0.102: RH109.1 185.04,68.57 183.93,68.57 182.8,67.44 v1(182.8,66.09) 182.8,65.39 184.04,64.15 v2(184.43,64.15) ; JUSH1.6 264.51,86.57 265.12,87.17 268,87.17 268.5,86.68 268.5,84.7 v2(267.93,84.12)
  IN4 w0.102: v2(184.43,64.15) 183.99,63.72 183.99,51.08 191.44,43.64 191.44,40.33 214.88,16.89 222.66,16.89 223.25,17.49 229.51,17.49 230.07,18.05 230.78,18.05 231.88,16.95 257.52,16.95 265.8,25.22 267.72,25.22 270.1,27.6 270.1,40.65 273.66,44.21 273.66,46.34 274.05,46.74 274.05,48.6 273.68,48.97 273.68,50.62 273.16,51.13 273.16,60.31 269.78,63.69 269.25,63.69 268.18,64.76 268.18,67.23 268.89,67.94 268.89,69.18 268.69,69.38 268.67,69.38 268.31,69.74 268.31,69.76 268.31,75.28 267.78,75.81 267.78,83.59 267.93,83.74 v2(267.93,84.12)
PM_APWROK: length 168.5
  TOP w0.102: v2(209.24,53.62) 208.97,53.35 208.97,51.71 v1(209.23,51.46) ; U51.A9 293.39,114.16 v2(293.62,114.39)
  IN1 w0.102: v2(209.24,53.62) 209.24,53.4 206.23,50.39 206.23,48.92 207.79,47.36 208.21,47.36 208.94,48.08 216.85,48.08 217.33,48.57 217.33,49.76 220.61,53.03 227.8,53.03 228.34,52.49 v2(228.34,52.5) ; v2(252.61,61.9) v2(247.42,61.9)
  IN2 w0.127: v2(251.34,110.85) 251.72,110.85 253.28,112.41 258.07,112.41 258.45,112.41 259.97,113.93 274.46,113.93 274.63,114.11 276.86,114.11 278.09,112.88 278.79,112.88 279.52,113.61 282.78,113.61 283.07,113.32 284.78,113.32 284.94,113.17 285.65,113.17 287.55,115.07 291.96,115.07 292.65,114.39 v2(293.62,114.39) ; v2(231.52,56.42) 230.88,55.78 230.88,54.8 231.62,54.06 233.9,54.06 235.61,55.77 238.92,55.77 239.78,56.63 240.09,56.63 241.49,58.03 241.49,58.38 241.02,58.85 241.02,60.05 242.87,61.9 v2(247.42,61.9)
  BOTTOM w0.102: v2(231.52,56.42) 230.82,56.42 228.34,53.94 v2(228.34,52.5) ; RH87.1 209.74,53.12 v2(209.24,53.62) 209.19,53.67 209.19,54.53 UH2.2 ; v2(251.34,110.85) 251.06,110.57 251.06,107.02 251.06,106.83 251.06,106.83 251.06,106.72 251.52,106.26 251.52,98.66 250.25,97.39 250.25,86.94 252.24,84.94 252.24,62.27 v2(252.61,61.9)
PM_APWROK_R: length 23.7
  TOP w0.102: v2(208.78,54.08) v3(209.67,54.08)
  IN4 w0.089: 207.31,57.86 207.31,60.17 206.22,61.26 206.22,63.46 207.09,64.33 207.09,65.06 206.33,65.82 206.33,66.36 207.12,67.14 207.12,67.83 206.48,68.47 205.6,68.47 204.41,67.28 v2(203.82,67.28)
  IN4 w0.102: 207.31,57.86 207.31,57.05 208.64,55.71 208.64,54.22 v2(208.78,54.08)
  BOTTOM w0.089: v2(203.82,67.28) 203.64,67.46 UH1.AB7
  BOTTOM w0.102: RH87.2 208.48,52.71 UH2.4 208.48,53.78 v2(208.78,54.08)
PM_DRAM_PWRGD: length 99.2
  TOP w0.102: RC12.2 RC4.2 138.87,66.26 139.3,65.82 139.3,64.08 139.51,63.88 140.57,63.88 140.88,63.58 140.88,61.86 140.01,61 140.01,59.79 RC13.2 138.77,58.55 138.77,56.24 140.32,54.68 v2(142.15,54.68) ; 204.07,50.53 205.89,52.35 v2(205.89,52.91) ; 204.07,50.53 203.74,50.2 201.54,50.2 197.69,46.35 196.49,46.35 v2(196.15,46.01) ; 204.07,50.53 v1(204.07,50.56)
  IN1 w0.102: v2(184.45,61.34) 184.45,61.11 184.86,60.71 184.86,57.86 190.64,52.09 190.64,50.9 195.52,46.01 v2(196.15,46.01)
  BOTTOM w0.102: v2(184.45,61.34) 183.98,60.87 179.64,60.87 174.98,56.22 143.68,56.22 v2(142.15,54.68) ; v2(205.89,52.91) 205.89,54.65 RH104.1
PM_DRAM_PWRGD_CPU: length 38.8
  TOP w0.102: RC10.1 142.35,63.06 142.79,62.61 v2(143.44,62.61) v3(143.44,61.85) 141.98,60.39 QC5.3
  IN3 w0.089: 143.24,77.36 143.24,87.25 143.45,87.46 149.28,87.46 v2(149.73,87.92)
  IN3 w0.127: v2(143.44,62.61) 142.48,63.58 142.48,72.02 143.24,72.78 143.24,77.36
  BOTTOM w0.089: v2(149.73,87.92) 150.2,88.39 JCPU1.AC10
PM_DRAM_PWRGD_R: length 7.6
  BOTTOM w0.089: UH1.H3 205.96,61.92 205.96,61.33 205.8,61.18 205.8,60.49 205.29,59.98 205.29,59.88
  BOTTOM w0.102: RH104.2 206.95,56.72 206.26,57.42 206.26,58.31 205.56,59 205.29,59.27 205.29,59.88
PM_LANPHY_ENABLE: length 255.1
  TOP w0.102: v1(219.31,55.38) 218.96,55.03 v2(218.87,55.03)
  IN2 w0.127: v2(256.37,165.75) 257.28,166.66 270.16,166.66 271.69,168.19 273.92,168.19 276.08,166.03 277.12,166.03 277.64,166.55 277.64,167.68 280.98,171.02 284.23,171.02 289.5,176.29 293.43,176.29 295.74,173.98 309.19,173.98 309.55,173.61 319.43,173.61 319.76,173.28 319.76,173.24 319.78,173.24 v2(319.78,173.18)
  IN3 w0.089: 210.04,60.23 209.77,60.49 209.77,63.27 208.77,64.28 v2(208.77,64.93)
  IN3 w0.127: v2(256.37,165.75) 258.73,163.39 258.73,144.5 260.21,143.02 260.21,137.77 257.65,135.21 257.65,134.9 257.98,134.57 258.34,134.57 259.57,133.34 259.57,131.48 258.85,130.76 258.85,113.57 256.24,110.96 256.24,103.78 246.53,94.06 246.53,86.37 243.41,83.25 243.41,74.26 242.24,73.09 242.24,60.26 235.43,53.46 231.05,53.46 229.99,54.51 220.23,54.51 219.54,55.21 219.03,55.21 218.87,55.04 v2(218.87,55.03) 218.71,55.19 218.7,55.19 218.35,55.53 218.34,55.53 216.87,57 216.87,57.71 216.2,58.38 214.63,58.38 214.49,58.52 211.63,58.52 210.04,60.11 210.04,60.23
  BOTTOM w0.089: UH1.K13 208.77,65.45 v2(208.77,64.93)
  BOTTOM w0.102: R555.1 318.24,192.34 318.24,191.92 317.7,191.38 317.7,190.99 318.08,190.61 318.08,189.3 318.4,188.98 318.4,188 317.94,187.54 317.94,185.55 317.94,185.55 317.94,182.53 320.14,180.33 320.14,173.54 v2(319.78,173.18) ; RH217.1 218.71,55.19 v2(218.87,55.03)
POWER_SW#_MB: length 160.8
  TOP w0.102: R811.2 C721.1 297.42,103.85 297.96,104.39 v3(299.6,104.39) 306.08,104.39 314.08,112.39 314.08,115.16 v2(313.3,115.94) 313.3,115.94 JAPS1.11 ; v2(347.18,201.29) 347.09,201.38 344.56,201.38 D23.3 342.54,203.41 SW1.4 340.45,204.61 340.33,204.72 339.42,204.72 339.3,204.61 SW1.2
  IN3 w0.127: v2(347.18,201.29) 347.32,201.29 349.07,199.54 349.07,184.3 347.98,183.2 338.18,183.2 330.82,175.83 327.69,175.83 327.31,175.45 327.31,173 328.65,171.66 328.65,171.6 328.79,171.46 328.79,169.43 328.6,169.24 328.6,169.19 328.11,168.71 328.11,155.77 327.36,155.02 327.36,138.46 326.16,137.25 326.16,123.06 324.4,121.31 318.85,121.31 313.48,115.94 v2(313.3,115.94)
POWER_SW_IN#: length 10.5
  TOP w0.102: v2(296.21,106.99) R811.1 295.35,106.2 R810.2 C722.1 ; v2(290.86,110.12) 290.82,110.12 290.97,109.98 U51.B67
  BOTTOM w0.102: v2(290.86,110.12) 290.82,110.12 291.38,109.56 v1(292.11,109.56) 292.79,109.56 293.2,109.16 294.5,109.16 296.21,107.44 v2(296.21,106.99)
PROCHOT#_EC: length 235.6
  TOP w0.102: U51.A46 279.9,111.16 R812.2 R1179.2 278.39,110.54 278.39,110.27 277.63,109.51 275.95,109.51 274.79,110.68 267.85,110.68 267.2,110.03 264.98,110.03 264.1,109.16 254.15,109.16 253.51,108.52 250.86,108.52 250.38,108.04 249.44,108.04 v2(247.42,110.06) ; v2(109.71,154.7) 109.71,154.95 109.98,155.22 Q47.2 111.88,155.22 112.3,155.64 R1180.1 ; v2(128.28,125.08) v1(124.8,125.08) 120.23,125.08 v2(118.22,123.08)
  IN2 w0.127: v2(220.24,102.59) 220.24,102.72 222.07,104.55 228.09,104.55 229.62,106.08 229.62,108.36 232.79,111.52 232.79,113.11 233.24,113.56 234.47,113.56 235.47,112.56 237.73,112.56 237.84,112.46 241.5,112.46 242.72,111.23 246.21,111.23 247.39,110.06 v2(247.42,110.06) ; v2(165.81,124.19) 166.04,124.19 166.63,124.79 176.87,124.79 177.91,123.75 v2(177.95,123.75)
  IN4 w0.102: v2(118.22,123.08) 112.63,128.66 112.63,138.95 108.57,143.01 108.57,148.73 109.71,149.87 v2(109.71,154.7) ; v2(165.81,124.19) 164.74,124.19 163.57,123.02 159.84,123.02 159.52,123.34 151.76,123.34 150.77,122.35 146.03,122.35 146,122.31 144.84,122.31 144.29,122.86 143.73,122.86 143.53,123.06 142.36,123.06 141.6,123.82 139.96,123.82 137.22,126.57 133.47,126.57 132.66,125.76 128.76,125.76 128.28,125.27 v2(128.28,125.08) ; v2(177.95,123.75) 177.95,123.53 176.64,122.22 176.64,116.7 178.34,115 183.19,115 185.26,112.93 192.06,112.93 194.36,110.63 199.94,110.63 205.63,104.94 214.73,104.94 217.22,102.45 220.1,102.45 v2(220.24,102.59)
PROCHOT_AD_POTC: length 99.6
  TOP w0.254: 95.51,160.3 96.37,160.3 96.96,159.71 PR724.1 99.93,159.14 100.12,159.33 v2(100.12,161.12) ; 95.51,160.3 94.74,159.53 PQ707.3 ; 95.51,160.3 95.51,160.87 95.16,161.23 93.66,161.23 93.44,161.01 PQ707.6 ; v4(164.83,178.96) 164.74,179.04 163.44,179.04 163.13,178.73 PR845.2
  IN1 w0.254: v2(100.31,167.65) 100.47,167.81 117.58,167.81 118.26,168.49 121.76,168.49 124.02,170.75 129.85,170.75 131.68,168.92 131.68,168.39 133.65,166.42 137.94,166.42 140.08,168.55 144.7,168.55 146.52,166.74 148.24,166.74 152.49,170.99 154.99,170.99 155.63,171.64 v2(155.63,172.06)
  IN3 w0.254: v4(164.83,178.96) 164.7,179.08 163.21,179.08 159.91,175.78 159.91,175.33 159.38,174.8 157.86,174.8 155.63,172.58 v2(155.63,172.06)
  IN4 w0.254: v2(100.12,161.12) 100.06,161.19 100.06,167.4 v2(100.31,167.65)
  BOTTOM w0.102: v1(99.42,168.03) 99.8,167.65 v2(100.31,167.65)
  BOTTOM w0.254: v2(155.63,172.06) 155.63,172.2 PR879.2
PROCHOT_AD_POTC_C2: length 12
  TOP w0.203: v2(162.37,177.04) 162.4,177.02 PU808.19
  TOP w0.254: PR845.1 162.21,177.2 v2(162.37,177.04) ; v2(161.01,176.2) 160.83,176.2 160.03,175.39 160.03,173.28 v1(159.05,172.3) v2(157.74,172.3)
  IN2 w0.254: v2(162.37,177.04) 161.53,176.2 v2(161.01,176.2)
  BOTTOM w0.254: PQ910.2 157.95,172.1 v2(157.74,172.3) 157.73,172.29 157.59,172.29 157.16,171.86 PR880.2
PROCHOT_GATE: length 344.6
  TOP w0.102: v2(96.9,164.12) 95.27,162.5 92.74,162.5 91.85,161.61 91.85,160.27 91.55,159.97 91.55,159.18 91.66,159.07 PU704.2 ; v1(262.36,44.34) 262.61,44.58 R761.2 v2(263.63,45.28) 263.69,45.28 264.41,46 264.41,46.25 264.94,46.78 U46.A50
  TOP w0.254: PR861.2 169.01,178.61 170.26,178.61 170.41,178.76 v2(170.41,178.76)
  IN3 w0.127: v2(263.63,45.28) 263.62,45.26 262.11,45.26 259.11,48.26 259.11,51.21 258.59,51.73 258.59,53.16 257.93,53.82 257.93,55.71 258.19,55.96 258.19,60.73 258.78,61.33 258.78,63.63 261.07,65.92 261.07,67.59 261.84,68.36 261.84,76.17 262.93,77.26 262.93,96.91 263.89,97.86 263.89,119.57 263.18,120.29 263.18,129.63 262.89,129.92 262.89,142.32 260.8,144.4 260.8,148.53 259.88,149.46 259.88,165.59 258.88,166.58 258.88,172.76 258.23,173.41 253.79,173.41 252.95,174.24 247.89,174.24 246.82,175.31 238.84,175.31 237.98,174.45 224.26,174.45 224.16,174.55 222.63,174.55 221.04,172.96 221.04,170.15 220.35,169.47 217.97,169.47 217.18,170.25 193.17,170.25 193.01,170.41 188.34,170.41 186.36,168.43 181.35,168.43 180.41,169.37 178.63,169.37 178.08,169.91 176.53,169.91 176.05,169.43 175.68,169.43 175.2,169.91 174.09,169.91 172.92,171.08 170.18,171.08 v2(170.14,171.12) 169.91,171.12 169.47,170.68 169.47,169.17 165.06,164.76 163.75,164.76 163.28,164.29 161.09,164.29 157.44,160.64 149.29,160.64 148.87,160.22 147.98,160.22 147.68,159.92 140.87,159.92 140.28,159.33 137.61,159.33 137.01,159.93 135.73,159.93 135.4,159.6 128.86,159.6 127.96,158.7 127.3,158.7 126.97,158.37 122.3,158.37 122.22,158.44 120.89,158.44 120.18,159.16 118.58,159.16 117.95,158.53 111.15,158.53 110.49,157.87 109.69,157.87 108.78,158.78 108.78,164.34 108.32,164.81 106.72,164.81 106.1,164.19 96.96,164.19 v2(96.9,164.12)
  IN4 w0.102: v2(170.41,178.76) 170.41,178.65 170.26,178.5 170.26,177.28 168.77,175.78 168.77,172.68 169.02,172.43 169.71,172.43 170.14,171.99 v2(170.14,171.12)
PROCHOT_GATE_C2: length 5.7
  TOP w0.102: v1(166.19,177.94) PR861.1
  TOP w0.203: PU808.14 165.28,174.82 165.5,175.04 165.5,176.02 PR861.1
PS2_CLK_TS: length 108.4
  TOP w0.102: v2(255.81,93.97) 255.65,94.13 255.65,95.91 255.76,96.03 JTP1.7 ; v2(316.97,137.62) 316.97,137.62 JKB1.2
  IN2 w0.127: v2(265.46,137.59) 267.86,139.99 271.56,139.99 272.14,139.41 276.81,139.41 277.66,140.26 278.95,140.26 280.45,141.76 287.19,141.76 288.34,140.6 303.54,140.6 304.97,139.17 308.58,139.17 308.89,139.48 309.66,139.48 309.82,139.33 312.44,139.33 312.59,139.48 313.06,139.48 313.65,139.48 315.52,137.62 v2(316.97,137.62)
  IN4 w0.102: v2(265.46,137.59) 265.82,137.24 265.82,132 265.17,131.36 265.17,121.34 265.4,121.11 265.4,113.92 265.03,113.55 265.03,109.84 264.28,109.09 264.28,108.33 264.14,108.19 264.14,107.85 264.14,104.24 263.51,103.61 263.51,102.03 259.94,98.46 259.94,97.98 255.93,93.97 v2(255.81,93.97)
PS2_DAT_TS: length 104.7
  TOP w0.102: JKB1.3 316.94,136.62 v2(317,136.55) ; v2(260.93,133.43) v1(260.93,132.88) ; v2(255.4,96.79) 255.66,96.53 JTP1.6
  IN2 w0.127: v2(317,136.55) 316.45,137.1 315.32,137.1 313.44,138.98 312.8,138.98 312.65,138.82 309.6,138.82 309.45,138.98 309.11,138.98 308.79,138.66 304.76,138.66 303.33,140.09 288.13,140.09 286.97,141.25 280.68,141.25 279.18,139.75 277.87,139.75 277.02,138.9 271.46,138.9 267.29,134.73 265.21,134.73 265.12,134.65 263.65,134.65 262.16,133.16 261.2,133.16 v2(260.93,133.43)
  IN3 w0.127: v2(260.93,133.43) 260.93,129.1 261.64,128.39 261.64,121.09 260.42,119.88 260.42,113.16 260.03,112.76 260.03,108.47 259.43,107.87 259.43,102.77 255.4,98.73 v2(255.4,96.79)
PS_0: length 8.9
  TOP w0.102: v1(234.97,116.53) 235.03,116.47 RV244.2 RV243.1 CV357.1 236.13,119.3 235.57,119.86 233.65,119.86 v2(233.45,120.07)
  BOTTOM w0.102: v2(233.45,120.07) 233.45,120.55 233.26,120.74 232.59,120.74 UV1.AM34
PS_1: length 14.2
  TOP w0.102: CV342.1 RV237.2 RV238.1 235.11,126.09 234.51,126.68 233.99,126.68 233.88,126.57 233.88,125.99 233.52,125.63 232.43,125.63 231.28,124.47 230.65,124.47 230.56,124.38 230.56,124.04 230.23,123.71 230.02,123.71 v1(229.69,123.38) 229.69,123.28 229.37,122.96 228.82,122.96 228.32,122.45 227.76,122.45 227.5,122.71 226.79,122.71 v2(226.6,122.52)
  BOTTOM w0.254: UV1.AD31 226.09,122.8 226.37,122.52 v2(226.6,122.52)
PS_2: length 12.1
  TOP w0.102: v2(227.94,123.1) 227.94,123.15 228.28,123.49 228.28,124.12 v1(228.74,124.57) 228.86,124.7 231.16,124.7 232.29,125.83 233.43,125.83 233.68,126.07 233.68,126.66 233.9,126.89 CV340.1 RV240.1 RV239.2
  BOTTOM w0.102: v2(227.94,123.1) 227.95,123.09 228.01,123.09 228.27,122.82 228.42,122.82 UV1.AG31
PS_3: length 7.8
  TOP w0.102: v2(225.48,120.88) 225.48,120.1 225.57,120.01 225.57,119.68 225.55,119.65 225.55,119.2 225.87,118.88 v1(225.87,118.64) 225.87,117.82 225.92,117.77 RV241.2 225,115.51 RV242.1 CV341.1
  BOTTOM w0.102: UV1.AD33 225.83,121.2 225.51,120.88 v2(225.48,120.88)
PS_ID: length 240.3
  TOP w0.102: v2(286.41,107.76) 286.56,107.92 286.56,108.08 286.72,108.23 U51.A55
  IN3 w0.127: v2(149.11,163.98) 149.16,164.02 153.73,164.02 156.9,167.2 156.9,170.34 159.02,172.45 159.85,172.45 160.85,173.46 164.05,173.46 165.69,175.09 167.14,175.09 168.05,176 170.14,176 171.77,177.62 172.65,177.62 173.52,178.5 174.38,178.5 175.09,177.79 179.07,177.79 179.76,177.09 180.37,177.09 180.64,177.36 184.56,177.36 185.27,178.07 185.86,178.07 186,177.93 188.01,177.93 189.05,178.97 189.65,178.97 190,179.32 192.66,179.32 193.35,180.01 195.79,180.01 196.11,180.33 205.48,180.33 207.02,178.79 210.65,178.79 213.27,181.41 216.66,181.41 223.05,187.79 237.66,187.79 238.95,186.51 245.19,186.51 245.38,186.7 248.21,186.7 248.44,186.47 252.56,186.47 252.79,186.7 255.96,186.7 257.11,185.56 264.18,185.56 271.85,177.89 271.85,176.48 272.82,175.51 272.82,174.82 272.16,174.16 272.16,172.16 271.42,171.42 271.42,167.88 271.09,167.55 271.09,149.37 273.22,147.24 273.22,146.94 275.99,144.17 275.99,133.43 275.2,132.64 275.2,117 275.45,116.76 275.45,111.96 275.83,111.58 278,111.58 280.18,109.39 280.18,108.44 281.9,106.71 285.69,106.71 285.95,106.97 285.95,107.17 285.95,107.18 285.95,107.47 286.25,107.76 v2(286.41,107.76)
  IN4 w0.102: v2(149.11,163.98) 148.85,164.24 148.85,171.73 151.61,174.49 v2(151.61,174.93)
  BOTTOM w0.102: v1(286.98,107.15) 286.98,107.26 286.47,107.76 v2(286.41,107.76)
  BOTTOM w0.254: v2(151.61,174.93) 151.69,175 PU1.4
PSATA_PRX_DTX_N0_C: length 97.6
  TOP w0.102: v2(114.71,57.84) 113.76,57.84 113.72,57.81 113.08,57.81 C385.2
  BOTTOM w0.089: UH1.BC8 197.62,74.1 197.3,74.42 196.57,74.42 196.45,74.54 196.44,74.54 196.21,74.78 195.45,74.78 195.44,74.77 195.42,74.77
  BOTTOM w0.102: v2(114.71,57.84) 113.96,57.84 113.73,57.61 113.73,56.78 114.16,56.35 115.3,56.35 115.77,56.82 172.46,56.82 185.84,70.21 185.98,70.21 v4(187.94,72.17) 189.73,73.96 189.73,74.16 192.21,76.64 192.62,76.64 194.48,74.77 195.42,74.77
PSATA_PRX_DTX_P0_C: length 97.6
  TOP w0.102: v2(114.71,57.11) 114.71,57.29 114.52,57.49 114.4,57.49 114.26,57.63 113.85,57.63 113.81,57.59 112.64,57.59 112.58,57.53 112.58,57.29 C386.2
  BOTTOM w0.089: UH1.BE8 196.99,74.74 196.87,74.62 196.65,74.62 196.53,74.74 196.29,74.97 195.45,74.97 195.44,74.98 195.42,74.98
  BOTTOM w0.102: v2(114.71,57.11) 114.71,57.29 114.51,57.49 114.37,57.49 114.23,57.63 114.04,57.63 113.94,57.53 113.94,56.87 114.24,56.56 115.21,56.56 115.69,57.04 172.37,57.04 185.75,70.42 185.89,70.42 187.59,72.12 187.59,72.14 187.98,72.53 188,72.53 189.52,74.05 189.52,74.25 192.12,76.85 192.71,76.85 194.57,74.98 195.42,74.98
PSATA_PTX_DRX_N0_C: length 95.3
  IN4 w0.089: 197.39,71.36 197.4,71.37 197.4,71.38 197.83,71.8 197.83,72.07 197.95,72.19 v2(198.19,72.19)
  IN4 w0.102: 197.39,71.36 196.91,70.88 196.35,70.88 195.19,72.03 194.39,72.03
  IN4 w0.114: 194.39,72.03 194.06,72.03 190.72,75.36 190.72,75.44 190.43,75.74 v2(190.16,75.74)
  BOTTOM w0.089: v2(198.19,72.19) 198.19,72.43 198.66,72.9 UH1.AW8
  BOTTOM w0.102: C384.2 116.45,61.16 116.7,61.16 118.4,59.47 121.47,59.47 122.85,58.09 172.56,58.09 185.39,70.93 185.39,71.52 189.67,75.8 189.67,75.95 189.76,76.04 190.12,76.04 190.16,76 v2(190.16,75.74)
PSATA_PTX_DRX_P0_C: length 95.2
  IN4 w0.089: v2(197.78,72.65) 197.78,72.31 197.63,72.16 197.63,71.89 197.27,71.53 197.26,71.53 197.24,71.51
  IN4 w0.102: 197.24,71.51 196.82,71.09 196.44,71.09 195.28,72.25 194.41,72.25
  IN4 w0.114: 194.41,72.25 194.16,72.25 190.95,75.46 190.95,75.54 190.57,75.92 v2(190.57,76.15)
  BOTTOM w0.089: UH1.AY8 198.3,73.17 v2(197.78,72.65)
  BOTTOM w0.102: v2(190.57,76.15) 190.31,76.15 190.21,76.25 189.68,76.25 189.46,76.03 189.46,75.89 185.18,71.61 185.18,71.02 172.47,58.31 122.94,58.31 121.56,59.68 118.48,59.68 116.79,61.37 116.62,61.37 C383.2
PSID_DISABLE#: length 272
  TOP w0.102: U46.A37 262.31,54.39 261.87,54.83 v2(261.87,54.86) ; v2(146.25,171.21) 146.25,171.75 v1(146.24,171.77)
  IN3 w0.127: v2(261.87,54.86) 261.88,54.86 263.13,56.12 263.13,58.4 262.94,58.59 262.94,59.2 262.16,59.98 262.16,62.51 265.61,65.96 265.61,72.16 266.29,72.84 266.29,74.82 267.22,75.75 267.22,92.71 267.46,92.95 267.46,95.13 267.97,95.63 267.97,96.92 267.46,97.43 267.46,104.29 268.02,104.85 268.02,124.73 267.42,125.33 267.42,128.16 267.66,128.4 267.66,138.57 267.13,139.1 267.13,140.74 265.92,141.95 265.92,143.46 263.72,145.66 263.72,149.75 262.8,150.67 262.8,173.64 262.61,173.83 262.61,175.45 262.11,175.95 261.3,175.95 258.61,178.63 251.32,178.63 250.69,179.26 246.81,179.26 246.11,179.96 237.84,179.96 235.17,177.29 233,177.29 225.76,177.29 225.37,177.29 225.06,177.61 221.52,177.61 220.14,176.23 218.03,174.12 200.2,174.12 199.86,174.46 196.52,174.46 195.89,173.82 188.32,173.82 187.49,172.99 184.91,172.99 184.48,172.55 183.9,172.55 183.31,173.15 182.57,173.15 181.76,173.96 179.81,173.96 179.65,173.8 177.63,173.8 177.51,173.67 176.04,173.67 176,173.71 169.46,173.71 166.7,170.95 166.7,170.59 165.44,169.33 164.45,169.33 163.13,168.01 163.13,166.95 161.78,165.61 159.9,165.61 156.81,162.52 156.41,162.52 155.33,161.44 148.71,161.44 v2(148.42,161.15)
  IN4 w0.254: v2(148.42,161.15) 148.15,161.42 148.15,164.57 148.19,164.61 148.19,168.63 146.97,169.85 146.97,170.55 146.31,171.21 v2(146.25,171.21)
  BOTTOM w0.254: PR16.2 149.08,172.34 148.56,171.82 146.82,171.82 146.25,171.25 v2(146.25,171.21)
PWM3: length 48
  TOP w0.102: v2(139.43,157.24) v1(140.09,157.24)
  TOP w0.254: v4(162.15,155.78) 162.15,155.77 161.86,155.47 161.86,155.19 161.36,154.69 PU501.3
  IN1 w0.254: v4(162.15,155.78) 162.02,155.9 161.89,155.9 161.32,156.48 160,156.48 158.54,157.94 156.03,157.94 155.01,156.92 152.07,156.92 151.6,157.38 144.53,157.38 144.15,157.77 139.96,157.77 v2(139.43,157.24)
  BOTTOM w0.203: PR523.2 125.47,153.24 124.36,153.24 123.83,153.77 123.33,153.77 122.88,154.23 PU500.22
  BOTTOM w0.254: PR523.2 126.07,152.67 126.58,152.16 130.92,152.16 131.55,152.79 136.38,152.79 139.43,155.84 v2(139.43,157.24)
PWR_SRC_ON: length 5.8
  BOTTOM w0.102: R422.2 177.76,143.29 v1(177.16,143.29)
  BOTTOM w0.254: R422.2 C297.2 R423.1 180.73,145.91 Q21.3
PWRSHARE_EN#: length 41.5
  TOP w0.102: v2(345.96,217.98) 343.77,217.98 343.25,217.46 327.12,217.46 v1(326.67,217.01) 325.87,216.21 323.92,216.21 323.02,215.32 317.61,215.32 v2(317.44,215.48)
  BOTTOM w0.102: R816.1 317.71,215.48 v2(317.44,215.48) 316.78,214.82 Q48.1 ; v2(345.96,217.98) 345.56,218.38 345.56,220.04 345.97,220.45 351.15,220.45 351.74,221.03 U48.4
PX_EN: length 12
  BOTTOM w0.102: v1(241.77,132.14) 241.77,131.91 241.07,131.22 239.87,131.22 239.68,131.41 RV48.2 237.82,131.71 237.09,130.98 236.55,130.98 236.2,131.33 234.04,131.33 233.81,131.1 231.95,131.1 UV1.AL21
RASA0#: length 33.9
  TOP w0.102: v2(192.25,124.3) UV5.L3
  IN4 w0.127: v2(192.25,124.3) 191.44,123.49 191.44,120.82 192.17,120.09 199.63,120.09 199.88,119.84 204.54,119.84 204.96,120.26 206.27,120.26 209.33,123.32 209.33,124.22 210.9,125.8 210.9,127.35 211.55,127.99 213.47,127.99 213.87,128.4 v2(213.87,128.73)
  BOTTOM w0.102: UV1.K23 214.25,129.11 v2(213.87,128.73) ; v2(192.25,124.3) UV5.L3
RASA1#: length 25.6
  TOP w0.102: UV3.L3 v2(194.65,136.09)
  IN4 w0.102: 207.12,134.25 207.16,134.25 207.5,134.59 208.33,134.59 208.82,134.1 213.05,134.1 213.18,133.97 213.18,132.88 v2(213.68,132.38)
  IN4 w0.127: v2(194.65,136.09) 194.94,136.09 195.06,135.98 195.06,134 195.3,133.76 199.67,133.76 199.98,134.07 200.37,134.07 201.24,134.94 204.33,134.94 204.59,134.68 206.28,134.68 206.7,134.25 207.12,134.25
  BOTTOM w0.102: UV1.K19 214.25,132.96 v2(213.68,132.38) ; UV3.L3 v2(194.65,136.09)
RASB0#: length 34.2
  TOP w0.102: v2(205.11,164.5) UV7.L3
  IN4 w0.102: 214.45,147.11 215.2,146.36 215.2,144.96 215.72,144.44 215.72,143.64 216.91,142.46 217.21,142.46 217.5,142.17 217.5,141.12 218.13,140.49 218.93,140.49 v2(219.43,140) ; 208.96,160.65 207.59,160.65 205.93,162.32 205.93,163.06 205.51,163.47 205.51,164.1 v2(205.11,164.5)
  IN4 w0.127: 208.96,160.65 209.52,160.1 209.52,152.86 210.84,151.54 210.84,149.76 212.68,147.93 213.72,147.93 214.45,147.21 214.45,147.11
  BOTTOM w0.102: v2(205.11,164.5) UV7.L3 ; v2(219.43,140) UV1.T10
RASB1#: length 32.6
  TOP w0.102: UV9.L3 225.73,164.9 v2(226.13,164.49)
  IN4 w0.102: 224.01,147.21 224.01,146.27 222.72,144.97 222.72,144.8 221.22,143.31 221.22,141.09 v2(221.81,140.5) ; 221.56,154.57 221.25,154.88 221.25,158.23 220.93,158.55 220.93,160.01 221.17,160.25 221.17,162.56 222.37,163.77 222.97,163.77 223.32,164.11 223.9,164.11 224.28,164.49 v2(226.13,164.49)
  IN4 w0.127: 224.01,147.21 224.01,152.12 221.56,154.57
  BOTTOM w0.102: UV9.L3 225.73,164.9 v2(226.13,164.49) ; UV1.Y10 222.31,140 v2(221.81,140.5)
RED_CRT: length 167.8
  TOP w0.102: JBTB1.23 53,203.54 v2(53.96,202.58) ; v2(180.13,177.51) 180.2,177.44 v1(180.2,176.77) 180.2,176.34 181.31,175.22 182.13,175.22 182.26,175.09 U6.27
  IN2 w0.127: v2(53.96,202.58) 53.96,200.8 58.02,196.74 58.02,186.91 57.48,186.37 57.48,186.02 58.02,185.47 58.02,184.68 62.53,180.17 64.64,180.17 71.64,173.18 80.29,173.18 81.54,171.92 81.68,171.92 87.74,165.86 87.74,165.39 89.77,163.36 91.03,163.36 91.73,162.66 97,162.66 97.61,163.28 99.73,163.28 100,163 101.13,163 101.68,162.46 108.22,162.46 110.45,164.69 118.13,164.69 119.03,163.79 136.25,163.79 137.59,162.45 146.47,162.45 148.26,162.45 149.36,163.55 149.64,163.55 151.66,165.57 155.77,165.57 156.47,166.27 158.72,166.27 159.69,167.23 159.7,167.23 161.62,169.15 166.26,169.15 167.65,170.54 168.8,170.54 170.56,172.29 170.56,174.23 172.65,176.33 178.95,176.33 v2(180.13,177.51)
RED_DOCK: length 7.2
  TOP w0.102: U6.26 182.66,175.2 181.06,176.8 v1(181.06,177.9) 181.06,178.24 v2(181.72,178.9)
  BOTTOM w0.102: JDOCK1.53 181.25,179.91 181.29,179.87 181.29,179.42 181.72,178.99 v2(181.72,178.9)
REGCTL_PNP10:
  vias: v1(314.21,194.63)
REM_DIODE1_N: length 440.7
  TOP w0.254: U51.B13 291.4,115.91 v2(291.31,116) ; C285.1 295.89,117.46 v2(295.93,117.42)
  IN1 w0.254: v2(291.31,116) 291.46,116.15 292.03,116.15 292.32,116.45 293.23,116.45 293.29,116.51 293.99,116.51 294.05,116.45 294.95,116.45 v2(295.93,117.42) ; v2(143.9,95.53) 143.05,95.53 142.34,96.25 142.34,96.99 141.78,97.55 136.56,97.55 133.02,94.01 126.86,94.01 120.39,87.54 120.39,66.01 120.52,65.89 120.52,59.31 120.32,59.11 120.32,56.1 120.52,55.89 120.52,40.71 118.61,38.8 118.61,33.15 119.3,32.47 119.3,26.87 119.92,26.25 119.92,21.37 122.77,18.53 158.07,18.53 158.74,17.86 161.23,17.86 161.65,17.44 169.11,17.44 169.53,17.86 186.91,17.86 192.31,23.25 194.84,23.25 196.34,24.75 212.74,24.75 214.06,23.43 240.12,23.43 254,9.55 270.24,9.55 275.45,14.76 275.45,17.34 277.38,19.28 280.01,19.28 282.27,21.54 282.28,21.54 285.66,24.92 287.02,24.92 288.12,26.02 288.12,36.42 287.72,36.82 286.12,36.82 280.88,42.05 280.88,46.49 282.37,47.98 282.37,60.71 280.03,63.05 278.32,64.76 278.32,91.53 284.84,98.06 286.18,98.06 288.21,100.09 308.43,100.09 314.78,106.43 314.78,116.51 313.48,117.8 v2(313.42,117.8)
  BOTTOM w0.254: v2(143.9,95.53) 144.06,95.69 144.38,95.69 C8.1 147.81,95.44 Q1.3 ; v2(295.93,117.42) 295.93,117.55 295.78,117.7 295.78,117.73 297.39,119.34 311.26,119.34 312.8,117.8 v2(313.42,117.8)
REM_DIODE1_P: length 442
  TOP w0.254: C285.2 295.12,117.98 v2(295.12,117.45) 295.12,117.31 294.57,116.76 294.29,116.76 293.81,116.28 293.31,116.28 293.19,116.16 U51.A13
  IN1 w0.254: v2(313.5,118.55) 313.51,118.55 315.29,116.78 315.29,106.22 308.64,99.58 288.43,99.58 286.39,97.55 285.05,97.55 278.82,91.32 278.82,64.97 280.39,63.41 282.88,60.92 282.88,47.76 281.39,46.28 281.39,42.27 286.33,37.33 287.93,37.33 288.63,36.63 288.63,25.81 287.23,24.41 285.87,24.41 282.49,21.03 282.48,21.03 280.22,18.77 277.59,18.77 275.95,17.13 275.95,14.55 270.45,9.04 253.79,9.04 239.91,22.92 213.85,22.92 212.53,24.24 196.55,24.24 195.05,22.75 192.52,22.75 187.12,17.35 169.74,17.35 169.32,16.93 161.44,16.93 161.02,17.35 158.53,17.35 157.86,18.02 122.56,18.02 119.41,21.16 119.41,26.04 118.79,26.66 118.79,32.26 118.11,32.94 118.11,39.01 120.01,40.92 120.01,55.68 119.81,55.89 119.81,59.32 120.01,59.52 120.01,65.68 119.88,65.8 119.88,87.75 126.65,94.51 132.8,94.51 136.35,98.06 141.99,98.06 142.97,97.08 142.97,96.33 143.18,96.13 v2(143.87,96.13)
  BOTTOM w0.254: Q1.2 147.22,96.15 Q1.1 145.77,96.35 C8.2 144.41,96.13 v2(143.87,96.13) ; v2(295.12,117.45) 295.12,117.55 295.27,117.7 295.27,117.94 297.18,119.85 311.58,119.85 312.87,118.55 v2(313.5,118.55)
REM_DIODE2_N: length 52.2
  TOP w0.254: v2(291.4,116.92) 291.4,116.74 291.41,116.73 291.41,116.73 291.73,116.41 U51.B14 ; v2(295.89,119.62) C283.1 ; C9.2 311.63,150.32 Q2.3 311.25,148.36 v2(311.67,147.94)
  IN1 w0.254: v2(295.89,119.62) 295.89,119.39 293.77,117.27 291.91,117.27 291.55,116.92 v2(291.4,116.92)
  IN4 w0.254: v2(305.18,120.97) 305.05,120.97 304.61,121.41 304.61,124.15 306.66,126.21 306.66,143.66 310.84,147.84 311.48,147.84 311.58,147.94 v2(311.67,147.94)
  BOTTOM w0.254: v2(295.89,119.62) 295.67,119.84 v1(295.67,120.24) 295.67,120.52 295.67,120.52 295.92,120.78 304.99,120.78 v2(305.18,120.97)
REM_DIODE2_P: length 52.7
  TOP w0.254: C9.1 311.76,151.84 Q2.1 309.95,151.19 Q2.2 309.95,149.47 v1(310.57,148.85) 310.74,148.68 310.74,148.14 311.63,147.26 v2(311.63,147.24) ; U51.A14 293.15,116.66 293.15,116.66 293.39,116.66 294.22,117.49 294.22,118.36 295.05,119.2 v2(295.05,119.6) 294.98,119.67 C283.2
  IN4 w0.254: v2(311.63,147.24) 311.54,147.33 311.05,147.33 307.17,143.45 307.17,125.92 305.18,123.93 v2(305.18,121.58)
  BOTTOM w0.254: v2(305.18,121.58) 304.97,121.58 304.68,121.28 295.71,121.28 295.17,120.74 295.17,119.71 v2(295.05,119.6)
REM_DIODE4_N: length 268.6
  TOP w0.254: v2(174.75,179.53) 175,179.78 175,180.23 175.6,180.82 178.34,180.82 179.61,182.09 179.61,183.46 178.62,184.45 178.62,185.2 v2(178.8,185.38) ; U51.A16 293.04,117.78 293.04,118.95 293.3,119.21 293.3,120.34 C286.1 292.34,121.31 292.34,123.58 292.59,123.84 v2(292.59,123.96) ; Q3.3 160.69,134.12 C16.1 160.69,135.06 v1(161.57,135.95) 162.03,136.41 v2(162.16,136.41)
  IN2 w0.254: v2(162.16,136.41) 164.26,138.51 164.26,152.17 166.43,154.34 168.48,154.34 169.65,155.51 178.74,155.51 179.3,156.07 184.05,156.07 184.64,156.66 184.64,157.28 183.97,157.95 183.19,157.95 182.94,157.7 182.6,157.7 v2(182.41,157.51)
  IN3 w0.254: v2(178.8,185.38) 178.8,185.45 179.68,186.33 180.84,186.33 182.49,184.68 186.3,184.68 187.6,185.98 189.68,185.98 189.79,186.09 192.51,186.09 192.88,185.72 197.78,185.72 199.04,186.99 199.04,187.48 202.12,190.55 209.02,190.55 209.55,190.02 220.66,190.02 220.68,190.04 239.65,190.04 239.67,190.02 241.54,190.02 242.86,188.7 246.4,188.7 247.91,190.21 247.92,190.22 253.01,190.22 253.82,189.41 256.92,189.41 257.48,189.97 260.44,189.97 261,189.41 266.1,189.41 269.16,186.35 269.16,185.44 275.51,179.09 275.51,176.1 276.21,175.4 276.21,170.59 275.7,170.09 275.7,168.83 275.27,168.4 275.27,165.07 273.52,163.32 273.52,154.32 275.7,152.13 275.7,147.97 278.57,145.1 278.57,144.01 280.39,142.19 280.39,137.68 279.43,136.72 279.43,133.15 278.96,132.68 278.96,129.63 280.68,127.92 280.68,127.09 283.45,124.32 288.86,124.32 290.15,123.02 291.78,123.02 292.59,123.84 v2(292.59,123.96)
  IN4 w0.254: v2(174.75,179.53) 174.57,179.35 174.57,179.02 174.91,178.68 174.91,177.91 175.57,177.25 176.12,177.25 177.01,176.36 177.01,176 178.34,174.66 178.34,173.22 178.21,173.09 178.21,171.22 179.2,170.23 179.28,170.23 181.39,168.12 181.39,165.38 180.79,164.78 180.79,161.14 182.91,159.02 182.91,158.03 182.41,157.52 v2(182.41,157.51)
REM_DIODE4_P: length 271.4
  TOP w0.254: v2(178.13,185.5) 178.13,184.12 179.09,183.16 179.09,182.29 178.13,181.33 175.39,181.33 174.54,180.48 174.2,180.48 173.46,179.74 v2(173.46,179.34) ; Q3.1 161.8,132.68 Q3.2 161.6,134.12 C16.2 161.53,135.01 v2(162.23,135.71) ; U51.B17 292.35,117.91 292.5,118.06 292.5,119.13 292.79,119.43 292.79,120.07 292.39,120.47 292.12,120.47 291.63,120.97 C286.2 291.96,121.44 v2(291.96,123.96)
  IN2 w0.254: v2(182.41,158.28) 182.48,158.2 182.73,158.2 182.98,158.46 184.18,158.46 185.15,157.49 185.15,156.45 184.26,155.56 179.51,155.56 178.95,155 169.86,155 168.69,153.83 166.65,153.83 164.77,151.96 164.77,138.25 v2(162.23,135.71)
  IN3 w0.254: v2(178.13,185.5) 179.47,186.84 181.05,186.84 182.7,185.19 186.09,185.19 187.39,186.49 189.47,186.49 189.58,186.6 192.73,186.6 193.09,186.23 197.57,186.23 198.53,187.2 198.53,187.69 201.91,191.06 209.23,191.06 209.76,190.53 220.45,190.53 220.47,190.55 239.86,190.55 239.88,190.53 241.75,190.53 243.07,189.2 246.19,189.2 247.55,190.57 247.71,190.73 253.22,190.73 254.03,189.92 256.71,189.92 257.26,190.47 260.65,190.47 261.21,189.92 266.31,189.92 269.67,186.56 269.67,185.65 276.02,179.3 276.02,176.31 276.72,175.61 276.72,170.38 276.21,169.87 276.21,168.62 275.78,168.19 275.78,164.86 274.02,163.11 274.02,154.53 276.21,152.34 276.21,148.18 279.08,145.31 279.08,144.22 280.89,142.4 280.89,137.46 279.94,136.51 279.94,132.94 279.47,132.47 279.47,129.84 281.19,128.13 281.19,127.3 283.66,124.83 289.07,124.83 290.36,123.53 291.57,123.53 291.96,123.92 v2(291.96,123.96)
  IN4 w0.254: v2(182.41,158.28) 182.41,158.81 180.28,160.93 180.28,164.99 180.88,165.59 180.88,167.91 179.07,169.72 178.99,169.72 177.71,171.01 177.71,173.3 177.83,173.43 177.83,174.45 176.5,175.79 176.5,176.15 175.91,176.75 175.36,176.75 174.4,177.7 174.4,178.41 173.48,179.34 v2(173.46,179.34)
RES_BIAS: length 5.1
  BOTTOM w0.102: U31.12 313.12,195.68 312.97,195.53 310.84,195.53 v1(310.06,194.75) 309.74,194.42 R562.1
RESERVED: length 4.8
  TOP w0.102: U7.16 320.13,131.72 319.54,132.31 318.85,132.31 R564.2 R1687.1 317.41,133.81 v1(317.25,133.96)
RESET_OUT#: length 258.8
  TOP w0.089: v2(170.72,94.96) 171.08,95.31 172.95,95.31 173.59,94.68 173.59,94.68
  TOP w0.102: v2(212.85,52.99) 212.53,53.31 RH103.1 ; U51.B39 283.53,115.91 v2(283.54,115.93) ; RH27.1 269.25,80.66 v2(269.03,80.44) ; R843.2 281.03,121.3 281.31,121.02 v2(281.31,120.79) ; 173.59,94.68 174.94,94.68 175.7,93.92 RC69.1
  IN2 w0.127: v2(247.85,56.19) 247.5,56.19 245.94,54.64 240.02,54.64 238.73,53.35 231.13,53.35 227.37,57.11 225.89,57.11 225.14,56.36 224.58,56.36 222.97,54.75 220.53,54.75 219.49,55.79 218.5,55.79 218.08,55.38 218.08,54.23 216.63,52.78 215.44,52.78 215.12,52.46 214.04,52.46 213.51,52.99 v2(212.85,52.99) 212.85,52.49 210.16,49.8 207.68,49.8 205.57,47.69 204.66,47.69 203.89,48.45 203.89,52.37 202.93,53.34 201.7,53.34 199.36,51 199.36,48.79 197.07,46.49 195.87,46.49 195.33,45.96 187.31,45.96 v2(185.66,44.31) ; v2(269.03,83.72) 269.88,82.87 269.88,80.87 269.45,80.44 v2(269.03,80.44) 269.45,80.02 269.45,77.77 269.17,77.48 263.46,77.48 260.61,74.64 252.12,74.64 251.44,73.96 v2(251.44,73.84) ; v2(283.54,115.93) 283.54,115.93 283.52,115.95 282.83,115.95 282.02,116.75 282.02,117.47 281.6,117.9 280.31,117.9 279.96,117.9 278.37,116.31 270.76,116.31 v2(269.05,118.02)
  IN3 w0.089: 173.59,94.5 171.15,94.5 170.72,94.93 v2(170.72,94.96)
  IN3 w0.127: 173.59,94.5 174.07,94.5 174.73,93.84 174.73,91.02 177.12,88.63 177.12,75.06 174.19,72.13 174.19,60.08 185.23,49.04 185.23,44.74 v2(185.66,44.31) ; v2(281.31,120.79) 280.44,119.91 280.44,118.97 283.49,115.93 v2(283.54,115.93)
  BOTTOM w0.102: RH85.1 212.56,53.28 v2(212.85,52.99) ; v2(251.44,73.84) 251.44,73.35 249.79,71.7 249.79,69.61 250.22,69.18 250.22,60.49 247.89,58.15 247.89,56.23 v2(247.85,56.19) ; v2(269.05,118.02) 270.07,116.99 v1(270.07,104.24) 270.07,101.99 268.34,100.26 268.34,97.49 266.91,96.06 266.91,87.8 268.46,86.25 268.46,84.29 v2(269.03,83.72)
RESET_OUT#_R: length 3.8
  TOP w0.102: RH27.2 272.05,80.66 v2(272.32,80.39) 272.32,80.96 v1(272.4,81.04)
  BOTTOM w0.102: JXDP2.46 270.62,80.34 272.27,80.34 v2(272.32,80.39)
REXT: length 4.6
  TOP w0.102: U7.9 326.08,131.22 R748.1 327.31,131.81 R563.2 328.34,131.91 v1(328.54,131.71)
REXTA: length 3.6
  BOTTOM w0.102: U90.7 328.04,192.61 327.73,192.93 v1(327.73,193) 327.73,193.27 R3686.1 R3678.2
REXTB: length 5.5
  BOTTOM w0.102: R3718.1 332.85,215.99 332.9,215.99 332.95,216.04 333.87,216.04 334.2,216.37 R3708.2 334.46,217.06 v1(335.26,217.86) 335.37,217.96 U92.7
REXTC: length 4
  BOTTOM w0.102: U94.7 32.98,183.29 32.23,182.54 v1(32.11,182.54) 31.58,182.54 R3744.2 31.05,181.02 R3742.1
REXTD: length 5.8
  BOTTOM w0.102: U95.7 340.22,193.43 339.34,194.31 R3778.2 339.34,194.98 338.34,195.99 v1(338.34,196.35) 338.34,196.63 338.95,197.24 R3757.1
RF_+1.05VSP: length 4.7
  TOP w0.254: PU300.5 240.11,6.55 240.33,6.32 v1(242.41,6.32) 243.19,5.55 PR305.1
RING2: length 0.7
  TOP w0.102: v2(349.42,183.39) v1(349.42,184.11)
  vias: v2(345.56,170.08) v2(346.16,170.09) v2(348.86,182.87)
RING2_L:
  vias: v1(356.72,182.47)
RSMRST#: length 7.2
  BOTTOM w0.102: v1(214.79,52.55) 214.67,52.43 R1622.1 215.32,50.62 215.76,50.18 215.76,49.83 U8.3 214.4,48.47 R1630.1 U9.2
RSMRST#_XDP: length 5.4
  TOP w0.102: v2(274.73,81.88) 276.36,81.88 RH26.2 277.82,81.53 v1(277.82,81.47)
  BOTTOM w0.102: v2(274.73,81.88) 276.28,81.88 JXDP2.39
RUN_ON: length 186
  TOP w0.102: v3(273.54,40.75) 273.54,41.05 v2(272.65,41.94) 272.65,41.72 269.68,38.75 R717.1 ; U46.A11 v2(274.45,53.89) 274.91,53.43 276.05,53.43 R786.2
  TOP w0.254: v4(233.96,109.02) 233.93,108.99 233.93,108.66 PR406.1
  IN1 w0.102: v2(274.45,53.89) 273,52.43 273,48.6 272.51,48.11 272.51,46.7 273.67,45.54 273.67,43.12 272.65,42.11 v2(272.65,41.94)
  IN2 w0.127: v4(233.96,109.02) 233.96,108.93 234.53,108.36 237.27,108.36 239.28,110.36 244.24,110.36 246.08,108.52 247.95,108.52 249.63,106.84 v2(250.58,106.84) ; v2(272.65,41.94) 272.13,41.41 269.01,41.41 268.38,40.79 262.56,40.79 260.61,38.85 258.29,38.85 257.73,38.29 256.34,38.29 254.03,35.98 247.21,35.98 245.78,37.41 245.78,38.65 244.93,39.5 243.13,39.5 242.4,40.23 240.52,40.23 240.19,39.9 240.19,38.46 v2(240.2,38.46)
  BOTTOM w0.102: R744.1 236.55,19.2 241.71,24.37 241.71,27.81 241.28,28.25 241.28,31.7 240.2,32.78 v2(240.2,38.46) 240.2,39.39 241.56,40.76 241.56,45.78 242.53,46.74 242.53,48.44 242.98,48.9 242.98,50.71 244.72,52.45 244.72,53.14 245.22,53.63 246.23,53.63 247.44,54.84 247.44,55.55 247.44,58.11 250,60.67 250,69.08 249.56,69.52 249.56,71.79 250.98,73.21 250.98,75.1 251.98,76.1 251.98,84.89 250.01,86.86 250.01,97.48 251.29,98.76 251.29,106.13 v2(250.58,106.84)
RUN_ON_CPU1.5VS3: length 8.3
  TOP w0.102: v1(143.21,73.69) 143.37,73.53 RC95.2
  TOP w0.254: QC6.4 146.79,73.53 146.54,73.79 145.78,73.79 145.4,73.41 CC136.1 RC143.1 RC95.2 143.34,72.48 142.52,71.66 QC4.3
RUN_ON_CPU1.5VS3#:
  vias: v1(139.02,68.62)
RUN_ON_EN: length 296
  TOP w0.102: U101.3 324.4,199.14 324.05,198.79 324.05,198.37 324.68,197.74 324.68,188.14 323.71,187.16 321.71,187.16 316.87,182.32 312.26,182.32 311.03,181.09 311.03,179.7 v2(309.6,178.27)
  IN1 w0.102: v2(221.98,37.19) 221.98,40.28 228.21,46.52 228.21,46.52 228.34,46.65 232.33,46.65 232.94,47.25 236.91,47.25 237.46,47.81 237.46,50.08 245.31,57.92 246.9,57.92 248.14,59.16 249.4,59.16 249.64,58.92 250.85,58.92 251.29,59.36 255.28,59.36 255.82,59.91 257.24,59.91 259.07,61.73 259.07,62.8 263.62,67.35 263.62,67.63 268.42,72.43 268.42,76.27 270.89,78.74 270.89,91.54 273.55,94.2 273.55,104.46 272.99,105.03 272.99,119.46 273.44,119.91 273.44,123.28 277.33,127.16 277.33,132.41 276.84,132.89 276.84,136.97 276.58,137.24 276.58,143.59 273.86,146.31 273.86,147.46 273.11,148.21 273.11,152.67 273.95,153.51 273.95,167.7 274.32,168.06 274.32,170.13 274.48,170.29 274.48,171.9 275.41,172.83 279.08,172.83 279.47,173.23 v2(279.47,173.71)
  IN2 w0.127: v2(221.98,37.19) 221.98,37.36 223.67,39.05 232.28,39.05 234.35,36.98 241.76,36.98 242.18,36.56 242.18,30.86 240.48,29.16 v2(240.48,27.06) ; v2(279.47,173.71) 279.47,172.24 279.89,171.82 283.9,171.82 284.51,172.42 284.51,174.31 288.5,178.31 289.71,178.31 290.68,177.34 296.96,177.34 297.26,177.65 297.26,178.5 297.63,178.87 299.65,178.87 299.96,178.55 306.48,178.55 307.34,179.41 308.46,179.41 v2(309.6,178.27)
  BOTTOM w0.102: v2(240.48,27.06) 240.51,27.04 240.51,24.3 236.32,20.12 v1(233.37,20.12) R744.2 R735.2 230.84,20.46 231.24,20.85 Q52.2 ; U105.3 v2(221.98,37.19)
RUN_ON_ENABLE#: length 207.7
  TOP w0.102: Q72.2 192.97,18.83 v1(194.95,20.82) 199.17,25.03 202.04,25.03 203.87,26.86 214.61,26.86 215.44,26.03 v2(215.44,24.85) ; v2(287.98,123.81) 287.98,124.29 289.1,125.41 Q45.2
  IN2 w0.127: v2(260.69,121.83) 270.93,121.83 272.21,123.11 276.14,123.11 276.38,123.35 277.98,123.35 278.76,124.14 280.68,124.14 280.82,124.28 282.61,124.28 282.93,124.6 285.14,124.6 285.63,124.12 285.71,124.12 285.93,123.9 286.5,123.9 286.51,123.89 287.9,123.89 v2(287.98,123.81) ; v2(215.44,24.85) 216.76,26.17 230.81,26.17 v2(231.36,25.62)
  IN3 w0.127: v2(260.69,121.83) 259.7,120.84 259.7,113.18 258.61,112.09 258.61,103.98 249.03,94.41 249.03,86.9 250.7,85.23 250.7,82.61 252.08,81.24 252.08,70.72 248.34,66.98 248.34,61.51 247.59,60.77 247.59,57.2 247.15,56.76 247.15,55.06 245.74,53.65 245.74,51.17 245.31,50.74 245.31,45.08 244.43,44.2 244.43,37.73 246.78,35.38 246.78,31.83 245.61,30.66 245.61,28.24 244.35,26.97 243.23,26.97 240.52,24.27 233.98,24.27 232.64,25.62 v2(231.36,25.62)
  BOTTOM w0.102: Q70.2 214.97,21.33 214.75,21.55 214.75,24.17 v2(215.44,24.85) ; R909.2 231.89,23.88 Q52.6 231.89,22.56 231.8,22.47 231.36,22.47 231.24,22.59 Q52.5 231.02,23.26 231.02,25.27 v2(231.36,25.62)
RUNPWROK: length 327.8
  TOP w0.102: v2(287.52,117.68) 287.52,117.75 287.49,117.79 287.49,118.28 287.47,118.31 U51.B26 ; 276.83,123.84 276.84,123.83 U50.2 ; 276.83,123.84 276.01,123.84 275.2,123.04 R840.1 ; 276.83,123.84 277.36,123.84 277.91,124.38 277.91,126.26 278.62,126.97 282.8,126.97 284.05,128.22 284.39,128.22 284.67,128.5 286.74,128.5 287.32,127.91 v2(287.32,127.85) 287.32,126.78 287.2,126.66 Q45.1 287.2,125.97 286.97,125.74 R799.2 ; RC7.2 137.83,61.1 v2(138.38,61.1)
  IN1 w0.102: v2(287.32,127.85) 287.32,125.93 285.4,124.02 285.4,122.25 286.37,121.28 286.37,119.3 287.52,118.15 v2(287.52,117.68) ; v2(270.79,29.5) 271.32,29.5 271.34,29.48 271.83,29.48 272.11,29.76 272.11,31.04 271.93,31.22 271.93,37.63 272.51,38.22 272.51,39.51 273.69,40.69 273.69,42.35 274.13,42.79 274.13,46.42 273.69,46.85 273.69,50.9 v2(274.4,51.61)
  IN2 w0.127: v2(270.79,29.5) 269.52,28.23 263.42,28.23 262.59,27.39 255.92,27.39 253.56,25.03 243.29,25.03 242.94,25.37 242.24,25.37 239.7,22.83 234.87,22.83 232.51,25.2 230.96,25.2 230.23,25.92 217.89,25.92 217.11,25.15 217.11,23.95 216.89,23.72 215.76,23.72 214.99,24.49 214.99,25.39 215.18,25.58 215.18,30.16 209.14,36.21 200.71,36.21 200.36,35.86 v2(200.36,35.89)
  IN3 w0.127: v2(182.02,71.06) 182.02,70.94 181.47,70.38 181.47,64.34 182.06,63.75 182.06,56.78 194.32,44.52 194.32,42.64 195.19,41.77 195.19,38.79 198.49,35.5 199.97,35.5 v2(200.36,35.89)
  IN4 w0.102: v2(274.4,51.61) 273.95,52.06 273.95,56 274.38,56.43 275.08,56.43 275.43,56.07 278.77,56.07 280.74,58.04 280.74,63.15 280.09,63.8 280.09,65.38 278.19,67.28 278.19,91.8 282.33,95.95 282.33,97.86 283.29,98.82 283.35,98.82 286.76,102.22 288.31,102.22 289.96,103.87 289.96,105.38 290.81,106.24 290.81,108.22 290.99,108.39 291.83,108.39 292.96,109.52 292.96,119.13 v2(292.11,119.98)
  BOTTOM w0.102: v2(138.38,61.1) 138.68,61.39 143.09,61.39 143.89,60.59 171.59,60.59 182.02,71.02 v2(182.02,71.06) ; v2(287.52,117.68) v1(289.1,119.25) 290.24,119.25 290.46,119.47 290.46,120.4 290.8,120.74 291.63,120.74 292.11,120.26 v2(292.11,119.98)
RUNPWROK_AND: length 12.4
  TOP w0.102: RC10.2 141.33,63.84 QC5.1 ; RC10.2 141.27,65.94 v1(141.07,65.94) 140.33,65.94 139.95,65.56 UC1.4 ; RC10.2 RC16.1 RC6.2 RC9.1 RC15.2
RUNPWROK_R: length 27.5
  TOP w0.102: RC103.1 143.05,58 143.87,57.18 143.87,55.08 142.49,53.7 140.41,53.7 v1(137.27,56.83) 137,57.1 137,61.8 RC7.1 ; RC103.1 141.59,58.55 141.45,58.69 140.95,58.69 140.68,58.95 QC5.2 ; RC103.1 RC104.1 ; RC7.1 RC5.2 ; RC7.1 138.15,61.7 v2(138.38,61.7) 138.65,61.97 UC1.1
S3_1.35V: length 2.9
  TOP w0.203: PU200.7 212.9,13.46 v1(213.22,13.14) PR208.2
S5_1.35V: length 88.2
  TOP w0.102: v1(273.16,42.56) 272.7,42.56 272.25,42.1 272.25,41.9 270.85,40.5 v2(270.56,40.5) 270.37,40.69 PR210.2
  TOP w0.203: PR206.2 v2(213.52,13.86) PU200.8
  TOP w0.254: PC215.1 PR206.2
  IN4 w0.102: v2(270.56,40.5) 270.56,38.79 271.5,37.85 271.5,33.03 272.42,32.11 272.73,32.11 272.89,31.94 272.89,27.38 270.1,24.59 266.06,24.59 257.79,16.31 231.61,16.31 231.07,16.85 224.59,16.85 223.8,16.07 215.1,16.07 213.52,14.49 v2(213.52,13.86)
SATA_ACT#: length 347.8
  TOP w0.102: v2(321.78,155.83) 321.8,155.8 321.88,155.8 321.94,155.74 328.1,155.74 328.95,154.89 329.85,154.89 330.02,154.72 331.57,154.72 332.85,156.01 332.85,156.37 333.26,156.78 333.26,158.25 332.76,158.75 Q74.4 ; v2(313.88,150.7) v1(313.88,150.16)
  IN2 w0.127: v2(321.78,155.83) 321.3,155.83 315.12,149.64 314.12,149.64 313.88,149.89 v2(313.88,150.7) ; v2(260.36,147.37) 260.43,147.29 276.86,147.29 277.82,148.25 280.93,148.25 281.76,149.07 281.76,149.35 v2(281.92,149.51)
  IN3 w0.127: v2(313.88,150.7) 313.63,150.46 313.63,147.08 312.63,146.08 308.83,146.08 308.3,145.54 308.3,145.11 306.88,143.69 305.14,143.69 304.72,143.27 293.67,143.27 293.54,143.4 287.45,143.4 287.14,143.7 284.88,143.7 281.29,147.29 281.29,148.64 281.71,149.06 281.71,149.3 v2(281.92,149.51) ; v2(194.48,67.81) 190.9,67.81 189.25,69.46 183.99,69.46 182.86,68.33 182.86,57.08 196.11,43.84 196.11,40.77 199.39,37.49 201.04,37.49 202.05,36.47 211.17,36.47 215.25,32.39 215.25,27.94 216.01,27.19 219.45,27.19 227.71,18.94 229.49,18.94 230.48,17.94 247.54,17.94 261.54,31.94 261.54,41.52 260.46,42.6 260.46,45.5 258.38,47.59 257.61,47.59 257.36,47.84 257.36,53.32 257.17,53.51 257.17,56.02 257.42,56.28 257.42,65.02 260.87,68.46 260.87,92.37 261.84,93.34 261.84,99.14 263.53,100.83 263.53,119.57 262.92,120.18 262.92,129.45 262.61,129.77 262.61,142.24 260.36,144.49 v2(260.36,147.37)
  BOTTOM w0.089: 196.54,68.63 196.91,68.99 197.13,68.99 197.2,69.06 197.72,69.06 198.02,69.36 198.46,69.36 198.78,69.67 UH1.AP3
  BOTTOM w0.102: 196.54,68.63 196.42,68.5 195.93,68.5 195.31,67.88 194.56,67.88 v2(194.48,67.81)
SATA_COMP: length 6
  TOP w0.254: RH57.1 194.16,72.3 194.26,72.2 194.69,72.2 195.18,72.69 v1(195.18,72.83) 195.18,72.94 195.41,73.16 196.06,73.16 197.11,72.11 v2(197.16,72.11)
  BOTTOM w0.254: v2(197.16,72.11) 197.54,72.11 UH1.AY5
SATA_IREF: length 4.7
  TOP w0.254: v2(196.66,73.21) 195.71,74.16 v1(195.5,74.16) 195.04,73.7 194.25,73.7 RH51.2
  BOTTOM w0.089: UH1.BD4 196.45,73 v2(196.66,73.21)
SATA_LED: length 9.7
  TOP w0.102: R934.2 325.83,168.33 JLED2.4 325.83,170.72 326.22,171.11 327.64,171.11 328.34,170.41 328.34,169.64 328.75,169.23 329.6,169.23 330.36,168.47 v1(330.36,168.26)
SATA_ODD_PRX_DTX_N1: length 3.6
  BOTTOM w0.102: JSATA2.5 233.52,32.72 231.2,32.72 C405.1
SATA_ODD_PRX_DTX_N1_C: length 99.4
  IN1 w0.114: v2(195.57,76.5) 195.56,76.5 194.37,75.31 194.37,75.01 192.53,73.17 186.95,73.17 182.53,68.76 182.53,57.79 188.82,51.5 188.82,50.29 194.65,44.46 194.65,42.83 194.92,42.56 194.92,40 197.78,37.13 198.1,37.13 204.42,30.81 214.21,30.81 215.22,29.81 225.83,29.81 227.07,28.57 229.31,28.57 229.73,28.99 229.73,30.98 228.65,32.05 228.65,32.28 228.81,32.44 v2(229.15,32.44)
  BOTTOM w0.089: UH1.BC10 198.2,74.81 197.86,75.15 197.86,75.45 197.82,75.49 197.82,76.1 197.39,76.53 197.1,76.53 196.94,76.68 196.79,76.68
  BOTTOM w0.102: C405.2 229.55,32.44 v2(229.15,32.44) ; v2(195.57,76.5) 195.57,76.51 196.01,76.95 196.43,76.95 196.69,76.68 196.79,76.68
SATA_ODD_PRX_DTX_P1: length 3.7
  BOTTOM w0.102: C404.1 231.25,32.93 233.28,32.93 JSATA2.6
SATA_ODD_PRX_DTX_P1_C: length 99.4
  IN1 w0.114: v2(196.02,76.05) 195.99,76.07 195.45,76.07 194.59,75.21 194.59,74.92 192.62,72.94 187.04,72.94 182.76,68.66 182.76,57.88 189.05,51.6 189.05,50.39 194.88,44.56 194.88,42.93 195.14,42.66 195.14,40.09 197.87,37.36 198.19,37.36 204.52,31.04 214.31,31.04 215.31,30.04 225.93,30.04 227.16,28.8 229.21,28.8 229.5,29.09 229.5,30.88 228.42,31.96 228.42,32.37 228.71,32.67 228.79,32.67 229.15,33.03 v2(229.15,33.11)
  BOTTOM w0.089: UH1.BE10 197.63,75.38 197.63,76.02 197.31,76.33 197.02,76.33 196.88,76.47 196.79,76.47
  BOTTOM w0.102: v2(229.15,33.11) 229.15,33.02 229.51,32.67 229.86,32.67 229.98,32.79 229.98,33.28 C404.2 ; v2(196.02,76.05) 195.98,76.08 195.98,76.63 196.09,76.74 196.34,76.74 196.61,76.47 196.79,76.47
SATA_ODD_PTX_DRX_N1: length 4.1
  BOTTOM w0.102: C406.1 230.69,29.75 230.79,29.65 232.25,29.65 232.72,29.17 233.33,29.17 JSATA2.3
SATA_ODD_PTX_DRX_N1_C: length 89.9
  IN1 w0.089: v2(199.19,73.11) 199.15,73.16 198.7,73.16 198.52,72.97 198.11,72.97 198.03,73.05 197.49,73.05 197.23,73.31 197.22,73.31 197.17,73.36 197.15,73.36 197.15,73.37
  IN1 w0.109: 193.22,71.95 193.98,72.72 194.97,73.71 196.81,73.71 197.15,73.37
  IN1 w0.114: 193.22,71.95 193,71.73 187.63,71.73 183.61,67.72 183.61,58.24 189.96,51.89 189.96,50.68 196.44,44.2 196.44,40.84 202.38,34.9 202.74,34.9 205.74,31.9 214.77,31.9 215.75,30.92 226.41,30.92 227.66,29.68 228.7,29.68 v2(228.89,29.86)
  BOTTOM w0.089: UH1.AV10 199.25,73.17 v2(199.19,73.11)
  BOTTOM w0.102: v2(228.89,29.86) 229.08,29.67 229.62,29.67 229.78,29.82 C406.2
SATA_ODD_PTX_DRX_P1: length 4.1
  BOTTOM w0.102: JSATA2.2 233.46,28.96 232.64,28.96 232.16,29.44 230.79,29.44 230.69,29.34 C407.1
SATA_ODD_PTX_DRX_P1_C: length 90.1
  IN1 w0.089: 197.3,73.53 197.58,73.25 198.12,73.25 198.2,73.18 198.43,73.18 198.78,73.52 v2(198.78,73.53)
  IN1 w0.109: 197.3,73.53 196.9,73.93 194.88,73.93 193.13,72.18 193.13,72.18 193.08,72.13 193.08,72.13 193.06,72.11
  IN1 w0.114: 193.06,72.11 192.9,71.96 187.53,71.96 183.38,67.81 183.38,58.14 189.73,51.79 189.73,50.58 196.21,44.11 196.21,40.74 202.28,34.67 202.65,34.67 205.64,31.67 214.68,31.67 215.65,30.7 226.32,30.7 227.56,29.45 228.71,29.45 v2(228.89,29.28)
  BOTTOM w0.089: v2(198.78,73.53) 198.83,73.59 UH1.AW10
  BOTTOM w0.102: C407.2 229.78,28.92 229.24,29.46 229.07,29.46 v2(228.89,29.28)
SATA_PCIE_EN#: length 9.6
  TOP w0.102: U7.3 v2(322.61,127.83) ; v2(318.84,124.37) 319.03,124.37 319.32,124.66 Q85.1 319.9,125.02 319.39,125.53 R724.1
  IN1 w0.102: v2(322.61,127.83) 322.49,127.83 319.03,124.37 v2(318.84,124.37)
  BOTTOM w0.102: v2(322.61,127.83) 322.61,127.29 v1(322.59,127.27)
SATA_PRX_DKTX_N2: length 5.1
  TOP w0.102: C698.2 183.78,185.51 183.5,185.79 183.5,186.17 v2(183.57,186.23)
  BOTTOM w0.102: v2(183.57,186.23) 183.38,186.41 183.38,186.59 183.08,186.89 181.9,186.89 181.61,187.19 181.61,187.61 181.75,187.76 JDOCK1.56
SATA_PRX_DKTX_N2_C: length 228.3
  TOP w0.102: C698.1 183.59,184.3 183.59,183.07 184.68,181.97 187.29,181.97 187.66,181.6 189.82,181.6 191.54,179.88 192.07,179.88 193.7,178.26 194.38,178.26 195.82,176.82 196.5,176.82 197.01,176.31 198.2,176.31 198.57,176.68 201.07,176.68 201.99,175.76 v2(201.99,172.11)
  IN1 w0.114: v2(201.99,172.11) 201.99,172.93 202.44,173.38 218.58,173.38 219.53,174.33 226.02,174.33 226.97,173.38 240.9,173.38 241.04,173.24 243.23,173.24 244.58,171.89 244.83,171.64 248.31,171.64 250.41,171.64 251.4,170.64 251.4,159.55 251.94,159.02 251.94,148.98 249.7,146.75 249.7,132.11 251.34,130.47 251.34,115.26 250.57,114.49 250.57,108.51 241.74,99.68 236.79,99.68 234.45,102.02 228.28,102.02 227.72,101.46 213.5,101.46 211.74,99.69 209.24,99.69 203.38,93.84 203.38,93.23 194.81,84.66 194.81,83.64 193.68,82.51 193.51,82.51 192.89,81.88 v2(192.89,81.87)
  BOTTOM w0.089: 195.65,75.54 195.69,75.5 196.95,75.5 197.46,74.99 197.72,74.99 197.9,74.82 197.9,74.4 198.21,74.08 UH1.BB9
  BOTTOM w0.102: 195.65,75.54 195.44,75.76 195.18,75.76 192.81,78.12 192.81,79.86 194.17,81.22 194.17,81.88 193.97,82.07 193.53,82.07 193.33,81.87 v2(192.89,81.87)
SATA_PRX_DKTX_P2: length 5.1
  TOP w0.102: v2(182.98,186.23) 183.16,186.05 183.16,185.81 C697.2
  BOTTOM w0.102: JDOCK1.54 181.25,187.76 181.39,187.61 181.39,187.1 181.82,186.68 182.99,186.68 183.17,186.5 183.17,186.42 v2(182.98,186.23)
SATA_PRX_DKTX_P2_C: length 228.3
  TOP w0.102: v2(201.4,172.11) 201.77,172.48 201.77,175.67 200.98,176.47 198.66,176.47 198.29,176.1 196.92,176.1 196.42,176.61 195.73,176.61 194.29,178.05 193.61,178.05 191.98,179.67 191.45,179.67 189.73,181.39 187.57,181.39 187.21,181.76 184.6,181.76 183.38,182.98 183.38,184.08 C697.1
  IN1 w0.114: v2(193.3,81.46) 193.3,81.97 193.61,82.28 193.77,82.28 195.04,83.55 195.04,84.57 203.61,93.13 203.61,93.75 209.33,99.47 211.83,99.47 213.6,101.23 227.82,101.23 228.37,101.79 234.36,101.79 236.69,99.45 241.83,99.45 250.8,108.41 250.8,114.4 251.57,115.17 251.57,130.57 249.93,132.21 249.93,146.65 252.17,148.89 252.17,159.11 251.63,159.64 251.63,170.74 250.5,171.87 248.22,171.87 244.92,171.87 243.32,173.47 241.14,173.47 241,173.61 227.06,173.61 226.11,174.56 219.43,174.56 218.48,173.61 202.34,173.61 201.76,173.02 201.76,172.47 v2(201.4,172.11)
  BOTTOM w0.089: UH1.BD9 197.48,74.69 197.37,74.8 196.86,75.3 195.59,75.3 195.5,75.39
  BOTTOM w0.102: v2(193.3,81.46) 193.3,81.54 193.62,81.86 193.88,81.86 193.96,81.79 193.96,81.3 192.6,79.95 192.6,78.03 195.09,75.54 195.35,75.54 195.5,75.39
