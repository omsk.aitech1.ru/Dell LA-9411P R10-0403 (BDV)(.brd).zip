# Allegro board LA-9411P R10-0403.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
SATA_PRX_DTX_N0: length 4.6
  TOP w0.102: v2(110.07,57.62) 110.14,57.55 111.42,57.55 C385.1
  BOTTOM w0.102: JSATA1.5 111.41,58.13 110.85,57.57 110.12,57.57 v2(110.07,57.62)
SATA_PRX_DTX_P0: length 4.7
  TOP w0.102: C386.1 111.62,57.34 110.42,57.34 v2(110.07,56.98)
  BOTTOM w0.102: v2(110.07,56.98) 110.42,57.34 110.98,57.34 111.47,56.86 JSATA1.6
SATA_PTX_DKRX_N2: length 5.3
  TOP w0.102: C700.1 185.47,185.95 185.47,186.09 v2(185.6,186.22)
  BOTTOM w0.102: v2(185.6,186.22) 185.42,186.41 185.42,186.72 185.14,186.99 183.97,186.99 183.17,187.79 183.17,187.87 183.25,187.95 JDOCK1.62
SATA_PTX_DKRX_N2_C: length 234.7
  TOP w0.102: v2(204.18,172.38) 203.8,172.75 203.8,173.07 203.02,173.86 203.02,175.73 201.23,177.52 196.12,177.52 194.57,179.07 194.57,180.09 192.32,182.33 191.23,182.33 190.29,183.27 188.89,183.27 188.34,182.72 186.3,182.72 185.38,183.65 185.38,184.65 185.48,184.75 185.76,184.75 C700.2
  IN1 w0.114: v2(189.27,79.32) 189.25,79.3 189.21,79.3 188.69,79.83 188.69,81.82 192.79,85.93 195.38,85.93 202.89,93.43 202.89,94.05 209.06,100.22 209.4,100.22 211.25,102.07 218.98,102.07 220.15,103.24 227.8,103.24 228.46,102.58 234.64,102.58 236.01,101.21 242.55,101.21 249.04,107.7 249.04,110.49 250.07,111.52 250.07,120.35 245.27,125.15 245.27,128.09 249.17,131.99 249.17,146.94 251.44,149.21 251.44,158.41 250.68,159.17 250.68,169.78 249.32,171.14 248.52,171.14 244.57,171.14 242.97,172.75 240.74,172.75 240.62,172.86 207.87,172.86 207.11,172.1 207.11,171.09 206.79,170.78 204.76,170.78 203.95,171.58 203.95,172.15 v2(204.18,172.38)
  IN4 w0.089: v2(199.47,74.22) 199.36,74.12 198.51,74.12 198.29,74.34 198.29,74.35 198.28,74.36
  IN4 w0.102: 194.62,74.51 198.13,74.51 198.28,74.36
  IN4 w0.114: v2(189.27,79.32) 189.27,78.74 189.7,78.31 190.4,78.31 192.28,76.44 192.56,76.44 194.49,74.51 194.62,74.51
  BOTTOM w0.089: UH1.AY13 199.68,74.44 v2(199.47,74.22)
SATA_PTX_DKRX_P2: length 5.3
  TOP w0.102: v2(185.02,186.22) 185.26,185.99 185.26,185.87 C699.1
  BOTTOM w0.102: v2(185.02,186.22) 185.2,186.41 185.2,186.63 185.05,186.78 183.88,186.78 182.94,187.71 182.94,187.78 182.75,187.97 JDOCK1.60
SATA_PTX_DKRX_P2_C: length 234.8
  TOP w0.102: C699.2 185.17,184.32 185.17,183.56 186.22,182.51 188.43,182.51 188.98,183.06 190.21,183.06 191.14,182.12 192.24,182.12 194.36,180 194.36,178.98 196.03,177.31 201.14,177.31 202.81,175.64 202.81,173.77 203.59,172.98 v2(203.59,172.38)
  IN1 w0.114: v2(203.59,172.38) 203.72,172.25 203.72,171.49 204.66,170.55 206.88,170.55 207.34,171 207.34,172 207.96,172.63 240.53,172.63 240.64,172.52 242.88,172.52 244.48,170.92 248.61,170.92 249.22,170.92 250.45,169.68 250.45,159.08 251.21,158.32 251.21,149.31 248.94,147.03 248.94,132.08 245.04,128.18 245.04,125.06 249.84,120.26 249.84,111.61 248.81,110.58 248.81,107.8 242.45,101.43 236.1,101.43 234.73,102.81 228.56,102.81 227.9,103.47 220.06,103.47 218.89,102.3 211.16,102.3 209.3,100.44 208.96,100.44 202.66,94.14 202.66,93.53 195.29,86.16 192.7,86.16 188.46,81.91 188.46,79.73 188.56,79.62 188.56,79.12 188.82,78.87 v2(188.82,78.87)
  IN4 w0.089: v2(199.93,73.76) 199.92,73.75 199.4,73.75 199.24,73.91 198.43,73.91 198.14,74.2 198.13,74.2 198.12,74.21
  IN4 w0.102: 198.12,74.21 198.04,74.29 194.72,74.29 194.71,74.28 194.64,74.28 194.64,74.28 194.62,74.28
  IN4 w0.114: 194.62,74.28 194.39,74.28 192.46,76.21 192.18,76.21 190.31,78.09 189.6,78.09 188.82,78.87 v2(188.82,78.87)
  BOTTOM w0.089: v2(199.93,73.76) 200.11,73.94 UH1.AW13
SATA_PTX_DRX_N0: length 3.3
  BOTTOM w0.102: JSATA1.3 113.57,60.67 114.14,61.23 114.8,61.23 115.18,60.85 C384.1
SATA_PTX_DRX_P0: length 3.3
  BOTTOM w0.102: C383.1 114.8,61.44 113.84,61.44 113.35,61.94 JSATA1.2
SB#: length 3.7
  BOTTOM w0.102: R153.2 R1626.2 319.08,218.44 319.48,218.83 v1(319.96,218.83) 320.39,218.83 320.66,218.57 U2.8
SCLK: length 5
  BOTTOM w0.102: PR508.2 116.18,150.34 PR504.1 v1(116.79,152.05) 117.03,152.29 117.03,152.72 117.73,153.43 PU500.1
SD_CD#: length 36
  TOP w0.102: v2(246.73,44.41) 246.73,44.35 247.24,43.84 U38.21 ; C802.2 256.23,31.81 v1(256.88,32.46) ; C802.2 R493.1 ; C802.2 255.85,31.81 JSD1.17 255.85,28.25 255.3,27.71 252.8,27.71 251.37,26.28 250.43,26.28 248.99,27.71 247.68,27.71 v2(246.95,28.45)
  IN1 w0.102: v2(246.95,28.45) 247.05,28.45 247.56,28.96 247.56,30.43 246.81,31.18 246.81,32.92 245.61,34.11 245.61,39.79 247.09,41.27 247.09,43.99 246.73,44.35 v2(246.73,44.41)
SD_CLK: length 24.8
  TOP w0.102: CE759.1 256.98,44.72 R676.2 257.51,44.59 v2(257.92,45) ; v2(261.02,28.3) 260.98,28.26 257.92,28.26 257.34,28.83 JSD1.5
  IN1 w0.102: v2(257.92,45) 258.29,45 259.33,43.95 259.33,38.52 260.82,37.04 260.82,28.5 v2(261.02,28.3)
SD_CLK_R: length 4.3
  TOP w0.102: U38.43 255.74,45.04 R676.1 256.19,44.45 256.55,44.09 v1(258.15,44.09)
SD_CMD: length 25.6
  TOP w0.102: v2(265.72,28.66) 266.16,28.66 266.34,28.85 JSD1.2 ; v2(255.18,46.18) 254.84,45.84 U38.45
  IN1 w0.102: v2(265.72,28.66) 265.72,29.37 262.16,32.93 262.16,36.27 259.74,38.69 259.74,44.14 257.91,45.97 255.38,45.97 v2(255.18,46.18)
SD_D0_RCLK_P_MMC_D0: length 12.2
  TOP w0.089: v2(251.25,27.37) 251.34,27.47 251.61,27.47 252.24,28.1 252.24,29.26 252.4,29.42 JSD1.7 ; v2(249.07,33.02) 249.03,33.06 249.03,33.54 249.2,33.71 LE5.3 249.2,34.4 RE28.2
  IN1 w0.089: v2(251.25,27.37) 251.78,27.37 252.08,27.67 252.08,29.51 249.07,32.52 v2(249.07,33.02)
SD_D0_RCLKR_P: length 17.3
  TOP w0.089: U38.38 254.7,43.04 254.8,42.94 254.82,42.94 255.37,42.39 255.37,42.37 255.45,42.29 255.58,42.29 v2(255.59,42.3) ; RE28.1 249.2,35.48 LE5.4 249.2,36.33 249.12,36.41 249.03,36.41 248.93,36.5 248.93,36.69 v2(249.08,36.83)
  TOP w0.102: U38.30 251.12,41.32 251.05,41.25 251.05,40.9 v2(251.2,40.76)
  IN1 w0.089: v2(249.08,36.83) 248.75,37.16 248.75,37.58 249.56,38.39 249.56,39.3 249.92,39.66 250.63,39.66 251.01,40.04 251.01,40.57 v2(251.2,40.76) 251.03,40.92 251.03,41.25 251.22,41.44 253.43,41.44 254.9,42.91 255.71,42.91 256.12,42.51 256.12,42.26 255.99,42.13 255.77,42.13 v2(255.59,42.3)
SD_D1_RCLK_N: length 12.4
  TOP w0.089: JSD1.8 251.58,29.65 251.85,29.65 251.95,29.55 251.95,28.23 251.49,27.76 251.35,27.76 251.25,27.87 v2(251.25,27.96) ; RE27.2 248.35,34.4 LE5.2 248.35,33.53 248.42,33.46 248.67,33.46 248.74,33.4 248.74,33.27 v2(248.48,33.02)
  IN1 w0.089: v2(248.48,33.02) 248.81,32.69 248.81,32.41 251.82,29.4 251.82,27.78 251.67,27.63 251.58,27.63 v2(251.25,27.96)
SD_D1_RCLKR_N: length 18.4
  TOP w0.089: RE27.1 248.35,35.48 LE5.1 248.35,36.27 248.64,36.56 248.64,36.69 v2(248.5,36.83) ; v2(255.61,41.69) 255.61,41.72 255.08,42.25 255.08,42.27 254.7,42.64 U38.37
  TOP w0.102: v2(250.61,40.76) 250.76,40.9 250.76,41.3 250.72,41.34 U38.29
  IN1 w0.089: v2(255.61,41.69) 255.79,41.87 256.09,41.87 256.37,42.15 256.37,42.61 255.82,43.17 254.8,43.17 253.32,41.69 251.11,41.69 250.78,41.36 250.78,40.92 v2(250.61,40.76) 250.76,40.61 250.76,40.14 250.53,39.92 249.82,39.92 249.31,39.41 249.31,38.49 248.5,37.68 v2(248.5,36.83)
SD_D2: length 27.6
  TOP w0.102: RE30.2 257.58,48.22 v2(257.78,48.02) 257.78,48.65 v1(257.93,48.81) ; JSD1.9 269.35,28.84 269.16,28.65 v2(268.72,28.65)
  IN1 w0.102: v2(268.72,28.65) 267.85,29.51 266.8,29.51 263.03,33.29 263.03,40.46 260.94,42.54 260.94,44.45 257.78,47.61 v2(257.78,48.02)
SD_D2_R: length 3.3
  TOP w0.102: v1(256.04,49.39) RE30.1 254.86,47.04 U38.48
SD_D3: length 24.9
  TOP w0.102: RE29.2 257.49,46.88 v2(257.79,46.57) 257.87,46.57 v1(258.3,47) ; v2(267.17,28.7) 267.62,28.7 267.85,28.93 JSD1.1
  IN1 w0.102: v2(257.79,46.57) 258.15,46.57 260.14,44.58 260.14,42.68 262.57,40.26 262.57,33.12 266.99,28.7 v2(267.17,28.7)
SD_D3_R: length 5.8
  TOP w0.102: U38.47 255.05,46.64 255.28,46.88 RE29.1 256.07,46.94 256.55,47.42 259.11,47.42 v1(259.6,46.94)
SD_UHS2_D0N: length 30.8
  TOP w0.089: v2(264.22,11.75) 264.37,11.6 264.37,10.49 263.77,9.89 JSD1.12 ; v2(252.59,32.83) 252.75,32.99 252.75,33.32 252.42,33.66 LE4.2 252.42,34.4 RE25.2
  IN1 w0.089: v2(264.22,11.75) 264.41,11.94 264.41,13.35 254.87,22.89 254.87,30.11 252.76,32.22 252.76,32.65 v2(252.59,32.83)
SD_UHS2_D0N_R: length 7.7
  TOP w0.089: RE25.1 252.42,35.48 LE4.1 252.42,36.07 252.59,36.25 252.59,36.44 v2(252.23,36.79)
  TOP w0.102: v2(253.33,40.51) 253.42,40.6 253.42,40.7 253.25,40.88 253.02,40.88 252.76,41.14 252.76,41.34 252.72,41.39 U38.34
  IN1 w0.089: v2(253.33,40.51) 253.5,40.34 253.5,39.69 252.38,38.57 252.38,36.94 v2(252.23,36.79)
SD_UHS2_D0P: length 30.7
  TOP w0.089: RE26.2 253.26,34.4 LE4.3 253.26,33.64 253.04,33.41 253.04,32.96 v2(253.17,32.83) ; v2(264.81,11.75) 264.66,11.61 264.66,10.45 265.27,9.85 JSD1.11
  IN1 w0.089: v2(253.17,32.83) 253.02,32.68 253.02,32.33 255.13,30.22 255.13,22.99 264.66,13.45 264.66,11.89 v2(264.81,11.75)
SD_UHS2_D0P_R: length 7.9
  TOP w0.089: RE26.1 253.26,35.48 LE4.4 253.26,36.21 253.09,36.39 252.97,36.39 252.88,36.47 252.88,36.56 252.74,36.7 252.74,36.81 v2(252.84,36.92)
  TOP w0.102: v2(253.92,40.51) 253.73,40.7 253.73,40.83 253.37,41.19 253.14,41.19 253.07,41.26 253.07,41.36 253.12,41.41 U38.35
  IN1 w0.089: v2(253.92,40.51) 253.75,40.35 253.75,39.59 252.64,38.47 252.64,37.12 v2(252.84,36.92)
SD_UHS2_D1N: length 31
  TOP w0.089: RE4.2 251.23,34.4 LE2.3 251.23,33.71 250.88,33.36 250.88,33.16 v2(251.07,32.97) ; v2(257.32,11.75) 257.16,11.58 257.16,10.46 257.77,9.85 JSD1.15
  IN1 w0.089: v2(257.32,11.75) 257.16,11.91 257.16,17.06 253.93,20.29 253.93,29.15 253.37,29.71 253.37,29.84 253.73,30.2 253.73,30.59 253.45,30.87 253.06,30.87 252.7,30.51 252.57,30.51 252.38,30.7 252.38,30.83 252.69,31.13 252.69,31.52 252.41,31.81 252.02,31.81 251.71,31.5 251.58,31.5 250.99,32.1 250.99,32.88 v2(251.07,32.97)
SD_UHS2_D1N_R: length 7.6
  TOP w0.089: v2(251.07,36.87) 250.96,36.76 250.96,36.55 251.23,36.28 LE2.4 251.23,35.48 RE4.1
  TOP w0.102: U38.33 252.32,41.36 252.38,41.3 252.38,40.93 v2(252.72,40.58)
  IN1 w0.089: v2(252.72,40.58) 252.51,40.37 252.51,39.99 250.91,38.39 250.91,37.03 v2(251.07,36.87)
SD_UHS2_D1P: length 31
  TOP w0.089: v2(250.49,32.97) 250.59,33.07 250.59,33.45 250.38,33.66 LE2.2 250.38,34.4 RE3.2 ; JSD1.16 256.27,9.86 256.87,10.45 256.87,11.62 v2(256.74,11.75)
  IN1 w0.089: v2(256.74,11.75) 256.9,11.91 256.9,16.95 253.68,20.18 253.68,29.04 253.12,29.61 253.12,29.94 253.48,30.3 253.48,30.48 253.34,30.62 253.16,30.62 252.8,30.26 252.47,30.26 252.13,30.6 252.13,30.93 252.43,31.24 252.43,31.42 252.3,31.55 252.12,31.55 251.81,31.25 251.48,31.25 250.73,31.99 250.73,32.73 v2(250.49,32.97)
SD_UHS2_D1P_R: length 7.5
  TOP w0.089: v2(252.14,40.58) 252.18,40.62 252.18,41.08 251.92,41.35 ; RE3.1 250.38,35.48 LE2.1 250.38,36.23 250.67,36.51 250.67,36.69 v2(250.49,36.87)
  TOP w0.102: U38.32 251.92,41.35
  IN1 w0.089: v2(252.14,40.58) 252.26,40.46 252.26,40.09 250.66,38.49 250.66,37.03 v2(250.49,36.87)
SD_WPI: length 19.1
  TOP w0.102: v2(247.25,32.12) 247.3,32.12 247.91,31.51 249.6,31.51 249.85,31.26 JSD1.18 ; U38.20 247.47,44.24 v2(247.38,44.34)
  IN1 w0.102: v2(247.25,32.12) 247.25,32.22 247.26,32.23 247.26,33.25 246.02,34.49 246.02,39.62 247.49,41.1 247.49,44.22 v2(247.38,44.34)
SDA: length 4
  BOTTOM w0.102: PU500.31 119.25,152.3 118.98,152.03 v1(118.98,151.14) 118.98,150.27 PR500.1 PR505.2
SDOUT_TERM: length 2.3
  BOTTOM w0.102: R754.1 C678.1 v1(262.95,141.93)
SEL: length 12.7
  TOP w0.102: v2(324.06,216.97) 324.63,216.97 v1(324.72,217.06)
  IN4 w0.102: v2(322.7,213.55) 322.7,215.61 v2(324.06,216.97)
  BOTTOM w0.102: U2.4 323.96,217.07 v2(324.06,216.97) ; Q59.1 316.78,212.62 R1614.1 318.73,213.45 322.6,213.45 v2(322.7,213.55)
SIO_14M: length 4.2
  TOP w0.089: v2(217.71,72.05) 217.81,72.05 218.31,71.54 218.31,70.95 219.19,70.07 220.14,70.07 RH157.2
  BOTTOM w0.089: v2(217.71,72.05) 217.71,71.96 217.46,71.71 UH1.F38
SIO_A20GATE: length 235.9
  TOP w0.089: 195.87,69.3 195.91,69.34 197.32,69.34 198.63,70.64 198.87,70.64 199.85,71.61 v2(200.47,71.61)
  TOP w0.102: v2(281.27,111.66) U51.A45 ; v2(262.59,110.26) v1(263.5,110.26) ; 195.87,69.3 195.32,68.75 194.39,68.75 193.66,68.02 191.87,68.02 RH193.2
  IN2 w0.127: v2(281.27,111.66) 280.84,111.24 280.41,111.24 280.29,111.11 279.73,111.11 279.36,111.48 276.78,111.48 276.52,111.21 275.69,111.21 275.6,111.3 275.1,111.3 274.5,111.9 269.99,111.9 269.52,111.43 268.85,111.43 267.17,109.74 266.34,109.74 266.04,110.05 262.81,110.05 v2(262.59,110.26)
  IN3 w0.089: v2(200.47,71.61) 200.54,71.55 200.54,69.86 200.26,69.59 200.26,67.42 197.86,65.02
  IN3 w0.127: v2(262.59,110.26) 262.78,110.07 262.78,100.84 261.31,99.37 261.31,93.54 260.36,92.59 260.36,68.67 256.92,65.23 256.92,56.49 256.66,56.23 256.66,53.3 256.85,53.11 256.85,47.63 257.44,47.04 257.65,47.04 257.65,47.04 257.92,47.04 259.95,45 259.95,42.25 261.03,41.17 261.03,32.15 247.43,18.55 230.75,18.55 229.82,19.48 227.88,19.48 220.77,26.59 220.77,28.77 217.12,32.43 215.93,32.43 211.29,37.07 202.5,37.07 201.32,38.25 199.97,38.25 197.18,41.04 197.18,43.59 188.82,51.95 188.82,57.21 192.32,60.71 192.79,60.71 194.79,62.7 195.66,62.7 197.79,64.84 197.79,64.95 197.86,65.02
  BOTTOM w0.089: v2(200.47,71.61) 200.83,71.61 UH1.AN10
SIO_EXT_SCI#: length 234.2
  TOP w0.102: v2(187.54,64.01) 187.73,64.2 RH204.1 188.89,64.41 188.89,64.59 RH195.1 ; v2(281.53,118.59) 281.55,118.57 281.55,117.82 281.71,117.66 U51.A33
  IN2 w0.127: v2(261.73,115.96) 264,115.96 265.92,117.88 267.8,117.88 268.61,118.69 269.67,118.69 271.55,116.81 276.81,116.81 277.85,117.86 278.49,117.86 279.23,118.59 v2(281.53,118.59)
  IN3 w0.127: v2(261.73,115.96) 261.87,116.1 261.87,118.65 262.42,119.19 263,119.19 263.23,118.97 263.23,110.84 263.04,110.65 263.04,100.74 261.56,99.26 261.56,93.44 260.61,92.48 260.61,68.57 257.17,65.13 257.17,56.38 256.92,56.13 256.92,53.4 257.11,53.21 257.11,47.73 257.55,47.29 258.2,47.29 260.21,45.29 260.21,42.35 261.29,41.27 261.29,32.05 247.43,18.2 230.59,18.2 229.6,19.19 227.81,19.19 219.56,27.44 216.11,27.44 215.51,28.05 215.51,32.49 211.26,36.74 202.29,36.74 201.2,37.84 199.51,37.84 196.36,40.98 196.36,43.98 185.27,55.07 185.27,60.84 186.61,62.18 186.61,63.67 186.95,64.01 v2(187.54,64.01)
  BOTTOM w0.102: v2(281.53,118.59) 280.95,118.59 v1(280.93,118.61)
SIO_EXT_SMI#: length 180.5
  TOP w0.102: RH10.1 275.55,83.45 274.96,84.04 274.56,84.04 274.09,83.57 272.78,83.57 272.58,83.36 v2(272.32,83.36) ; U51.A6 293.48,112.66 v2(293.61,112.53)
  IN1 w0.089: 203.69,61.48 v2(203.7,61.49)
  IN1 w0.102: 203.69,61.48 203.26,61.05 203.26,60.29 202.92,59.94 202.22,59.94 201.84,59.56 v2(201.25,59.56) 201.25,58.23 201.63,57.85 201.63,56.42 202.17,55.88 202.17,55.21 201.64,54.68 201.64,54.11 200.93,53.4 200.93,51.78 201.38,51.33 201.38,49.03 205.61,44.81 215.99,44.81 222.36,51.17 226.08,51.17 226.32,50.93 230.06,50.93 231,51.87 235,51.87 236.87,53.73 236.87,54.87 239.41,57.42 240.1,57.42 241.54,58.85 241.54,59.54 243.24,61.24 245.18,61.24 246.93,62.99 253.71,62.99 255.58,64.86 263.33,72.61 263.33,75.71 266.61,78.99 266.61,85.09 v2(265.58,86.12)
  IN2 w0.127: v2(276.13,112.14) 275.99,112.28 275.49,112.28 275.06,112.71 269.45,112.71 v2(269.12,112.38) ; v2(272.32,83.36) 271.85,83.36 271.45,83.77 271.45,85.7 270.9,86.25 265.81,86.25 265.68,86.12 v2(265.58,86.12)
  IN3 w0.127: v2(293.61,112.53) 292.67,112.53 292.45,112.31 290.43,112.31 289.55,111.44 288.7,111.44 288.32,111.06 288.32,109.75 288.07,109.5 281.83,109.5 281.24,110.08 280.23,110.08 278.39,111.92 276.44,111.92 276.22,112.14 v2(276.13,112.14)
  BOTTOM w0.089: v2(203.7,61.49) 203.81,61.59 203.81,61.96 204.46,62.62 UH1.M1
  BOTTOM w0.102: RPH1.2 201.25,58.15 v2(201.25,59.56) ; v2(269.12,112.38) 269.62,111.89 269.62,109.58 269.69,109.51 v1(269.69,102.25) 269.69,101.99 268.11,100.41 268.11,97.64 266.58,96.11 266.58,87.03 265.67,86.12 v2(265.58,86.12)
SIO_EXT_WAKE#: length 192.8
  TOP w0.089: v2(200.83,62.85) 200.83,62.89 200.35,63.37 199.51,63.37
  TOP w0.102: U46.B49 263.95,49.64 264.07,49.75 264.84,49.75 265.21,49.38 v2(265.21,49.37) ; v2(199.09,55.21) 199.09,55.05 200.04,54.1 RH24.1 ; 199.51,63.37 199.13,63.37 v1(198.84,63.09) 198.33,62.58 198.33,62.44 RPH9.3
  IN2 w0.127: v2(256.73,71.01) 256.78,71.01 256.8,71.03 v2(273.18,71.03)
  IN3 w0.089: v2(200.83,62.85) 200.43,62.45
  IN3 w0.127: v2(273.18,71.03) 272.73,70.58 272.73,62.83 272.54,62.64 272.54,53.46 272.28,53.2 270.79,53.2 270.26,52.68 270.26,50.98 269.89,50.6 268.44,50.6 267.51,49.67 267.51,48.31 267.17,47.97 265.88,47.97 265.64,48.21 265.64,48.94 v2(265.21,49.37) ; v2(256.73,71.01) 256,70.28 256,70.14 251.58,65.73 251.58,60.92 252.3,60.21 252.3,56.53 252.37,56.46 252.37,53.53 251.51,52.67 251.51,50.91 250.06,49.46 250.06,48.76 250.84,47.98 252.39,47.98 253.08,47.29 253.08,42.22 255.25,40.04 255.25,37.55 254.25,36.55 254.25,33.32 252.72,31.79 251.32,31.79 248.79,29.25 248.79,27.69 243.46,22.36 233.14,22.36 232.01,23.49 229.1,23.49 224.46,28.14 224.46,30.44 220,34.9 211.3,43.6 205.12,43.6 201.78,46.94 199.85,46.94 197.5,49.3 197.5,51 197.54,51.04 197.54,54.95 197.78,55.19 199.07,55.19 v2(199.09,55.21) 199.12,55.24 199.12,55.79 198.67,56.24 198.67,58.34 199.23,58.9 199.23,61.25 200.43,62.45
  BOTTOM w0.089: 201.26,64.13 202.15,65.02 UH1.Y1
  BOTTOM w0.102: v2(200.83,62.85) 200.72,62.96 200.72,63.59 201.26,64.13
SIO_PWRBTN#: length 166.1
  TOP w0.102: v2(286.49,110.02) 286.47,109.99 U51.B58 ; v2(252.42,109.14) 252.93,109.14 v1(253.4,109.61) ; v2(204.32,58.92) 204.42,58.92 RH108.1
  IN1 w0.102: v2(204.32,58.92) 203.08,58.92 202.24,58.08 202.24,56.77 202.7,56.31 202.7,54.18 202.38,53.86 202.04,53.86 201.67,53.49 201.67,52.62 202.47,51.82 202.47,51 203.08,50.39 203.08,49.15 206.23,46 211.04,46 212.57,47.52 217,47.52 221.88,52.4 v2(225.15,52.4)
  IN2 w0.127: v2(225.15,52.4) 225.15,52.59 225.65,53.09 228.42,53.09 229.45,52.06 244.86,52.06 245.45,51.47 248.99,51.47 v2(249.25,51.22) ; v2(286.49,110.02) 286.24,110.02 285.78,109.56 282.95,109.56 282.88,109.63 279.9,109.63 279.69,109.84 279.2,109.84 279.02,110.02 278.66,110.02 278.27,109.63 277.6,109.63 277.35,109.37 275.81,109.37 275.24,109.94 274.66,109.94 274.05,110.56 271.59,110.56 269.77,108.74 266.59,108.74 265.79,109.54 263.68,109.54 263.4,109.26 262.84,109.26 262.83,109.27 252.55,109.27 v2(252.42,109.14)
  IN3 w0.127: v2(249.25,51.22) 248.98,51.49 248.98,53.48 249.45,53.95 249.45,57.66 250.03,58.24 250.03,58.56 249.25,59.35 249.25,60.26 249.83,60.84 249.83,66.31 253.47,69.96 253.47,81.81 252.37,82.92 252.37,90.63 v2(253.36,91.62)
  BOTTOM w0.102: v2(252.42,109.14) 253.22,108.34 253.22,104.53 252.71,104.03 252.71,98.31 251.93,97.52 251.93,96.68 253.22,95.39 253.22,91.76 v2(253.36,91.62)
SIO_PWRBTN#_R: length 268.3
  TOP w0.089: 204.68,60.5 v2(204.68,61.35)
  TOP w0.102: 204.68,60.5 204.68,60.47 RH108.2 ; v2(115.93,111.89) 115.93,111.77 v1(115.38,111.21) 115.07,111.21 114.77,111.52 RC21.1 ; RH28.1 274.15,81.42 v2(273.66,81.91)
  IN2 w0.089: v2(204.68,61.35) 204.01,62.01 203.54,62.01 203.35,61.82
  IN2 w0.127: v2(243.8,71.41) 244.8,72.42 254.76,72.42 254.91,72.26 271.29,72.26 274.1,75.07 274.1,81.47 v2(273.66,81.91) ; v2(115.93,111.89) 113.34,109.29 113.34,86.45 113.8,85.99 117.5,85.99 118.39,85.1 118.39,81.08 119.12,80.35 119.12,66.34 121.59,63.87 121.59,55.6 126.34,50.85 189.67,50.85 190.51,51.69 192.07,51.69 194.32,49.44 196.65,49.44 197.13,49.92 197.13,50.27 196.84,50.56 196.72,50.56 194.77,52.51 194.77,53.44 195.91,54.58 197.8,54.58 198.03,54.35 198.82,54.35 199.52,55.05 199.52,56.76 200.95,58.19 200.95,58.38 202.46,59.89 202.97,59.89 203.16,60.08 203.16,61.63 203.35,61.82
  IN3 w0.089: 209.58,58.99 209.13,58.99 208.96,58.82 207.63,58.82 207.48,58.98 207.48,60.1 206.23,61.35 v2(204.68,61.35)
  IN3 w0.127: v2(243.8,71.41) 243.82,71.39 243.82,71.2 243.44,70.82 243.44,60.39 243.16,60.11 243.16,59.9 243.16,59.69 243.17,59.69 243.17,58.63 238.36,53.82 237.24,53.82 235.76,52.35 229.7,52.35 228.57,53.48 221.44,53.48 220.69,52.73 219.1,52.73 217.27,54.56 217.27,54.94 215.55,56.65 214.59,56.65 214.31,56.38 213.42,56.38 212.77,57.02 211.63,57.02 209.66,58.99 209.58,58.99
  BOTTOM w0.089: UH1.K1 205.03,61.98 204.68,61.63 v2(204.68,61.35)
SIO_RCIN#: length 300.7
  TOP w0.089: 194.07,71.1 v1(194.14,71.16) 194.42,71.44 195,71.44 195.94,70.5 197.76,70.5 198.67,71.4 v2(198.78,71.4)
  TOP w0.102: v2(285.95,120.22) 285.95,120.14 286.22,119.88 U51.A27 ; RH194.2 190.7,69.16 192.54,71.01 193.98,71.01 194.07,71.1
  IN1 w0.102: v2(213.65,26.43) 204.31,26.43 201.27,29.48 192.31,29.48 189.87,27.04 189.87,25.18 v2(190.2,24.85)
  IN3 w0.089: 195.16,76.06 195.71,75.51 196.8,75.51 198.32,73.98 198.32,72.62 198.78,72.16 v2(198.78,71.4)
  IN3 w0.127: v2(278.35,97.29) 278.23,97.29 277.48,96.54 277.48,66.1 282.28,61.3 282.28,49.36 273.65,40.74 273.16,40.74 271.16,38.74 267.86,38.74 265.48,36.35 265.48,30.31 251.83,16.67 225.21,16.67 221.8,20.08 218.6,20.08 213.65,25.04 v2(213.65,26.43) ; 195.16,76.06 194.57,76.64 194.57,76.97 189.85,81.7 186.2,81.7 184.13,79.63 184.13,77.47 177.2,70.54 177.2,57.88 191.55,43.53 191.55,35.7 190.03,34.18 190.03,25.03 v2(190.2,24.85)
  BOTTOM w0.089: v2(198.78,71.4) 198.78,71.13 UH1.AT6
  BOTTOM w0.102: v2(278.35,97.29) 277.54,98.11 277.54,99.68 279.57,101.71 280.1,101.71 280.35,101.96 282.39,101.96 282.96,102.53 282.96,102.72 281.22,104.46 281.22,105.42 281.81,106.01 283.19,106.01 283.75,106.57 284.19,106.57 285.01,107.39 285.01,110.88 286.18,112.05 286.18,113.89 283.05,117.02 283.05,118.19 283.7,118.85 284.7,118.85 285.95,120.09 v2(285.95,120.22)
SIO_SLP_A#: length 378.2
  TOP w0.102: v2(313.56,113.45) 313.55,113.44 JAPS1.6 ; PR303.1 v4(238.11,3.31) ; v2(270.25,49.59) 269.69,49.02 U46.B63 ; v2(274.85,38.84) v1(274.85,39.47)
  IN1 w0.102: v2(313.56,113.45) 311.79,115.21 311.79,135.86 312.56,136.63 313.11,136.63 318.25,141.76 318.25,142.72 323.16,147.64 323.16,158.1 323.05,158.21 323.05,158.55 324.42,159.92 324.42,167.75 323.56,168.61 323.56,169.41 322.93,170.04 322.93,170.2 v2(322.93,170.2)
  IN2 w0.127: v2(270.25,49.59) 269.98,49.59 269.38,50.19 266.81,50.19 265.34,51.66 264.08,51.66 264.03,51.71 262.92,51.71 262.24,52.4 258.81,52.4 258.21,51.8 255.46,51.8 254.41,50.76 248.9,50.76 248.73,50.58 247.66,50.58 247.14,51.1 244.5,51.1 243.8,51.8 228.42,51.8 227.47,52.76 227.16,52.76 v2(226.65,52.25)
  IN3 w0.089: 208.58,57.99 207.66,57.99 207.37,58.28 206.98,58.28 206.17,59.09 206.17,60.01 v2(206.19,60.03)
  IN3 w0.127: v2(307.98,198.24) 308.97,198.24 310.46,196.75 312.67,196.75 317.09,192.33 317.09,191.58 320.12,188.54 320.12,187.34 319.64,186.85 319.64,183.29 320.7,182.23 320.7,181.51 320.1,180.91 320.1,176.02 323.4,172.72 323.4,170.61 322.99,170.2 v2(322.93,170.2) ; v2(270.25,49.59) 269.81,49.15 269.81,48.51 270.1,48.22 270.76,48.22 271.29,47.69 271.29,47.61 272.56,46.34 274.84,46.34 v2(275.09,46.09) ; v2(274.85,38.84) 274.05,38.04 272.34,38.04 271.28,36.98 271.28,32.84 269.63,31.19 269.63,28.8 245.93,5.11 239.9,5.11 v4(238.11,3.31) ; v2(226.65,52.25) 226.65,51.8 226.22,51.37 218.85,51.37 216.38,53.84 214.4,53.84 213.6,54.65 212.24,54.65 211.01,55.88 211.01,56.25 209.27,57.99 208.58,57.99
  IN4 w0.102: v2(274.85,38.84) 275.49,39.48 275.49,45 275.09,45.4 v2(275.09,46.09) 275.09,46.37 276.91,48.18 276.91,52.21 281.94,57.24 281.94,65.56 279.56,67.94 279.56,91.16 287.97,99.57 300.05,99.57 313.56,113.08 v2(313.56,113.45)
  BOTTOM w0.089: UH1.F3 206.45,61.2 206.45,60.88 206.23,60.66 206.23,60.07 v2(206.19,60.03) 206.19,59.59 207.07,58.71 207.07,58.1
  BOTTOM w0.102: 207.07,58.1 207.07,57.89 208.25,56.71 208.25,55.83 UH2.1 ; R1615.1 304,186.41 308.28,186.41 308.62,186.76 308.62,190.97 306.59,193 306.59,195.24 308.33,196.98 308.33,197.89 v2(307.98,198.24)
SIO_SLP_LAN#: length 321.4
  TOP w0.102: v2(275.17,50.33) 275.14,50.33 274.58,50.89 U46.A5
  IN2 w0.089: 207.69,57.48 207.69,58.85 207.48,59.05 207.48,60.05 206.59,60.95 206.59,61.28 207.31,62 v2(207.8,62)
  IN2 w0.127: v2(282.68,169.43) 282.65,169.47 281.45,169.47 279.03,167.04 279.03,166.07 277.4,164.44 277.4,158.15 271.15,151.9 271.15,149.02 270.79,148.65 v2(270.79,148.23) ; v2(253.97,36.89) 254.19,36.89 256.12,38.82 257.34,38.82 261.54,43.03 261.54,44.06 v2(261.5,44.1) ; v2(198.37,50.09) 198.37,50.36 201.6,53.59 203.03,53.59 204.71,51.92 206.06,51.92 208.31,54.18 208.31,54.71 208.16,54.86 208.16,56.8 207.69,57.27 207.69,57.48
  IN3 w0.127: v2(282.68,169.43) 282.68,169.77 283.04,170.12 287.42,170.12 288.64,171.34 288.64,174.89 290.25,176.49 290.25,180.96 289.35,181.85 289.35,184.8 294.85,190.3 v2(295.45,190.3) ; v2(275.01,142.53) 275.01,142.74 274.84,142.91 274.84,143.16 271.95,146.05 271.94,146.05 270.79,147.21 v2(270.79,148.23) ; v2(198.37,50.09) 198.37,49.68 198.31,49.62 198.31,48.85 199.96,47.2 201.89,47.2 205.23,43.85 211.4,43.85 224.72,30.53 224.72,28.23 229.15,23.8 232.08,23.8 233.27,22.62 243.36,22.62 248.53,27.8 248.53,29.36 251.22,32.04 251.46,32.04 252,32.58 252,33 253.97,34.97 v2(253.97,36.89)
  BOTTOM w0.089: UH1.G5 207.65,62.15 v2(207.8,62)
  BOTTOM w0.102: v2(198.37,50.09) 198.37,50.34 198.51,50.48 RH80.2 ; v2(275.01,142.53) 275,142.53 274.35,143.18 273.36,143.18 272.98,142.8 272.98,137.42 274.21,136.19 274.21,131.89 272.14,129.82 272.14,127.63 271.86,127.35 271.86,126.89 263.9,118.93 263.9,114.1 258.48,108.67 257.4,108.67 256.13,107.4 256.13,97.83 256.66,97.29 256.66,81.44 256.6,81.38 256.6,75.41 258.92,73.08 258.92,63.91 259.41,63.43 259.41,58.95 259.15,58.69 259.15,56.06 260.17,55.05 260.17,48.41 260.32,48.26 260.32,45.01 261.24,44.1 v2(261.5,44.1) 264.02,41.58 270.95,41.58 272.69,43.32 v1(272.69,48.27) 272.69,48.84 273.46,49.62 274.46,49.62 v2(275.17,50.33) ; U102.5 301.26,190.18 301.15,190.07 301.15,188.5 300.78,188.13 297.62,188.13 v2(295.45,190.3)
SIO_SLP_S3#: length 622.1
  TOP w0.102: v2(264.98,37.38) 265.12,37.52 266.23,37.52 266.49,37.78 R734.1 ; v4(235.86,106.74) 235.86,107.75 PR403.1 ; v2(227.23,52.2) 227.23,52.19 227.31,52.11 227.31,51.96 228.96,50.3 237.15,50.3 238.09,49.36 239.56,49.36 243.2,45.72 v2(243.2,45.43) ; JAPS1.2 302.28,111.44 v2(302.07,111.23) ; v2(322.33,170.33) 322.07,170.33 321.99,170.26 v1(318.85,170.26) 317.91,170.26 317.02,169.37 314.09,169.37 313.47,168.74 PR607.1 ; RC98.1 145.03,69.02 145.87,69.86 v2(146.79,69.86) ; v2(271.38,49.34) 270.85,48.81 270.85,48.5 270.69,48.34 U46.B65
  IN1 w0.102: v2(271.38,49.34) 270.92,48.89 270.92,47.27 271.31,46.89 271.31,43.73 271.55,43.49 271.55,41.56 270.99,41.01 270.21,41.01 270.02,40.82 270.02,39.06 268.91,37.95 266.66,37.95 266.11,37.4 265.01,37.4 v2(264.98,37.38) ; v2(242.39,39.53) 242.39,40.03 242.26,40.15 242.26,44.49 v2(243.2,45.43)
  IN2 w0.127: v2(302.07,111.23) 302.2,111.23 302.88,111.9 305.04,111.9 305.29,111.65 305.29,108.47 302.74,105.92 294.12,105.92 293.93,106.11 292.32,106.11 291.85,106.58 287.62,106.58 287.56,106.52 287.56,106.51 287.01,105.96 283.7,105.96 283.54,106.12 282.25,106.12 281.34,107.04 279.93,107.04 279.68,107.29 278.69,107.29 278.42,107.02 277.2,107.02 276.84,107.38 275.22,107.38 274.61,106.77 256.73,106.77 256.33,106.37 251.46,106.37 251.22,106.13 249.11,106.13 248.24,107 246.74,107 243.89,109.85 239.49,109.85 236.38,106.74 v4(235.86,106.74) ; v2(264.98,37.38) 264.51,37.85 258.81,37.85 258.37,37.4 256.71,37.4 254.4,35.09 245.74,35.09 242.39,38.45 v2(242.39,39.53) ; v2(118.11,68.57) 118.03,68.49 118.03,54.13 127.82,44.34 127.82,32.41 128.87,31.36 190.81,31.36 200.36,40.91 205.72,40.91 215.44,31.19 226.97,31.19 227.54,31.76 229.71,31.76 231.86,29.62 231.86,27.31 232.9,26.28 238.43,26.28 239,26.85 239,29.04 v2(241.75,31.8)
  IN3 w0.089: 208.9,58.31 208.59,58.31 208.48,58.42 207.49,58.42 207.42,58.49 207.06,58.49 206.43,59.12 206.43,59.7 206.62,59.89 206.62,60.3 206.3,60.63 v2(205.39,60.63)
  IN3 w0.127: v2(319.71,187.65) 319.39,187.34 319.39,183.04 319.83,182.59 319.83,175.93 321.84,173.92 321.84,171.16 321.9,171.1 321.9,170.71 322.26,170.36 322.31,170.36 v2(322.33,170.33) 322.33,166.53 324.51,164.36 326.09,164.36 327.08,163.37 327.08,156.18 326.35,155.44 326.35,141.31 323.12,138.09 323.12,136.05 322.31,135.24 320.71,135.24 318.09,132.63 318.09,130.52 316.16,128.59 314.02,128.59 306.24,120.81 306.24,119.39 301.05,114.2 301.05,112.15 301.98,111.23 v2(302.07,111.23) ; 208.9,58.31 209.48,58.31 211.29,56.5 211.29,55.96 212.32,54.93 213.72,54.93 214.55,54.1 216.5,54.1 218.96,51.65 225.76,51.65 226.23,52.12 226.23,52.45 226.45,52.67 226.85,52.67 227.07,52.45 227.07,52.4 227.22,52.25 227.22,52.21 v2(227.23,52.2)
  IN4 w0.102: v2(317.48,217.82) 317.48,217.65 318.25,216.88 318.25,214.14 319.45,212.95 319.45,211 319.19,210.74 319.19,203.29 318.24,202.34 318.24,195.23 319.24,194.23 319.24,192.22 318.78,191.76 318.11,191.76 317.74,191.39 317.74,189.64 319.49,187.88 319.49,187.86 319.69,187.65 v2(319.71,187.65)
  BOTTOM w0.089: v2(205.39,60.63) 205.61,60.84 UH1.H1
  BOTTOM w0.102: v2(317.48,217.82) 317.48,217.53 317.95,217.06 R153.1 ; v4(235.86,106.74) 235.35,106.24 235.35,97.4 233.46,95.5 233.46,86.56 227.26,80.37 227.26,73.9 230.25,70.92 230.25,67.45 229.35,66.55 229.35,56.15 227.23,54.03 v2(227.23,52.2) ; v2(242.39,39.53) 242.3,39.63 242.3,39.77 241.97,40.09 241.64,40.09 240.76,39.22 240.76,37.11 240.43,36.77 240.43,33.13 v2(241.75,31.8) 241.75,28.22 241.94,28.03 241.94,24.23 236.43,18.72 231.34,18.72 230.86,19.2 R735.1 ; v2(118.11,68.57) 118.41,68.87 136.43,68.87 139.25,71.69 144.19,71.69 146.02,69.86 v2(146.79,69.86)
SIO_SLP_S4#: length 421.7
  TOP w0.102: v2(172.86,161.12) 172.63,161.12 171.56,162.19 R1608.1 ; JAPS1.5 304.88,112.94 305.29,112.53 305.29,106.03 306.17,105.16 v2(306.27,105.16) ; T70.1 209.1,57.85 208.46,57.85 v2(208.15,57.54) ; U46.A61 270.44,46.59 v2(270.64,46.39) ; PR206.1 v4(216.01,13.09)
  IN2 w0.127: v2(243.02,46.62) 245.63,46.62 246.05,47.04 255.65,47.04 256.88,45.81 261.27,45.81 261.69,45.39 262.63,45.39 263.41,44.61 269.52,44.61 269.85,44.95 269.85,46.16 270.07,46.39 v2(270.64,46.39) ; v2(306.27,105.16) 305.79,104.67 304.08,104.67 303.79,104.97 293.4,104.97 293.26,105.1 290.33,105.1 290.01,105.42 288.09,105.42 287.38,104.71 287.36,104.71 286.68,104.03 285.71,104.03 283.94,102.26 283.38,102.26 282.63,103.01 280.56,103.01 279.31,104.25 278.29,104.25 278.2,104.16 258.78,104.16 258.12,104.83 250.05,104.83 248.29,106.59 246.57,106.59 245.21,107.95 v2(245,107.95)
  IN3 w0.127: v2(245,107.95) 244.99,107.94 244.99,107.62 244.24,106.87 244.24,104.02 242.28,102.06 233.83,102.06 231.16,104.72 228.3,104.72 227.66,104.08 223.2,104.08 217.75,109.52 195.67,109.52 194.47,110.72 187.14,110.72 184.56,113.3 184.56,119.88 182.88,121.56 182.88,139.94 182.35,140.47 181.89,140.47 181.29,141.07 181.29,141.97 181.71,142.39 181.71,143.69 180.17,145.23 180.17,147.07 175.1,152.14 175.1,158.9 172.88,161.12 v2(172.86,161.12) ; v4(216.01,13.09) 216.01,13.27 217.37,14.63 217.37,19.48 212.08,24.77 212.08,26.97 212.48,27.37 212.48,28.5 209.79,31.19 205.41,31.19 v2(203.97,32.63) ; v2(243.02,46.62) 242.54,46.62 240.13,49.03 233.29,49.03 231.78,47.52 215.37,47.52 214.97,47.92 210.4,47.92 210.15,47.67 v2(209.13,47.67) 208.97,47.83 208.97,49.1 207.86,50.21 207.86,53.9 208.34,54.38 208.34,55.05 207.91,55.49 207.91,57.3 v2(208.15,57.54) ; v2(270.64,46.39) 270.64,46.07 271.23,45.48 274.2,45.48 274.39,45.29 v2(276.26,45.29)
  IN4 w0.102: v2(306.27,105.16) 305.42,104.3 305.42,103.72 301.02,99.33 288.1,99.33 279.79,91.02 279.79,68.04 282.16,65.66 282.16,57.14 277.26,52.24 277.26,46.29 v2(276.26,45.29)
  BOTTOM w0.089: 208.15,57.55 208.15,58.01 209.64,59.51 209.64,60.57 209.32,60.89 209.32,61.21 UH1.C6
  BOTTOM w0.102: 208.15,57.55 v2(208.15,57.54) ; v2(203.97,32.63) 203.97,33.39 210.16,39.58 210.16,40.36 211.1,41.29 211.1,41.71 210.82,41.99 210.82,44.68 209.37,46.13 209.37,47.44 v2(209.13,47.67)
SIO_SLP_S5#: length 213.9
  TOP w0.089: v2(204.51,66.59) 204.96,66.59 T69.1
  TOP w0.102: U51.A18 290.72,119.97 v2(290.88,120.13) ; R23.1 300.57,113.58 299.91,114.24 299.37,114.24 v2(299.22,114.39)
  IN2 w0.127: v2(290.88,120.13) 288.88,122.13 288.88,123.35 288.49,123.75 288.49,124.05 288.17,124.37 285.73,124.37 285.25,124.85 282.79,124.85 282.51,124.57 280.73,124.57 280.55,124.4 278.66,124.4 277.87,123.61 276.28,123.61 276.04,123.37 272.11,123.37 271.2,122.47 v2(266.86,122.47)
  IN4 w0.089: 203.18,61.99 203.55,61.99 203.94,62.38 203.94,65.29 204.71,66.05 204.71,66.39 v2(204.51,66.59)
  IN4 w0.102: v2(266.86,122.47) 266.94,122.39 266.94,117.82 267.57,117.18 267.57,115.3 267.24,114.97 267.24,110.65 266.84,110.24 266.84,104.28 265.43,102.87 265.43,101.04 264.83,100.44 264.83,99.7 261.96,96.83 261.96,96.45 257.44,91.93 257.44,71.95 257.95,71.44 257.95,55.62 257.95,54.43 257.01,53.49 257.01,44.67 255.7,43.36 254.71,43.36 252.9,41.54 246.38,41.54 244,43.92 242.91,43.92 240.79,46.04 240.79,49.46 239.16,51.09 226.45,51.09 226.04,51.5 212.15,51.5 210.24,49.59 207.83,49.59 206.11,51.31 201.72,51.31 199.8,53.23 199.5,53.23 198.22,54.5 198.22,55.2 198.06,55.36 198.06,55.98 198.62,56.54 199.28,56.54 200.44,57.69 200.44,58.05 202.29,59.91 202.29,61.66 202.62,61.99 203.18,61.99
  BOTTOM w0.089: v2(204.51,66.59) 204.17,66.59 UH1.Y7
  BOTTOM w0.102: v2(299.22,114.39) 299.22,115.56 298.36,116.42 295.89,116.42 294.82,115.35 292.49,115.35 291.93,115.91 291.93,118.12 290.88,119.17 v2(290.88,120.13)
SIO_SLP_SUS#: length 117.9
  TOP w0.102: v2(271.37,50.88) 271.37,50.95 271.73,51.31 272.32,51.31 272.5,51.14 U46.B6
  IN2 w0.127: v2(276.23,44.7) 274.83,44.7 271.79,41.67 268.9,41.67 268.28,41.05 262.25,41.05 260.38,39.17 258.25,39.17 257.62,38.54 256.23,38.54 253.92,36.23 247.33,36.23 246.05,37.52 246.05,38.74 245,39.79 243.2,39.79 242.5,40.49 239.5,40.49 238.26,39.24 233.73,39.24 231.83,41.14 v2(231.83,41.69)
  IN3 w0.089: v2(205.79,59.55) 205.79,59.38
  IN3 w0.127: v2(231.83,41.69) 231.34,42.19 231.34,45.96 230.06,47.24 215.24,47.24 214.82,47.66 210.87,47.66 210.45,47.24 208.91,47.24 208.63,47.52 208.63,49.08 207.5,50.21 207.5,53.91 208.03,54.44 208.03,54.82 205.79,57.06 205.79,59.38 ; v2(276.23,44.7) 277.26,44.7 277.63,45.08 277.63,46.04 276.82,46.85 275.56,46.85 275.31,46.6 272.84,46.6 270.87,48.56 270.87,50.32 271.36,50.8 271.36,50.86 v2(271.37,50.88)
  BOTTOM w0.089: 206.68,58.5 206.68,58.66 205.79,59.55 v2(205.79,59.55) 205.73,59.61 205.73,60.14 206.03,60.44 206.03,60.95 UH1.F1
  BOTTOM w0.102: 206.68,58.5 206.68,57.8 208.02,56.45 208.02,55.52 206.36,53.86 T73.1
SIO_SLP_WLAN#: length 310.5
  TOP w0.102: v2(273.69,65.16) 274.02,64.83 279.78,64.83 280.31,64.3 280.59,64.3 v2(280.6,64.3) ; v2(274.44,55.04) 274.09,55.39 U46.A14
  IN2 w0.127: v2(243.83,79.86) 244.86,78.83 247.81,78.83 248.56,79.58 254.41,79.58 255.3,78.69 257.73,78.69 v2(257.92,78.5) ; v2(288.13,177.34) 288.82,178.03 289.63,178.03 290.57,177.09 295.03,177.09 295.27,176.85 311.06,176.85 311.93,175.98 311.93,175.62 v2(312.31,175.23) ; v2(273.69,68.31) 273.57,68.31 272.78,67.53 265.26,67.53 262.82,65.09 259.74,65.09 v2(259.62,65.2)
  IN3 w0.089: v2(206.99,61.12) 206.99,61.04 207.71,60.32 208.28,60.32 209.35,59.26 209.85,59.26
  IN3 w0.127: 209.85,59.26 210.04,59.26 211.3,58 214.27,58 214.78,57.49 215.47,57.49 217.83,55.14 217.83,54.8 219.13,53.5 220.5,53.5 221,54.01 229.78,54.01 230.83,52.95 235.64,52.95 237.02,54.33 238.12,54.33 241.68,57.89 241.68,59.34 242.59,60.25 242.59,72.87 243.82,74.11 243.82,79.85 v2(243.83,79.86) ; v2(286.75,184.68) 286.75,182.82 285.99,182.05 285.99,179.49 v2(288.13,177.34) ; v2(309.7,141.2) 309.86,141.2 310.37,141.7 311.98,141.7 316.34,146.06 316.34,147.74 317.33,148.73 317.33,153.14 318.79,154.6 318.79,160.23 317.78,161.24 317.78,165.62 316.96,166.43 316.96,168.94 317.05,169.02 317.05,170.6 316.67,170.98 316.67,171.42 315.63,172.46 314.26,172.46 312.31,174.41 v2(312.31,175.23)
  IN4 w0.102: v2(280.6,64.3) 280.6,64.3 280.48,64.43 280.48,65.32 278.42,67.38 278.42,91.7 282.56,95.85 282.56,97.76 283.39,98.59 283.45,98.59 286.85,101.99 288.41,101.99 289.81,103.4 298.49,103.4 301.99,106.9 303.42,106.9 309.28,112.76 309.28,126.05 308.25,127.08 308.25,138.34 309.7,139.79 v2(309.7,141.2)
  BOTTOM w0.089: UH1.D2 207.35,60.76 v2(206.99,61.12)
  BOTTOM w0.102: v2(280.6,64.3) 280.6,64.29 280.6,64.12 280.89,63.83 280.89,58.32 278.32,55.74 276.36,55.74 275.76,55.14 274.54,55.14 v2(274.44,55.04) ; v2(273.69,65.16) v2(273.69,68.31) ; v2(286.75,184.68) 286.37,184.3 R1633.1 ; v2(259.62,65.2) 259.39,65.43 v1(259.39,74.69) 258.38,75.7 258.38,78.04 v2(257.92,78.5)
SL_BAT_PRES#: length 6.2
  TOP w0.102: v1(154.06,175.37) 153.51,175.37 152.8,174.66 152.8,173.9 153.27,173.43 PR860.1
  TOP w0.254: PR860.1 153.17,173.32 153.17,171.64 152.75,171.22 PU800.21
SLEEVE: length 2
  TOP w0.127: Q327.3 351.32,170.27 351.61,169.98 v1(351.98,169.98)
  TOP w0.381: v2(351.32,171.44) Q327.3
  vias: v2(345.58,170.69) v2(346.16,170.68) v2(353.64,167.32) v2(353.65,166.74)
SLICE_BAT_ON: length 380.1
  TOP w0.254: PR888.1 48.36,189.92 48.45,189.83 48.45,188.4 47.97,187.93 PU803.1 47.97,186.42 47.14,185.58 47.14,184.43 48.37,183.2 PU801.2 48.37,181.76 48.03,181.42 v1(46.46,181.42) 46.02,181.42 45,180.4 v2(45,174.42) ; PR853.1 166.73,167.4 166.35,167.02 v2(165.46,167.02) ; v2(219.41,105.14) 219.41,100.82 224.58,95.66 229.26,95.66 231.76,93.16 231.76,91.48 230.7,90.42 230.7,89.79 232.05,88.44 232.05,85.85 233.14,84.76 236.48,84.76 PD803.2 237.35,83.89 238.13,83.11 v2(238.13,82.99) ; R791.2 263.13,60.08 263.43,59.78 263.67,59.78 v2(263.86,59.59) 264.12,59.59 264.94,58.77 U46.A31 ; v4(148.01,175.09) 148.01,174.61 148.19,174.43 PR850.2 ; PU807.1 61.81,172.75 v2(61.65,172.59)
  IN1 w0.254: v2(45,174.42) 45,174.34 48.35,170.99 60.05,170.99 61.3,172.24 61.31,172.24 v2(61.65,172.59)
  IN2 w0.254: v2(268.8,71.59) 268.8,71.56 268.78,71.54 254.29,71.54 253.18,70.43 252.92,70.43 252.19,69.71 250.53,69.71 249.63,70.61 238.59,70.61 238.11,71.09 v2(238.08,71.09) ; v2(172.89,157.82) 172.74,157.67 168.87,157.67 168.42,158.11 v2(168.04,158.11) ; v2(94.37,169.01) 94.37,169.25 94.74,169.62 112.91,169.62 113.33,170.04 116.8,170.04 117.32,170.56 117.77,170.56 v4(117.91,170.7) 118.42,171.21 120.29,171.21 121,171.92 122.47,171.92 122.77,171.61 130.31,171.61 131.14,170.79 143.84,170.79 148.01,174.97 v4(148.01,175.09) 148.06,175.15 149.92,175.15 150.55,175.78 153.79,175.78 154.86,174.71 156.87,174.71 157.93,175.78 159.46,175.78 159.7,175.54 161.83,175.54 163.34,177.05 v2(164.19,177.05) ; v2(267.27,60.16) 267.2,60.24 264.84,60.24 264.19,59.59 v2(263.86,59.59)
  IN3 w0.254: v2(172.89,157.82) 172.93,157.78 172.93,157.73 174.02,156.64 174.02,151.69 176.47,149.24 176.47,146.61 179.54,143.55 180.32,143.55 180.63,143.24 180.63,142.84 180.21,142.42 180.21,140.14 180.85,139.5 180.85,133.18 179.66,131.99 179.66,123.1 183.36,119.4 183.36,116.79 181.47,114.9 181.47,109.68 185.57,105.57 195.14,105.57 195.45,105.88 195.99,105.88 196.7,106.59 206.73,106.59 207.75,105.57 218.23,105.57 218.33,105.68 218.88,105.68 v2(219.41,105.14) ; v2(267.27,60.16) 267.41,60.3 267.41,64.44 267.96,64.99 267.96,66.8 268.78,67.61 268.78,69.29 268.33,69.74 268.33,70.9 268.85,71.42 268.85,71.53 268.8,71.58 v2(268.8,71.59) ; v2(238.13,82.99) 238.13,82.49 237.24,81.6 237.24,72.55 238.08,71.72 v2(238.08,71.09) ; v2(81.97,173.05) 81.66,172.73 77.07,172.73 76.75,173.05 74.57,173.05 73.7,173.92 70.07,173.92 67.94,171.79 62.45,171.79 v2(61.65,172.59)
  IN4 w0.254: v2(164.19,177.05) 163.83,176.68 163.83,175.87 164.59,175.11 164.59,169.86 166,168.45 166,167.41 165.6,167.02 ; v2(81.97,173.05) 84.13,173.05 88.34,168.85 91.23,168.85 91.94,169.55 94.07,169.55 94.37,169.25 v2(94.37,169.01) ; v2(165.46,167.02) 165.6,167.02 ; 165.6,167.02 165.6,165.76 168.3,163.07 168.3,158.37 v2(168.04,158.11)
  BOTTOM w0.254: v4(117.91,170.7) PD812.2 117.15,171.46 116.87,171.18 PR890.2
SLICE_BAT_ON_C2: length 7.6
  TOP w0.102: PR853.2 167.2,168.78 167.2,167.25 v1(166.53,166.57)
  TOP w0.203: 164.64,170 163.6,171.04 PU808.6
  TOP w0.254: 164.64,170 164.83,169.81 166.18,169.81 PR853.2
SLICE_BAT_PRES#: length 499
  TOP w0.102: R760.2 260.38,58.62 261.13,57.87 v2(261.31,57.87) ; U46.B33 264.69,56.9 264.88,56.71 264.88,56.22 v2(264.73,56.07)
  TOP w0.254: v2(253.4,170.5) 252.87,170.5 252.37,171 251.52,171 249.49,173.04 243.61,173.04 242.88,173.76 242.88,174.27 242.12,175.03 220.98,175.03 216.62,179.39 211.92,179.39 211.41,178.88 205.06,178.88 204.69,179.25 v2(204.69,179.54) ; PU801.1 v2(47.72,181.92) ; v2(98.95,171.3) 98.95,172.79 99.46,173.3 99.46,177.99 100.44,178.97 106.62,178.97 107.37,179.72 PR26.1 ; PR860.2 153.79,174.85 154.19,174.85 154.48,175.15 154.48,176.63 154.21,176.9 154.21,177.61 154.31,177.71 154.31,178.52 154.16,178.68 154.16,179.83 154.73,180.4 v2(155.56,180.4) ; v2(242.1,88.32) 241.68,87.9 PQ807.5 ; PU805.1 76.96,175.73 v1(77.61,176.38) 79.22,177.99 v2(79.22,178.66) ; v2(37.88,173.82) 37.91,173.82 37.2,174.53 PU809.1 ; v4(164.56,167.64) 164.56,168.2 PR851.1 ; PD820.1 146.1,174.63 v2(146.48,174.26) ; PR882.1 v2(57.97,172.47) 57.34,171.83 55.58,171.83 54.44,170.69 PQ827.2
  IN1 w0.254: v2(155.56,180.4) 155.62,180.34 155.62,176.96 152.16,173.5 147.23,173.5 v2(146.48,174.26) 145.96,174.26 142.54,170.84 132.04,170.84 130.65,172.22 120.17,172.22 119.75,171.81 117.5,171.81 116.65,170.95 113.71,170.95 113.03,170.28 107.06,170.28 106.62,170.71 100.03,170.71 99.45,171.3 v2(98.95,171.3) 98.37,170.71 92.05,170.71 91.52,171.23 89.43,171.23 82.79,177.88 79.51,177.88 79.22,178.17 v2(79.22,178.66) 79.22,179.27 78.66,179.83 76.11,179.83 75.59,179.31 72.2,179.31 71.3,180.21 60.45,180.21 59.86,179.62 54,179.62 53.08,180.54 49.1,180.54 v2(47.72,181.92)
  IN2 w0.127: v2(242.1,88.32) 242.17,88.39 242.18,88.39 245.88,92.1 253.12,92.1 254.29,93.27 256.19,93.27 256.59,92.87 270.29,92.87 v2(270.49,93.08)
  IN2 w0.254: v2(261.31,57.87) 261.53,58.09 262.66,58.09 263.15,57.6 263.15,56.92 264,56.07 v2(264.73,56.07) ; v2(47.72,181.92) 47.72,181.2 55.58,173.34 57.09,173.34 v2(57.97,172.47)
  IN3 w0.127: v2(270.49,93.08) 270.49,92.47 269.9,91.87 269.9,77.76 268.57,76.43 268.57,76.43 268.57,74.92 268.13,74.48 268.13,73.6 266.37,71.84 266.37,65.65 264.87,64.14 264.87,61.83 264.35,61.3 264.35,58.73 264.03,58.41 264.03,56.79 263.98,56.74 263.98,56.39 264.22,56.15 264.65,56.15 v2(264.73,56.07)
  IN3 w0.254: v2(242.1,88.32) 242.1,94.39 246.04,98.34 248.02,98.34 254.2,104.52 254.2,111.97 256.88,114.65 256.88,129.43 254.95,131.36 254.95,135.29 256.05,136.4 256.05,156.81 254.28,158.59 254.28,162.56 253.69,163.14 253.69,170.21 v2(253.4,170.5)
  IN4 w0.254: v2(37.88,173.82) 56.61,173.82 v2(57.97,172.47) ; v2(204.69,179.54) 204.69,179.64 203.2,181.14 193.93,181.14 193.1,181.97 191.19,181.97 190.78,181.55 182.32,181.55 180.58,179.81 179.51,179.81 177.81,181.51 166.67,181.51 166.23,181.95 161.35,181.95 161.04,181.65 156.52,181.65 155.56,180.68 v2(155.56,180.4)
  BOTTOM w0.254: JDOCK1.143 204.75,179.55 204.74,179.54 v2(204.69,179.54) 204.25,179.98 JDOCK1.141 ; v4(164.56,167.64) 164.82,167.89 164.82,175.12 162.97,176.96 162.97,178.4 160.37,181 156.15,181 v2(155.56,180.4)
SLICE_BAT_PRES#_C2: length 6.5
  TOP w0.102: PC814.1 165.72,169.2 165.16,168.64 165.16,167.97 165.01,167.82 165.01,167.21 v1(164.92,167.12)
  TOP w0.203: PR851.2 164.7,169.43 163.2,170.94 PU808.5
  TOP w0.254: PC814.1 PR851.2
SLICE_PERF_EN: length 324.6
  TOP w0.102: U51.B37 283.16,116.91 283.49,117.24 283.5,117.24 v2(283.52,117.27)
  TOP w0.254: PR884.2 57.91,176.53 57.43,177.01 57.26,177.01 ; PR881.2 65.85,177.13 v1(65.34,177.63) 64.99,177.98 v2(64.69,177.98) ; 57.26,177.01 57.69,177.44 PR885.2 ; 57.26,177.01 v2(57.25,177.01)
  IN1 w0.254: v2(156.83,177) 156.2,177 152.32,173.12 145.49,173.12 142.83,170.46 131.78,170.46 130.4,171.84 120.33,171.84 119.91,171.42 117.66,171.42 116.81,170.57 113.86,170.57 113.06,169.77 106.98,169.77 106.42,170.33 91.83,170.33 91.31,170.85 89.27,170.85 82.63,177.49 79.05,177.49 78.67,177.88 78.67,179.21 78.47,179.41 76.58,179.41 75.94,178.78 72.2,178.78 71.36,179.61 66.32,179.61 v2(64.69,177.98) 63.81,178.87 59.13,178.87 57.27,177.01 v2(57.25,177.01)
  IN2 w0.127: v2(169.36,159.42) 172.8,159.42 v2(173.07,159.16) ; v2(220.3,104.3) 221.09,105.09 221.09,108.73 224.48,112.12 226.78,112.12 229.23,114.57 237.17,114.57 237.59,114.99 240.55,114.99 242.78,112.75 248.39,112.75 251.1,115.46 263.89,115.46 266.05,117.61 267.89,117.61 268.72,118.44 269.49,118.44 271.37,116.56 276.94,116.56 277.99,117.6 278.77,117.6 279.32,118.15 282.06,118.15 282.97,117.24 283.5,117.24 v2(283.52,117.27)
  IN3 w0.127: v2(220.3,104.3) 220.3,104.85 218.94,106.21 217.17,106.21 216.85,105.89 207.88,105.89 206.87,106.91 206.12,106.91 205.39,107.64 202.66,107.64 202.17,107.15 196.81,107.15 196.38,106.72 195.73,106.72 195.18,106.17 187.73,106.17 187.3,106.6 185.82,106.6 182.67,109.75 182.16,109.75 181.82,110.1 181.82,114.8 183.68,116.66 183.68,119.53 179.98,123.23 179.98,131.83 181.17,133.02 181.17,139.63 180.53,140.27 180.53,142.29 180.95,142.71 180.95,143.37 180.45,143.87 179.67,143.87 176.79,146.75 176.79,149.37 174.34,151.82 174.34,157.89 v2(173.07,159.16)
  IN4 w0.102: v2(169.36,159.42) 169.36,159.47 168.62,160.22 168.62,165.12 166.95,166.79 166.95,169.15 166.07,170.03 166.07,176.39 165.01,177.46 163.53,177.46 162.54,178.45 157.58,178.45 156.83,177.7 v2(156.83,177)
  BOTTOM w0.254: v2(156.83,177) 156.07,177 155.86,177.2 PR883.1
SLP_ME_CSW_DEV#: length 101.1
  TOP w0.102: v2(241.46,49.17) v1(241.46,49.97) ; v2(198.48,55.64) 198.14,55.98 RH222.1 196.7,55.98 196.02,55.31 RH223.1 ; U46.B58 267.19,48.61 v2(267.04,48.76)
  IN2 w0.089: 202.92,62.26 203.36,62.26 203.88,62.78 203.88,64.43 204.31,64.86 204.31,65.59 204.91,66.19 205.13,66.19 205.28,66.34 205.28,66.75 205.47,66.94 205.58,66.94 206.24,67.6 206.24,68.02 205.27,69 203.75,69 v2(203.54,69.21)
  IN2 w0.127: v2(267.04,48.76) 267.04,48.7 266.37,48.04 264.05,48.04 262.52,49.57 260.52,49.57 259.37,48.41 258.05,48.41 257.22,49.24 253.43,49.24 252.56,48.37 248.55,48.37 247.33,49.59 241.88,49.59 v2(241.46,49.17) ; v2(198.48,55.64) 198.48,56.1 200.38,57.99 200.38,59.37 201.51,60.5 201.67,60.5 202.14,60.97 202.14,61.86 202.54,62.26 202.92,62.26
  IN4 w0.102: v2(241.46,49.17) 241.4,49.17 239.25,51.32 226.56,51.32 226.16,51.73 211.97,51.73 210.07,49.82 207.93,49.82 205.92,51.83 204.82,51.83 203.33,53.31 201.23,53.31 200.01,54.53 200.01,54.87 199.24,55.64 v2(198.48,55.64)
  BOTTOM w0.089: v2(203.54,69.21) 204.08,69.21 UH1.AD11
SM_RCOMP0: length 11
  TOP w0.305: RC58.1 v1(134.09,85.99) 135.83,84.25 135.83,81.96 136.37,81.42 137.25,81.42 137.25,81.42 137.94,81.42 138.45,80.92 v2(138.73,80.92)
  BOTTOM w0.305: v2(138.73,80.92) 139.2,81.39 JCPU1.AP3
SM_RCOMP1: length 9.4
  TOP w0.305: RC61.1 132.84,84.98 v1(134.51,83.3) 134.51,81.95 136.01,80.45 136.39,80.45 136.47,80.37 136.91,80.37 137.45,80.91 v2(137.73,80.91)
  BOTTOM w0.305: v2(137.73,80.91) 138.2,81.38 JCPU1.AR3
SM_RCOMP2: length 10.3
  TOP w0.305: v2(138.73,79.92) 138.07,79.26 136.69,79.26 136.43,79.51 135.49,79.51 v1(133.71,81.29) 133.08,81.93 133.08,82.83 RC63.1
  BOTTOM w0.305: JCPU1.AP2 139.2,80.39 v2(138.73,79.92)
SMART_DET#: length 110.5
  TOP w0.102: RH211.2 198.73,54.77 v2(198.63,54.77) ; v2(262.16,84.82) 262.77,84.82 263.03,84.57 JUSH1.10 264.91,84.57 265.18,84.29 266.54,84.29 v3(266.8,84.54)
  IN1 w0.089: v2(205.15,68.58) 206.06,68.58 207.45,67.18 208.69,67.18 210.9,64.98 210.9,63.74 213.37,61.26 213.56,61.26 214.23,60.59
  IN1 w0.102: 214.23,60.59 216.95,57.87 216.95,57.04 218.26,55.73 219.22,55.73 220.94,54 229.67,54 230.61,53.06 234.51,53.06 235.67,54.23 235.67,55.88 236.77,56.98 243.98,64.19 253.21,64.19 255.08,66.05 260.97,71.94 260.97,83.88 261.9,84.82 v2(262.16,84.82)
  IN3 w0.089: v2(205.15,68.58) 205.13,68.6 204.53,68.6 202.73,66.8 202.73,66.52 202.13,65.91 202.13,63.3 201.38,62.55 201.11,62.55 200.73,62.16
  IN3 w0.127: 200.73,62.16 199.48,60.92 199.48,59.35 199.97,58.86 199.97,57.43 199.3,56.76 199.3,56.07 199.61,55.75 199.61,55.12 199.26,54.77 v2(198.63,54.77)
  BOTTOM w0.089: UH1.AB11 204.71,68.58 v2(205.15,68.58)
SMB_SCK: length 4.5
  TOP w0.102: v1(317.33,131.15) 317.53,131.36 318.7,131.36 R1689.1 R565.2 319.34,130.72 U7.18
SMB_SDA: length 3.5
  TOP w0.102: U7.19 319.36,130.22 R567.2 319.18,130 R1688.1 319.18,128.47 v1(318.89,128.18)
SML1_SMBCLK: length 168.9
  TOP w0.102: v2(268.26,91.76) 268.26,92.24 268.64,92.62 268.75,92.62 268.75,92.62 269.62,92.62 269.88,92.35 272.34,92.35 275.83,95.85 276.36,95.85 277.02,96.51 277.02,98.74 277.58,99.3 278.18,99.3 v2(278.34,99.47) ; U51.B6 291.61,112.41 291.56,112.35 291.15,112.35 290.72,112.78 v2(290.72,112.8)
  IN1 w0.102: v2(268.26,91.76) 268.51,91.76 268.98,91.29 268.98,87.41 267.29,85.72 267.29,78.7 265.85,77.26 265.85,73.55 257.92,65.62 257.92,64.98 256.3,63.36 255.37,63.36 253.48,61.47 247.09,61.47 245.94,60.32 244.75,60.32 235.38,50.95 231.86,50.95 230.16,49.25 221.88,49.25 216.52,43.89 203.06,43.89 198.09,48.86 198.09,49.73 197.1,50.72 v2(197.1,51.26) ; v2(278.34,99.47) 278.53,99.28 278.67,99.28 279.85,100.46 280.96,100.46 281.02,100.52 281.82,100.52 285.61,104.31 286.44,104.31 287.93,105.8 288.28,105.8 288.45,105.8 291.66,109 293.93,109 294.75,109.82 294.75,111.69 294.55,111.89 293.35,111.89 292.88,112.36 291.07,112.36 290.72,112.71 v2(290.72,112.8)
  IN2 w0.089: 205.29,59.88 205.3,59.89 205.3,59.91 205.42,60.03 205.65,60.03 206.02,60.4 206.02,61.78 206.32,62.08 206.32,63.1 206.55,63.33 v2(206.77,63.33)
  IN2 w0.127: v2(197.1,51.26) 197.1,51.51 197.53,51.94 199.08,51.94 201.4,54.25 202.36,54.25 205.66,57.56 205.66,58.74 205.06,59.33 205.06,59.65 205.14,59.73 205.14,59.73 205.29,59.88
  BOTTOM w0.089: v2(206.77,63.33) 206.53,63.58 UH1.K6
  BOTTOM w0.102: RH172.1 197.4,51.74 197.1,51.44 v2(197.1,51.26)
SML1_SMBDATA: length 168.7
  TOP w0.102: v2(294.25,112.53) 294.25,112.52 294.25,112.44 293.82,112.01 293.45,112.01 293.44,112.02 293.44,112.02 293.3,112.16 U51.A5 ; v2(278.34,98.88) 278.15,99.07 277.67,99.07 277.25,98.65 277.25,96.41 276.46,95.62 275.93,95.62 272.44,92.13 269.79,92.13 269.53,92.39 268.85,92.39 268.73,92.27 v2(268.73,92.11)
  IN1 w0.102: v2(196.65,51.71) 196.65,50.85 197.86,49.64 197.86,48.76 202.96,43.66 216.62,43.66 221.98,49.02 230.25,49.02 231.96,50.72 235.48,50.72 244.85,60.1 246.04,60.1 247.19,61.24 253.58,61.24 255.47,63.13 256.39,63.13 258.15,64.89 258.15,65.53 266.08,73.46 266.08,77.16 267.52,78.61 267.52,85.62 269.21,87.31 269.21,91.41 268.73,91.9 v2(268.73,92.11) ; v2(278.34,98.88) 278.51,99.05 278.76,99.05 279.93,100.22 281.04,100.22 281.12,100.29 281.92,100.29 285.7,104.08 286.53,104.08 288.02,105.57 288.19,105.57 288.55,105.57 291.75,108.78 294.03,108.78 294.98,109.73 294.98,111.8 v2(294.25,112.53)
  IN2 w0.089: v2(207.42,65.44) 207.2,65.22 207.2,64.3 206.09,63.19 206.09,62.17 205.8,61.88 205.8,60.49 205.56,60.25 205.3,60.25 205.11,60.06
  IN2 w0.127: v2(196.65,51.71) 196.92,51.71 197.4,52.2 198.98,52.2 201.29,54.51 202.23,54.51 205.42,57.7 205.42,58.64 204.81,59.25 204.81,59.75 205.11,60.06
  BOTTOM w0.089: UH1.N11 207.33,65.53 v2(207.42,65.44)
  BOTTOM w0.102: v2(196.65,51.71) 196.66,51.7 196.89,51.7 197.06,51.87 RH173.1
