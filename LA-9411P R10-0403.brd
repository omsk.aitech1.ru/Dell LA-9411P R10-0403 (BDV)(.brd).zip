# Allegro board LA-9411P R10-0403.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
DDR_B_DQS4: length 69.3
  IN1 w0.089: 164.15,77.36 163.69,77.81 163.69,78.11 163.12,78.68 163.12,80.13 162.93,80.32 162.47,80.32 162.26,80.52 162.26,81.08 162.07,81.27 161.86,81.27 161.73,81.15 v2(161.73,80.92)
  IN1 w0.102: 164.15,77.36 165.08,76.42 165.08,48.96 167.15,46.89 167.15,46.07 167.38,45.85 168.09,45.85 168.22,45.72 168.22,45.47 168.09,45.34 167.38,45.34 167.15,45.11 167.15,44.64 167.5,44.3 167.5,40.41 167.77,40.14 168.21,40.14 168.34,40.01 168.34,39.65 168.21,39.52 167.69,39.52 167.5,39.33 167.5,38.7 167.7,38.49 167.7,38.16 167.5,37.95 167.5,35.71 167.64,35.57 167.64,26.8 167.01,26.17 167.01,23.43 166.83,23.25 166.64,23.25 v2(166.47,23.43)
  BOTTOM w0.089: v2(161.73,80.92) JCPU1.M3
  BOTTOM w0.102: JDIMM2.137 166.1,24.64 165.95,24.49 165.95,23.37 166.06,23.25 166.29,23.25 v2(166.47,23.43)
DDR_B_DQS5: length 79.4
  IN1 w0.089: v2(165.73,86.92) 165.57,86.92 165.46,87.03 165.46,87.19 165.58,87.31 165.99,87.31 166.14,87.16 166.14,85.57 166.39,85.32 167.9,85.32 168.13,85.09 168.13,79.49 168.66,78.96 168.66,77.36
  IN1 w0.102: v2(171.57,20.42) 171.57,20.66 171.44,20.79 171.2,20.79 170.94,21.06 170.94,22.2 171.52,22.78 171.52,24.89 172.41,25.78 172.41,26.65 173.17,27.41 173.17,28.82 172.7,29.3 172.7,38.21 172.93,38.43 173.14,38.43 173.25,38.54 173.25,38.84 173.14,38.94 172.93,38.94 172.7,39.17 172.7,39.78 172.93,40.01 173.14,40.01 173.25,40.11 173.25,40.42 173.14,40.52 172.93,40.52 172.7,40.75 172.7,44.81 172.93,45.04 173.14,45.04 173.25,45.14 173.25,45.45 173.14,45.55 172.93,45.55 172.7,45.78 172.7,47.84 168.66,51.88 168.66,77.36
  BOTTOM w0.089: JCPU1.H8 165.26,86.45 v2(165.73,86.92)
  BOTTOM w0.102: JDIMM2.154 171.2,18.81 171.06,18.95 171.06,20.61 171.14,20.69 171.31,20.69 v2(171.57,20.42)
DDR_B_DQS6: length 80.1
  IN1 w0.089: v2(170.73,87.92) 170.57,87.76 170.57,87.57 170.72,87.41 170.94,87.41 171.04,87.52 173.12,87.52 173.4,87.24 173.4,78.81 172.44,77.85 172.44,77.38 172.45,77.37 172.45,77.36
  IN1 w0.102: v2(177.03,23.56) 176.76,23.28 176.66,23.28 176.6,23.34 176.6,25.34 178.34,27.08 178.34,38.49 177.94,38.89 177.8,38.89 177.69,39 177.69,39.3 177.8,39.4 178.47,39.4 178.72,39.65 178.72,40.09 178.47,40.34 177.8,40.34 177.69,40.44 177.69,40.75 177.8,40.85 178.11,40.85 178.39,41.13 178.39,44.35 178.16,44.58 177.85,44.58 177.69,44.73 177.69,45.09 177.8,45.19 178.49,45.19 178.72,45.42 178.72,45.9 178.49,46.13 177.8,46.13 177.69,46.23 177.69,50.11 174.91,52.9 174.91,53.42 172.45,55.88 172.45,77.36
  BOTTOM w0.089: JCPU1.C9 170.26,87.45 v2(170.73,87.92)
  BOTTOM w0.102: v2(177.03,23.56) 176.84,23.36 176.41,23.36 176.18,23.59 176.18,25.03 176.3,25.15 JDIMM2.171
DDR_B_DQS7: length 93.8
  IN1 w0.089: 173.59,91.63 172.72,91.63 172.02,92.33 171.48,92.33 171.14,92.67 171.14,94.13 170.96,94.31 170.54,94.31 170.34,94.11 170.34,93.71 170.59,93.46 170.68,93.46 170.82,93.6 170.82,93.83 v2(170.73,93.92)
  IN1 w0.102: v2(182.12,20.55) 182.12,20.74 181.76,21.1 181.76,21.1 181.44,21.41 181.44,22.38 181.78,22.72 181.78,25.78 182.75,26.74 182.75,31.15 182.98,31.37 183.44,31.37 183.57,31.5 183.57,31.76 183.44,31.88 182.98,31.88 182.75,32.11 182.75,39.41 182.98,39.64 183.44,39.64 183.57,39.77 183.57,40.06 183.44,40.19 182.97,40.19 182.75,40.41 182.75,44.96 182.98,45.18 183.44,45.18 183.57,45.31 183.57,45.56 183.44,45.69 182.98,45.69 182.75,45.92 182.75,46.4 182.98,46.63 183.44,46.63 183.57,46.76 183.57,47.01 183.44,47.14 182.98,47.14 182.75,47.37 182.75,51.65 175.8,58.59 175.8,73.75 177.06,75.01 177.06,89.04 174.47,91.63 173.59,91.63
  BOTTOM w0.089: JCPU1.C15 170.31,93.45 170.73,93.88 v2(170.73,93.92)
  BOTTOM w0.102: v2(182.12,20.55) 182.12,20.78 181.97,20.93 181.89,20.93 181.74,21.08 181.66,21.08 181.61,21.03 181.61,19.11 181.55,19.06 181.45,19.06 181.4,19.02 JDIMM2.188
DDR_B_DQS#0: length 90.8
  IN1 w0.089: 136,93.47 136.05,93.52 136.9,93.52 137.14,93.76 137.14,94.16 137.51,94.53 138.06,94.53 138.14,94.61 138.14,95.35 138.35,95.55 138.57,95.55 138.73,95.72 v2(138.73,95.92)
  IN1 w0.102: 136,93.47 123.21,80.68 123.21,72.29 123.47,72.04 123.47,48.77 123.69,48.55 124.08,48.55 124.18,48.45 124.18,48.04 124.08,47.94 123.51,47.94 123.27,47.7 123.27,47.15 123.53,46.9 124.08,46.9 124.18,46.79 124.18,46.39 124.08,46.29 123.69,46.29 122.88,45.47 122.88,26.96 124.35,25.49 124.35,21.06 124.66,20.75 124.89,20.75 125.13,20.51 v2(125.14,20.51)
  BOTTOM w0.089: JCPU1.AP18 139.2,96.39 v2(138.73,95.92)
  BOTTOM w0.102: v2(125.14,20.51) 125.38,20.75 125.5,20.75 125.71,20.54 125.71,18.99 125.6,18.87 JDIMM2.10
DDR_B_DQS#1: length 81.5
  IN1 w0.089: 136,86.97 136.36,87.33 136.98,87.33 137.32,87.67 137.32,88.2 137.46,88.33 137.98,88.33 138.32,88.67 138.32,89.28 138.43,89.38 139.03,89.38 139.12,89.29 139.12,88.98 139.05,88.92 v2(138.73,88.92)
  IN1 w0.102: 136,86.97 132.91,83.88 132.91,72.29 129.99,69.37 129.99,67.03 129.77,66.81 129.59,66.81 129.46,66.68 129.46,66.32 129.59,66.2 129.64,66.2 129.89,65.94 129.89,65.41 129.64,65.16 129.57,65.16 129.45,65.03 129.45,64.67 129.57,64.55 129.65,64.55 129.9,64.29 129.9,63.76 129.65,63.5 129.54,63.5 129.41,63.38 129.41,63.02 129.54,62.89 129.56,62.89 129.82,62.64 129.82,62.11 129.56,61.85 129.52,61.85 129.4,61.73 129.4,61.37 129.52,61.24 129.68,61.24 129.93,60.99 129.93,60.46 129.68,60.2 129.52,60.2 129.4,60.08 129.4,59.72 129.52,59.59 129.61,59.59 129.87,59.34 129.87,58.8 129.61,58.55 129.56,58.55 129.43,58.42 129.43,58.07 129.56,57.94 129.74,57.94 129.99,57.69 129.99,46.46 128.99,45.46 128.04,44.51 128.04,40.39 129.85,38.57 129.85,26.92 130.55,26.23 130.55,23.39 130.72,23.23 130.83,23.23 130.98,23.38 v2(130.98,23.56)
  BOTTOM w0.089: v2(138.73,88.92) 139.2,89.39 JCPU1.AP11
  BOTTOM w0.102: v2(130.98,23.56) 131.21,23.33 131.31,23.33 131.39,23.41 131.39,24.5 130.7,25.19 JDIMM2.27
DDR_B_DQS#2: length 71.8
  IN1 w0.089: v2(138.73,82.92) 138.74,82.92 139.03,83.2 139.03,83.38 138.89,83.52 138.62,83.52 138.61,83.5 138.41,83.5 138.34,83.43 138.34,81.69 137.96,81.31 137.51,81.31 137.35,81.14 137.35,80.47 137.35,80.22 136.48,79.36 136.48,77.36
  IN1 w0.102: v2(136.06,23.56) 136.06,23.31 135.97,23.23 135.76,23.23 135.63,23.36 135.63,25.62 134.21,27.04 134.21,41.3 133.93,41.58 133.93,41.67 133.93,44.69 135.49,46.25 135.49,47.35 135.59,47.46 136.1,47.46 136.36,47.71 136.36,48.24 136.1,48.5 135.62,48.5 135.49,48.62 135.49,48.98 135.62,49.11 136.08,49.11 136.33,49.36 136.33,49.9 136.08,50.15 135.59,50.15 135.49,50.25 135.49,69.51 136.48,70.5 136.48,77.36
  BOTTOM w0.089: v2(138.73,82.92) 139.2,83.39 JCPU1.AP5
  BOTTOM w0.102: JDIMM2.45 136.1,25.09 136.66,24.53 136.66,23.55 136.52,23.41 136.2,23.41 v2(136.06,23.56)
DDR_B_DQS#3: length 68.9
  IN1 w0.089: v2(143.73,80.92) 143.32,80.92 143.18,80.78 143.18,80.5 143,80.32 142.57,80.32 142.33,80.09 142.33,78.58 141.37,77.62 141.37,77.36
  IN1 w0.102: 141.37,77.36 141.37,72.24 140.05,70.93 140.05,68.51 140.15,68.4 140.33,68.4 140.56,68.18 140.56,67.59 140.33,67.36 140.15,67.36 140.05,67.26 140.05,66.71 140.34,66.42 140.34,65.76 140.05,65.47 140.05,60.82 140.15,60.72 140.15,36.83 139.82,36.5 139.82,26.69 140.99,25.52 140.99,21.13 141.1,21.03 141.2,21.03 v2(141.47,21.3)
  BOTTOM w0.089: v2(143.73,80.92) 144.2,81.39 JCPU1.AJ3
  BOTTOM w0.102: v2(141.47,21.3) 141.17,21.01 140.96,21.01 140.76,20.81 140.76,19.45 141.05,19.16 141.21,19.16 141.35,19.03 141.35,18.92 141.2,18.78 JDIMM2.62
DDR_B_DQS#4: length 69.3
  IN1 w0.089: v2(162.73,80.92) 162.67,80.92 162.47,80.72 162.47,80.61 162.57,80.51 163.02,80.51 163.32,80.21 163.32,78.77 163.9,78.19 163.9,77.91 164.45,77.36
  IN1 w0.102: 164.45,77.36 165.3,76.51 165.3,49.05 167.37,46.98 167.37,46.16 167.47,46.06 168.18,46.06 168.44,45.81 168.44,45.38 168.18,45.12 167.47,45.12 167.37,45.02 167.37,44.73 167.71,44.39 167.71,40.5 167.86,40.36 168.3,40.36 168.55,40.1 168.55,39.56 168.3,39.31 167.78,39.31 167.71,39.24 167.71,38.79 167.92,38.58 167.92,38.07 167.71,37.86 167.71,35.8 167.85,35.66 167.85,26.71 167.23,26.08 167.23,23.34 166.92,23.04 166.84,23.04 v2(166.47,22.67)
  BOTTOM w0.089: v2(162.73,80.92) JCPU1.L3
  BOTTOM w0.102: v2(166.47,22.67) 166.11,23.02 165.97,23.02 165.72,23.27 165.72,24.49 165.5,24.7 JDIMM2.135
DDR_B_DQS#5: length 79.4
  IN1 w0.089: v2(165.73,87.92) 165.55,87.74 165.55,87.62 165.65,87.52 166.07,87.52 166.34,87.24 166.34,85.65 166.49,85.51 167.98,85.51 168.32,85.16 168.32,79.59 168.88,79.03 168.88,77.36
  IN1 w0.102: v2(171.57,21.19) 171.57,21.14 171.44,21.01 171.29,21.01 171.15,21.15 171.15,22.11 171.74,22.69 171.74,24.81 172.63,25.69 172.63,26.56 173.39,27.32 173.39,28.91 172.92,29.39 172.92,38.12 173.02,38.22 173.23,38.22 173.46,38.45 173.46,38.93 173.23,39.16 173.02,39.16 172.92,39.26 172.92,39.69 173.02,39.8 173.23,39.8 173.46,40.02 173.46,40.51 173.23,40.74 173.02,40.74 172.92,40.84 172.92,44.72 173.02,44.82 173.23,44.82 173.46,45.05 173.46,45.54 173.23,45.76 173.02,45.76 172.92,45.87 172.92,47.93 168.88,51.97 168.88,77.36
  BOTTOM w0.089: JCPU1.H9 165.26,87.45 v2(165.73,87.92)
  BOTTOM w0.102: v2(171.57,21.19) 171.3,20.92 171.05,20.92 170.84,20.71 170.84,19.1 170.6,18.86 JDIMM2.152
DDR_B_DQS#6: length 80.1
  IN1 w0.089: 172.23,77.36 172.23,77.37 172.24,77.38 172.24,77.93 173.2,78.89 173.2,87.15 173.04,87.31 171.13,87.31 v2(170.73,86.92)
  IN1 w0.102: 172.23,77.36 172.23,55.79 174.7,53.33 174.7,52.81 177.48,50.03 177.48,46.14 177.71,45.91 178.4,45.91 178.5,45.81 178.5,45.5 178.4,45.4 177.71,45.4 177.48,45.18 177.48,44.64 177.76,44.36 178.07,44.36 178.17,44.26 178.17,41.21 178.02,41.07 177.71,41.07 177.48,40.84 177.48,40.35 177.71,40.13 178.38,40.13 178.5,40 178.5,39.74 178.38,39.62 177.71,39.62 177.48,39.39 177.48,38.91 177.71,38.68 177.85,38.68 178.13,38.4 178.13,27.17 176.39,25.43 176.39,23.25 176.57,23.07 176.76,23.07 v2(177.03,22.79)
  BOTTOM w0.089: v2(170.73,86.92) 170.26,86.45 JCPU1.C8
  BOTTOM w0.102: v2(177.03,22.79) 176.69,23.13 176.32,23.13 175.95,23.5 175.95,24.99 175.7,25.25 JDIMM2.169
DDR_B_DQS#7: length 93.9
  IN1 w0.089: v2(170.73,92.92) 170.73,93.03 170.14,93.63 170.14,94.2 170.46,94.52 171.05,94.52 171.35,94.22 171.35,92.75 171.57,92.53 172.1,92.53 172.8,91.83 173.5,91.83 173.51,91.84 173.57,91.84 173.58,91.85 173.59,91.85
  IN1 w0.102: 173.59,91.85 174.56,91.85 177.28,89.13 177.28,74.92 176.02,73.66 176.02,58.68 182.96,51.74 182.96,47.46 183.07,47.36 183.53,47.36 183.78,47.1 183.78,46.67 183.53,46.42 183.07,46.42 182.96,46.31 182.96,46.01 183.07,45.91 183.53,45.91 183.78,45.65 183.78,45.22 183.53,44.97 183.07,44.97 182.96,44.87 182.96,40.5 183.06,40.4 183.53,40.4 183.78,40.15 183.78,39.68 183.53,39.42 183.07,39.42 182.96,39.32 182.96,32.2 183.07,32.1 183.53,32.1 183.78,31.84 183.78,31.41 183.53,31.16 183.07,31.16 182.96,31.06 182.96,26.65 182,25.69 182,22.63 181.66,22.29 181.66,21.5 181.85,21.31 v2(182.12,21.31)
  BOTTOM w0.089: JCPU1.C14 170.26,92.45 v2(170.73,92.92)
  BOTTOM w0.102: v2(182.12,21.31) 181.57,21.31 181.38,21.12 181.38,19.32 180.8,18.74 JDIMM2.186
DDR_B_MA0: length 79.8
  IN1 w0.089: v2(158.73,85.92) 158.73,85.72 158.33,85.32 156.49,85.32 156.36,85.19 156.36,84.51 156.23,84.38 152.5,84.38 152.41,84.29 152.41,83.75 151.68,83.01 151.68,82.53 151.51,82.36 151.51,78.39 152.25,77.65 152.25,77.36
  IN1 w0.165: v2(154.22,21.87) 154.22,21.73 153.92,21.43 153.56,21.43 153.34,21.65 153.34,22.03 153.47,22.16 153.64,22.16 153.77,22.29 153.77,22.68 153.64,22.81 153.47,22.81 153.34,22.94 153.34,23.18 153.28,23.24 153.28,24.55 152.89,24.94 152.89,25.46 151.85,26.5 151.85,45.06 151.05,45.86 151.05,58.8 151.18,58.93 152.12,58.93 152.25,59.05 152.25,77.36
  BOTTOM w0.089: v2(158.73,85.92) JCPU1.R8
  BOTTOM w0.165: JDIMM2.98 154.4,18.77 154.81,19.18 154.81,21.29 v2(154.22,21.87)
DDR_B_MA1: length 77.9
  IN1 w0.089: v2(153.73,83.91) 153.34,83.51 152.72,83.51 152.06,82.85 152.06,82.37 151.9,82.2 151.9,78.54 152.66,77.77 152.92,77.77 153.24,77.45 153.24,77.36
  IN1 w0.165: 153.24,77.36 153.24,54.91 153.08,54.75 152.47,54.75 152.34,54.62 152.34,54.22 152.47,54.09 153.08,54.09 153.24,53.92 153.24,53.59 153.08,53.43 152.43,53.43 152.31,53.3 152.31,52.89 152.43,52.77 153.08,52.77 153.24,52.6 153.24,52.27 153.08,52.11 152.38,52.11 152.26,51.98 152.26,51.57 152.38,51.45 153.08,51.45 153.24,51.28 153.24,50.95 153.08,50.79 152.36,50.79 152.23,50.66 152.23,50.25 152.36,50.13 153.08,50.13 153.24,49.96 153.24,49.46 153.08,49.3 152.33,49.3 152.21,49.17 152.21,48.76 152.33,48.64 153.08,48.64 153.24,48.47 153.24,48.14 153.08,47.98 152.31,47.98 152.18,47.85 152.18,47.44 152.31,47.32 153.29,47.32 153.42,47.19 153.42,46.78 153.29,46.66 152.42,46.66 152.29,46.53 152.29,46.12 152.42,46 153.29,46 153.42,45.87 153.42,40.84 153.25,40.68 152.97,40.68 152.84,40.55 152.84,40.15 152.97,40.02 153.29,40.02 153.42,39.89 153.42,39.49 153.29,39.36 152.97,39.36 152.84,39.23 152.84,38.82 152.97,38.7 153.25,38.7 153.42,38.53 153.42,37.76 153.57,37.61 153.57,32.46 153.41,32.3 152.97,32.3 152.84,32.17 152.84,31.76 152.97,31.64 153.45,31.64 153.57,31.51 153.57,31.1 153.45,30.98 152.97,30.98 152.84,30.85 152.84,30.44 152.97,30.32 153.45,30.32 153.57,30.19 153.57,28.12 153.45,27.99 153.17,27.99 153.04,28.12 v2(153.04,28.33)
  BOTTOM w0.089: v2(153.73,83.91) 153.27,83.45 JCPU1.Y5
  BOTTOM w0.165: v2(153.04,28.33) 153.5,27.88 153.5,27.62 154.1,27.02 JDIMM2.97
DDR_B_MA2: length 75.6
  IN1 w0.089: v2(153.73,87.92) 154.08,87.57 154.08,86.8 153.28,86 153.28,85.71 153.27,85.7 153.27,84.93 153.27,84.93 153.27,84.9 152.94,84.57 152.42,84.57 152.18,84.33 152.18,83.78 151.49,83.09 151.49,82.61 151.32,82.44 151.32,78.15 151.75,77.72 151.75,77.36
  IN1 w0.165: 151.75,77.36 151.75,59.84 151.63,59.72 150.68,59.72 150.55,59.59 150.55,45.65 151.31,44.9 151.31,26.34 152.39,25.26 152.39,24.74 152.79,24.34 152.79,23.03 152.85,22.97 152.85,21.45 153.95,20.35 v2(154.22,20.35)
  BOTTOM w0.089: v2(153.73,87.92) JCPU1.Y10
  BOTTOM w0.165: JDIMM2.96 153.8,18.95 153.64,19.11 153.64,19.77 v2(154.22,20.35)
DDR_B_MA3: length 78
  IN1 w0.089: 152.74,77.36 152.74,77.43 151.71,78.46 151.71,82.28 151.87,82.45 151.87,82.93 152.79,83.85 v2(152.79,83.92)
  IN1 w0.165: 152.74,77.36 152.74,58.06 152.62,57.94 151.67,57.94 151.54,57.81 151.54,57.38 151.67,57.25 152.62,57.25 152.74,57.12 152.74,56.72 152.62,56.59 151.67,56.59 151.54,56.46 151.54,56.01 151.67,55.88 152.62,55.88 152.74,55.75 152.74,55.37 152.62,55.24 151.67,55.24 151.54,55.12 151.54,46.17 152.21,45.5 152.8,45.5 152.92,45.37 152.92,44.89 152.8,44.76 152.47,44.76 152.34,44.63 152.34,26.71 152.75,26.3 153.01,26.3 153.14,26.43 153.14,27 153.41,27.27 153.8,27.27 153.99,27.08 153.99,26.9 153.73,26.64 153.73,26.52 153.82,26.43 154.46,26.43 154.58,26.3 154.58,25.98 154.46,25.86 153.86,25.86 153.73,25.73 153.73,25.35 153.86,25.22 154.46,25.22 154.58,25.09 154.58,24.73 154.46,24.6 153.91,24.6 153.78,24.47 153.78,23.52 153.91,23.4 v2(154.22,23.4)
  BOTTOM w0.089: JCPU1.AA5 152.32,83.45 v2(152.79,83.92)
  BOTTOM w0.165: v2(154.22,23.4) 153.5,24.12 JDIMM2.95
DDR_B_MA4: length 76.6
  IN1 w0.089: 149.77,77.36 149.77,78.16 149.32,78.61 149.32,82.14 149.73,82.55 149.89,82.55 150.11,82.76 150.11,83.36 150.31,83.56 150.31,84.08 150.56,84.33 151.08,84.33 152.27,85.52 152.29,85.52 v2(152.71,85.94)
  IN1 w0.165: 149.77,77.36 149.77,68.43 148.4,67.06 148.4,62.97 147.87,62.44 147.87,60.35 147.36,59.83 147.36,52.6 147.48,52.47 148.45,52.47 148.57,52.34 148.57,44.83 148.72,44.69 148.72,26.83 150.83,24.72 150.83,23.4 151.4,22.83 151.4,21.7 151.56,21.54 151.79,21.54 151.91,21.41 151.91,20.88 151.79,20.75 151.52,20.75 151.4,20.62 151.4,20.13 151.52,20.01 152.22,20.01 152.35,20.13 v2(152.35,20.35)
  BOTTOM w0.089: JCPU1.Y7 152.71,85.94 v2(152.71,85.94)
  BOTTOM w0.165: JDIMM2.92 152.6,18.67 153.02,19.09 153.02,19.68 v2(152.35,20.35)
DDR_B_MA5: length 77
  IN1 w0.089: v2(151.77,83.95) 151.64,83.95 151.52,83.83 151.52,83.45 151.3,83.23 151.3,82.69 151.13,82.52 151.13,77.78 151.26,77.65 151.26,77.36
  IN1 w0.165: 151.26,77.36 151.26,67.15 151.12,67.01 150.45,67.01 150.33,66.88 150.33,66.51 150.43,66.41 151.11,66.41 151.26,66.26 151.26,65.96 151.09,65.8 150.45,65.8 150.33,65.67 150.33,65.29 150.45,65.16 151.09,65.16 151.22,65.04 151.22,64.64 151.08,64.5 150.45,64.5 150.33,64.38 150.33,64.01 150.45,63.88 151.13,63.88 151.26,63.75 151.26,63.46 151.13,63.34 150.45,63.34 150.32,63.21 150.32,62.83 150.45,62.7 151.13,62.7 151.26,62.57 151.26,62.2 151.13,62.08 149.61,62.08 149.36,61.83 149.36,60.88 149.49,60.76 149.84,60.76 149.97,60.88 149.97,61.28 150.1,61.4 151.13,61.4 151.26,61.28 151.26,60.34 151.13,60.21 150.19,60.21 150.06,60.08 150.06,45.45 150.81,44.69 150.81,41.11 150.61,40.91 150.38,40.91 150.25,40.78 150.25,40.54 150.38,40.41 150.69,40.41 150.81,40.28 150.81,39.95 150.69,39.83 150.38,39.83 150.25,39.7 150.25,39.36 150.38,39.23 150.69,39.23 150.81,39.1 150.81,38.71 150.69,38.58 150.38,38.58 150.25,38.46 150.25,38.15 150.38,38.02 150.69,38.02 150.81,37.89 150.81,32.37 150.65,32.21 150.38,32.21 150.25,32.08 150.25,31.67 150.38,31.54 150.69,31.54 150.81,31.42 150.81,31.01 150.69,30.88 150.38,30.88 150.25,30.76 150.25,30.35 150.38,30.22 150.65,30.22 150.81,30.06 150.81,28.56 150.68,28.43 150.49,28.43 v2(150.21,28.15)
  BOTTOM w0.089: v2(151.77,83.95) 152.2,84.38 JCPU1.AA6
  BOTTOM w0.165: v2(150.21,28.15) 151.42,28.15 152.3,27.27 JDIMM2.91
DDR_B_MA6: length 79.6
  IN1 w0.089: 150.27,77.36 150.27,78.2 150.13,78.33 150.13,82.52 150.3,82.69 150.3,83.28 150.56,83.55 150.89,83.55 151.11,83.77 151.11,84.09 152.18,85.16 v2(152.71,85.16)
  IN1 w0.165: v2(152.35,21.87) 151.89,22.33 151.89,23.04 151.32,23.61 151.32,24.93 149.26,26.99 149.26,44.84 149.07,45.04 149.07,52.8 148.9,52.97 148.05,52.97 147.93,53.09 147.93,53.5 148.05,53.63 148.9,53.63 149.07,53.79 149.07,54.18 148.94,54.3 147.98,54.3 147.85,54.43 147.85,54.85 148.02,55.02 148.94,55.02 149.07,55.15 149.07,55.55 148.94,55.68 148.02,55.68 147.85,55.84 147.85,56.17 148.02,56.34 148.94,56.34 149.07,56.47 149.07,56.87 148.94,57 148.02,57 147.85,57.16 147.85,59.62 148.37,60.14 148.37,62.24 148.9,62.77 148.9,66.85 150.27,68.22 150.27,77.36
  BOTTOM w0.089: JCPU1.Y6 153.2,84.67 v2(152.71,85.16)
  BOTTOM w0.165: v2(152.35,21.87) 151.85,21.37 151.85,19.15 152,19 JDIMM2.90
DDR_B_MA7: length 75.4
  IN1 w0.089: 149.28,77.36 149.28,78.29 149.13,78.43 149.13,82.21 149.35,82.43 149.35,83.06 149.58,83.29 149.77,83.29 150.12,83.64 150.12,84.16 150.48,84.52 151,84.52 151.72,85.24 151.72,85.82 v2(151.73,85.83)
  IN1 w0.165: 149.28,77.36 149.28,68.63 147.91,67.26 147.91,63.18 147.38,62.65 147.38,60.55 146.86,60.03 146.86,52.1 146.99,51.98 147.95,51.98 148.08,51.85 148.08,44.63 148.21,44.5 148.21,40.7 148.04,40.54 147.91,40.54 147.78,40.41 147.78,40 147.91,39.87 148.09,39.87 148.22,39.75 148.22,39.34 148.09,39.21 147.91,39.21 147.78,39.09 147.78,38.68 147.91,38.55 148.04,38.55 148.21,38.39 148.21,32.45 148.04,32.29 147.91,32.29 147.78,32.16 147.78,31.75 147.91,31.63 148.04,31.63 148.21,31.46 148.21,26.64 150.33,24.52 150.33,22.37 v2(150.83,21.87)
  BOTTOM w0.089: v2(151.73,85.83) 152.11,85.45 JCPU1.AA7
  BOTTOM w0.165: JDIMM2.86 150.8,18.76 151.33,19.29 151.33,21.37 v2(150.83,21.87)
DDR_B_MA8: length 78.8
  IN1 w0.089: v2(153.67,86.96) 153.67,87.26 153.56,87.36 153.22,87.36 153.09,87.23 153.09,85.79 153.08,85.78 153.08,85.32 153.08,85.32 153.08,85.01 153.08,85 153.08,84.99 152.88,84.78 152.07,84.78 151.3,84.01 151.3,83.5 151.11,83.31 151.11,82.76 150.89,82.55 150.43,82.55 150.32,82.44 150.32,78.51 150.38,78.46 150.63,78.46 150.76,78.33 150.76,77.66 150.76,77.65 150.76,77.36
  IN1 w0.165: v2(152.35,23.4) 152.24,23.4 151.82,23.82 151.82,25.13 150.78,26.16 150.78,26.17 150.71,26.25 150.71,26.39 150.81,26.49 150.81,26.89 150.66,27.05 150.49,27.05 150.26,26.82 150.13,26.82 149.76,27.19 149.76,45.05 149.56,45.24 149.56,57.51 149.44,57.64 148.47,57.64 148.35,57.76 148.35,58.17 148.47,58.3 149.44,58.3 149.56,58.42 149.56,58.83 149.44,58.96 148.55,58.96 148.42,59.08 148.42,59.49 148.55,59.62 149.44,59.62 149.56,59.75 149.56,60.1 149.44,60.22 148.99,60.22 148.87,60.35 148.87,62.03 149.56,62.73 149.56,62.99 149.83,63.26 149.83,65.79 149.7,65.91 149.52,65.91 149.39,66.04 149.39,66.51 149.52,66.64 149.7,66.64 149.83,66.76 149.83,67.08 150.76,68.02 150.76,77.36
  BOTTOM w0.089: JCPU1.Y8 153.2,86.49 v2(153.67,86.96)
  BOTTOM w0.165: JDIMM2.89 151.7,25.03 151.82,24.9 151.82,23.76 152.19,23.4 v2(152.35,23.4)
DDR_B_MA9: length 74.4
  IN1 w0.089: 148.29,77.36 148.29,77.88 148.5,78.09 148.5,79.13 148.14,79.49 148.14,82.91 148.61,83.38 148.7,83.38 149.12,83.8 149.12,86.14 149.31,86.33 151.43,86.33 151.66,86.56 151.83,86.56 152.1,86.83 152.1,87.29 v2(152.73,87.92)
  IN1 w0.165: v2(149.3,23.4) 148.84,23.86 148.84,24.61 146.79,26.66 146.79,50.47 145.86,51.4 145.86,60.43 146.36,60.93 146.36,65.65 146.92,66.21 146.92,67.67 148.29,69.04 148.29,77.36
  BOTTOM w0.089: v2(152.73,87.92) JCPU1.AA10
  BOTTOM w0.165: v2(149.3,23.4) 150.5,24.59 JDIMM2.85
DDR_B_MA10: length 84.3
  IN1 w0.089: 155.75,77.77 154.13,79.39 154.13,80.16 154.5,80.52 154.86,80.52 155.13,80.79 155.13,82.7 156.14,83.71 156.14,83.89 156.57,84.32 157.66,84.32 158.33,84.99 158.33,85.05 158.8,85.52 158.86,85.52 159.11,85.76 159.11,86.8 158.99,86.92 v2(158.73,86.92)
  IN1 w0.165: v2(157.77,28.26) 157.68,28.35 157.49,28.35 157.37,28.23 157.37,27.73 157.25,27.61 156.99,27.61 156.86,27.73 156.86,28.43 156.73,28.56 156.69,28.56 156.56,28.69 156.56,29.09 156.69,29.22 157.12,29.22 157.25,29.35 157.25,29.87 157.12,30 156.69,30 156.56,30.12 156.56,30.54 156.69,30.66 157.65,30.66 157.78,30.79 157.78,31.2 157.65,31.32 156.69,31.32 156.56,31.45 156.56,31.86 156.69,31.98 157.65,31.98 157.78,32.11 157.78,32.52 157.65,32.64 157.15,32.64 156.99,32.81 156.99,35.46 156.86,35.59 156.12,35.59 156,35.71 156,36.04 156.12,36.17 156.76,36.17 156.87,36.28 156.87,36.36 157.01,36.5 157.48,36.5 157.6,36.63 157.6,37.06 157.48,37.19 156.5,37.19 156.38,37.32 156.38,37.72 156.5,37.85 157.41,37.85 157.53,37.98 157.53,38.35 157.41,38.47 155.57,38.47 155.44,38.6 155.44,39.01 155.57,39.13 157.65,39.13 157.78,39.26 157.78,39.73 157.65,39.86 156.07,39.86 155.94,39.99 155.94,40.34 156.07,40.47 156.36,40.47 156.51,40.62 156.51,43.59 156.43,43.66 156.12,43.66 156,43.79 156,44.26 156.12,44.39 156.24,44.39 156.37,44.52 156.37,44.92 156.24,45.05 156.12,45.05 156,45.18 156,73.07 155.75,73.32 155.75,77.77
  BOTTOM w0.089: v2(158.73,86.92) JCPU1.R9
  BOTTOM w0.165: JDIMM2.107 157.1,27.59 v2(157.77,28.26)
DDR_B_MA11: length 77
  IN1 w0.089: 148.78,77.36 148.78,79.12 148.33,79.57 148.33,82.04 149.16,82.86 149.16,83.14 149.31,83.3 149.31,84.03 149.58,84.29 149.71,84.29 150.14,84.72 150.93,84.72 151.35,85.14 151.35,85.97 151.7,86.32 151.99,86.32 v2(152.67,87)
  IN1 w0.165: 148.78,77.36 148.78,68.84 147.41,67.47 147.41,63.38 146.88,62.85 146.88,60.76 146.36,60.23 146.36,51.61 146.48,51.48 147.46,51.48 147.58,51.35 147.58,44.93 147.28,44.63 147.28,26.86 149.84,24.31 149.84,20.48 149.96,20.35 v2(150.83,20.35)
  BOTTOM w0.089: JCPU1.Y9 153.12,87.45 v2(152.67,87)
  BOTTOM w0.165: JDIMM2.84 150.2,19.72 v2(150.83,20.35)
DDR_B_MA12: length 74.9
  IN1 w0.089: 147.79,77.36 147.79,79.12 147.33,79.58 147.33,84.04 147.36,84.07 147.36,84.08 147.58,84.29 147.59,84.29 147.84,84.55 147.89,84.55 148.14,84.8 148.14,85.51 v2(147.73,85.92)
  IN1 w0.165: v2(149.3,21.87) 149.07,21.87 148.84,22.1 148.84,23.16 148.12,23.88 148.12,24.02 148.31,24.21 148.31,24.44 148.06,24.68 147.88,24.68 147.69,24.49 147.51,24.49 147.17,24.82 147.17,25 147.37,25.2 147.37,25.38 147.08,25.66 146.9,25.66 146.73,25.5 146.5,25.5 146.29,25.71 146.29,50.17 145.37,51.1 145.37,60.64 145.86,61.14 145.86,65.86 146.42,66.42 146.42,67.88 147.79,69.25 147.79,77.36
  BOTTOM w0.089: JCPU1.AF7 147.26,85.45 v2(147.73,85.92)
  BOTTOM w0.165: v2(149.3,21.87) 148.69,22.49 148.69,24.21 149.25,24.76 149.49,24.76 149.9,25.18 JDIMM2.83
DDR_B_MA13: length 84.9
  IN1 w0.089: v2(159.69,86.98) 160.33,86.34 160.33,82.45 160.21,82.32 158.57,82.32 158.32,82.08 158.32,81.23 158.13,81.04 158.13,78.47 159.25,77.36 159.25,77.36
  IN1 w0.165: v2(162.04,23.4) 161.61,23.84 161.61,25.55 161.77,25.71 161.92,25.71 162.04,25.84 162.04,26.25 161.92,26.37 161.64,26.37 161.51,26.5 161.51,26.83 161.64,26.96 162,26.96 162.04,27 162.04,27.4 162.77,28.12 162.77,45.89 160.71,47.95 160.71,56.48 160.88,56.65 161.11,56.65 161.28,56.81 161.28,57.14 161.11,57.31 160.88,57.31 160.71,57.47 160.71,57.94 160.84,58.06 161.15,58.06 161.28,58.19 161.28,58.6 161.15,58.72 160.84,58.72 160.71,58.85 160.71,59.27 160.84,59.4 161.15,59.4 161.28,59.52 161.28,59.92 161.15,60.05 160.84,60.05 160.71,60.17 160.71,60.57 160.84,60.69 161.15,60.69 161.28,60.82 161.28,61.19 161.15,61.32 160.84,61.32 160.71,61.44 160.71,61.86 160.84,61.99 161.15,61.99 161.28,62.12 161.28,62.59 161.15,62.71 160.39,62.71 160.24,62.86 160.24,63.27 160.37,63.4 161.11,63.4 161.28,63.56 161.28,64.02 161.11,64.19 160.22,64.19 160.09,64.32 160.09,64.72 160.22,64.85 161.11,64.85 161.28,65.01 161.28,65.34 161.11,65.51 160.22,65.51 160.09,65.64 160.09,66.04 160.22,66.17 161.11,66.17 161.28,66.34 161.28,66.67 161.11,66.83 160.22,66.83 160.09,66.96 160.09,67.36 160.22,67.49 161.11,67.49 161.28,67.66 161.28,74.84 159.25,76.87 159.25,77.36
  BOTTOM w0.089: JCPU1.P9 159.22,87.45 v2(159.69,86.98)
  BOTTOM w0.165: JDIMM2.119 160.7,24.74 v2(162.04,23.4)
DDR_B_MA14: length 79.8
  IN1 w0.089: v2(151.7,86.96) 151.62,86.96 151.18,86.52 147.7,86.52 147.7,86.52 147.41,86.52 147.14,86.26 147.14,79.24 147.3,79.08 147.3,77.36
  IN1 w0.165: 147.3,77.36 147.3,69.45 145.93,68.08 145.93,66.62 145.37,66.06 145.37,61.34 144.87,60.85 144.87,50.27 145.08,50.06 145.67,50.06 145.8,49.94 145.8,49.63 145.67,49.51 145.13,49.51 144.97,49.34 144.97,49.01 145.13,48.85 145.63,48.85 145.8,48.68 145.8,43.39 145.67,43.27 145.45,43.27 145.32,43.14 145.32,40.94 145.45,40.82 145.67,40.82 145.8,40.69 145.8,25.5 148.34,22.96 148.34,20.78 148.77,20.35 v2(149.3,20.35)
  BOTTOM w0.089: JCPU1.AA8 v2(151.7,86.96)
  BOTTOM w0.165: v2(149.3,20.35) 148.76,19.81 148.76,19.4 149,19.16 JDIMM2.80
DDR_B_MA15: length 70.7
  IN1 w0.089: v2(145.73,84.92) 146.13,84.52 146.13,78.75 145.84,78.46
  IN1 w0.165: v2(147.44,20.35) 146.51,21.28 146.51,23.39 144.81,25.09 144.81,26.58 144.18,27.21 144.18,48.4 143.88,48.7 143.88,61.26 144.38,61.75 144.38,67.93 145.84,69.4 145.84,78.46
  BOTTOM w0.089: JCPU1.AG7 146.2,85.39 v2(145.73,84.92)
  BOTTOM w0.165: JDIMM2.78 148.4,18.86 148.2,19.05 148.2,19.58 v2(147.44,20.35)
DDR_B_RAS#: length 80.9
  IN1 w0.089: v2(158.73,83.92) 158.52,83.71 158.52,83.55 158.14,83.16 158.14,82.7 158.09,82.65 157.96,82.52 156.52,82.52 156.32,82.33 156.32,80.67 156.13,80.48 156.13,78.56 157.23,77.46 157.23,77.36
  IN1 w0.165: 157.23,77.36 157.23,73.94 157.48,73.69 157.48,63.6 157.61,63.48 157.9,63.48 158.11,63.27 158.11,55.5 157.98,55.37 157.61,55.37 157.48,55.25 157.48,45.91 159.26,44.13 159.26,32.12 159.39,31.99 159.9,31.99 160.03,31.86 160.03,31.46 159.9,31.33 159.39,31.33 159.26,31.2 159.26,30.68 159.39,30.56 159.9,30.56 160.03,30.43 160.03,30.04 159.9,29.91 159.39,29.91 159.26,29.79 159.26,26.62 159.39,26.49 160.37,26.49 160.5,26.36 160.5,25.9 160.37,25.77 159.66,25.77 159.53,25.64 159.53,25.21 159.69,25.05 160.13,25.05 160.26,24.92 160.26,24.51 160.13,24.39 159.64,24.39 159.52,24.26 159.52,23.85 159.64,23.73 159.9,23.73 160.03,23.6 160.03,23.19 159.9,23.07 159.69,23.07 159.53,22.9 159.53,22.57 159.69,22.41 159.9,22.41 160.03,22.28 160.03,21.87 159.9,21.75 159.66,21.75 159.53,21.62 159.53,21.14 159.66,21.01 159.91,21.01 160.04,20.88 160.04,20.48 159.91,20.35 159.69,20.35 159.5,20.15 158.03,20.15 157.84,20.35 v2(157.52,20.35)
  BOTTOM w0.089: v2(158.73,83.92) JCPU1.R6
  BOTTOM w0.165: v2(157.52,20.35) 158,19.87 JDIMM2.110
DDR_B_WE#: length 82.2
  IN1 w0.089: 158.22,77.36 157.13,78.44 157.13,79.88 157.33,80.08 157.33,81.09 157.67,81.42 157.8,81.42 158.13,81.75 158.13,82.16 158.49,82.51 159.19,82.51 159.25,82.58 159.25,83.19 159.38,83.32 160.02,83.32 160.14,83.45 160.14,84.1 160.11,84.13 159.94,84.13 159.73,83.93 v2(159.73,83.92)
  IN1 w0.165: 158.22,77.36 158.22,74.35 159.1,73.47 159.1,62.14 159.26,61.98 159.6,61.98 159.72,61.85 159.72,61.44 159.6,61.32 159.22,61.32 159.1,61.19 159.1,60.78 159.22,60.66 159.55,60.66 159.67,60.53 159.67,60.12 159.55,60 159.22,60 159.1,59.87 159.1,59.46 159.22,59.33 159.53,59.33 159.65,59.21 159.65,58.8 159.53,58.67 159.22,58.67 159.1,58.55 159.1,58.14 159.22,58.01 159.53,58.01 159.65,57.89 159.65,57.48 159.53,57.35 159.22,57.35 159.1,57.23 159.1,56.82 159.22,56.69 159.42,56.69 159.59,56.53 159.59,56.2 159.42,56.03 159.26,56.03 159.1,55.87 159.1,55.54 159.26,55.37 159.53,55.37 159.65,55.25 159.65,54.84 159.53,54.71 159.18,54.71 159.05,54.58 159.05,54.18 159.18,54.05 159.53,54.05 159.65,53.92 159.65,53.52 159.53,53.39 159.18,53.39 159.05,53.26 159.05,52.86 159.18,52.73 159.53,52.73 159.65,52.6 159.65,52.2 159.53,52.07 159.18,52.07 159.05,51.94 159.05,51.54 159.18,51.41 159.53,51.41 159.65,51.28 159.65,50.88 159.53,50.75 159.18,50.75 159.05,50.62 159.05,50.22 159.18,50.09 159.53,50.09 159.65,49.96 159.65,49.56 159.53,49.43 159.13,49.43 159,49.3 159,48.9 159.13,48.77 159.53,48.77 159.65,48.64 159.65,48.23 159.53,48.11 159.26,48.11 159.1,47.94 159.1,47.03 159.31,46.82 159.54,46.82 159.87,47.15 160.1,47.15 160.34,46.92 160.34,46.69 160.01,46.36 160.01,46.12 160.21,45.91 160.45,45.91 160.78,46.25 161.01,46.25 161.25,46.01 161.25,45.78 160.62,45.15 160.62,44.82 161.02,44.43 161.02,23.18 160.89,23.05 160.65,23.05 160.52,23.18 v2(160.52,23.4)
  BOTTOM w0.089: v2(159.73,83.92) JCPU1.P6
  BOTTOM w0.165: JDIMM2.113 158.9,25.02 v2(160.52,23.4)
DDR_CKE0_DIMMA: length 60.5
  IN4 w0.089: v2(148.73,86.92) 148.57,86.92 148.11,86.45 148.11,79.63 147.49,79.02 147.49,78.38 146.46,77.36
  IN4 w0.165: v2(145.18,35.4) 144.88,35.4 143.08,37.21 143.08,43.26 142.61,43.73 142.61,57.9 144.06,59.35 144.06,62.73 145.84,64.51 145.84,76.73 146.46,77.36
  BOTTOM w0.089: JCPU1.AD9 149.2,87.39 v2(148.73,86.92)
  BOTTOM w0.165: JDIMM1.73 146.9,37.12 v2(145.18,35.4)
DDR_CKE1_DIMMA: length 62.1
  IN4 w0.089: 147.26,77.36 147.8,77.89 147.8,78.87 148.3,79.37 148.3,85.14 149.73,86.57 v2(149.73,86.92)
  IN4 w0.165: 147.26,77.36 146.34,76.43 146.34,64.3 144.56,62.52 144.56,59.15 143.11,57.7 143.11,43.94 143.59,43.46 143.59,37.75 144.72,36.62 145.51,36.62 145.68,36.45 145.68,34.37 v2(145.18,33.88)
  BOTTOM w0.089: v2(149.73,86.92) 150.2,87.39 JCPU1.AC9
  BOTTOM w0.165: v2(145.18,33.88) 147.2,31.86 JDIMM1.74
DDR_CKE2_DIMMB: length 75.7
  IN1 w0.089: 144.85,77.36 144.85,78.57 145.17,78.89 145.17,88.19 145.36,88.38 146.06,88.38 146.52,87.92 v2(146.73,87.92)
  IN1 w0.165: 144.85,77.36 144.85,69.81 143.39,68.34 143.39,63.87 142.89,63.38 142.89,48.29 143.18,47.99 143.18,26.8 143.76,26.23 143.76,24.74 144.6,23.9 144.6,22.43 v2(145.15,21.87)
  BOTTOM w0.089: JCPU1.AF10 147.2,88.39 v2(146.73,87.92)
  BOTTOM w0.165: JDIMM2.73 146.9,23.62 v2(145.15,21.87)
DDR_CKE3_DIMMB: length 74
  IN1 w0.089: 145.34,77.36 145.36,77.37 145.36,87.55 v2(145.73,87.92)
  IN1 w0.165: v2(145.15,20.35) 145.65,20.84 145.65,23.55 144.26,24.94 144.26,26.43 143.68,27.01 143.68,48.2 143.39,48.49 143.39,61.46 143.88,61.96 143.88,68.14 145.34,69.6 145.34,77.36
  BOTTOM w0.089: v2(145.73,87.92) 146.2,88.39 JCPU1.AG10
  BOTTOM w0.165: v2(145.15,20.35) 145.58,20.35 147.2,18.73 JDIMM2.74
DDR_CS0_DIMMA#: length 66
  IN4 w0.089: 161.71,77.67 161.71,78.24 161.32,78.62 161.32,84.49 v2(161.73,84.89)
  IN4 w0.152: 161.71,77.67 161.71,77.39
  IN4 w0.165: v2(160.4,35.4) 160.73,35.4 160.84,35.5 160.84,37.35 160.96,37.48 161.41,37.48 161.54,37.35 161.54,37.15 161.64,37.05 163.03,37.05 163.16,37.17 163.16,39.09 163.03,39.22 162.5,39.22 162.38,39.09 162.38,38.08 162.28,37.98 161.73,37.98 161.63,38.08 161.63,39.82 161.73,39.92 163.06,39.92 163.16,40.02 163.16,45.19 163.06,45.3 162.54,45.3 162.44,45.4 162.44,48.79 162.84,49.19 162.84,49.92 163.63,50.71 163.63,61.86 161.65,63.83 161.65,77.33 161.71,77.39
  BOTTOM w0.089: v2(161.73,84.89) 161.2,85.42 JCPU1.M7
  BOTTOM w0.165: JDIMM1.114 159.2,34.2 v2(160.4,35.4)
DDR_CS1_DIMMA#: length 65
  IN4 w0.089: v2(162.73,86.92) 162.25,86.44 161.64,86.44 161.13,85.93 161.13,78.36 161.13,78.36 161.13,77.36
  IN4 w0.165: v2(162.05,42.08) 162.05,42.31 161.95,42.41 161.6,42.41 161.48,42.28 161.48,40.54 161.6,40.41 162.54,40.41 162.64,40.51 162.64,44.7 162.54,44.8 162.05,44.8 161.95,44.9 161.95,49.36 162.05,49.47 162.24,49.47 162.34,49.57 162.34,50.01 162.24,50.11 162.05,50.11 161.95,50.22 161.95,50.71 162.05,50.81 163.03,50.81 163.13,50.91 163.13,51.38 163.03,51.49 162.05,51.49 161.95,51.59 161.95,52.04 162.05,52.14 163.02,52.14 163.12,52.24 163.12,59.3 163.02,59.4 162.84,59.4 162.73,59.5 162.73,59.93 162.84,60.03 163.03,60.03 163.13,60.13 163.13,60.77 163.03,60.87 162.04,60.87 161.93,60.97 161.93,61.32 162.06,61.44 162.87,61.44 162.99,61.57 162.99,61.79 162.64,62.14 162.04,62.14 161.93,62.24 161.93,62.85 161.13,63.65 161.13,77.36
  BOTTOM w0.089: v2(162.73,86.92) JCPU1.L9
  BOTTOM w0.165: JDIMM1.121 161.3,40.3 161.43,40.42 161.73,40.42 161.86,40.55 161.86,40.88 161.76,40.98 161.49,40.98 161.39,41.08 161.39,42.3 161.49,42.41 161.95,42.41 162.05,42.3 v2(162.05,42.08)
DDR_CS2_DIMMB#: length 79.1
  IN1 w0.089: 160.87,77.36 160.48,77.75 160.34,77.75 159.32,78.76 159.32,81.25 159.45,81.38 160.23,81.38 160.36,81.51 160.36,81.79 160.23,81.92 v2(159.73,81.92)
  IN1 w0.165: v2(160.52,20.35) 160.84,20.35 160.97,20.22 160.97,18.85 161.1,18.72 161.43,18.72 161.55,18.85 161.55,20.04 161.68,20.17 162.05,20.17 162.17,20.04 162.17,19.04 162.37,18.85 163.97,18.85 164.23,19.11 164.23,22.36 163.53,23.06 163.53,26.73 164.25,27.45 164.25,37.31 164.63,37.7 164.63,46.13 162.77,48 162.77,75.46 160.87,77.36
  BOTTOM w0.089: v2(159.73,81.92) JCPU1.P4
  BOTTOM w0.165: v2(160.52,20.35) 159.96,20.35 159.2,19.59 JDIMM2.114
DDR_CS3_DIMMB#: length 77.8
  IN1 w0.089: v2(157.73,79.92) 157.32,79.51 157.32,78.76 158.36,77.73 158.57,77.73 158.75,77.55 158.75,77.36
  IN1 w0.165: v2(161.61,28.34) 161.61,28.33 161.74,28.2 162.14,28.2 162.27,28.33 162.27,29.43 162.14,29.56 161.64,29.56 161.51,29.68 161.51,30.06 161.64,30.19 162.14,30.19 162.27,30.31 162.27,30.71 162.14,30.83 161.64,30.83 161.51,30.96 161.51,31.33 161.64,31.46 162.14,31.46 162.27,31.58 162.27,31.94 162.14,32.06 161.64,32.06 161.51,32.19 161.51,32.53 161.64,32.66 162.04,32.66 162.17,32.79 162.17,34.97 162.04,35.1 161.64,35.1 161.51,35.23 161.51,35.7 161.64,35.82 162.14,35.82 162.27,35.95 162.27,36.45 162.14,36.57 161.71,36.57 161.58,36.7 161.58,37.88 161.71,38.01 162.14,38.01 162.27,38.13 162.27,38.45 162.14,38.58 161.71,38.58 161.58,38.71 161.58,39.09 161.71,39.22 162.14,39.22 162.27,39.34 162.27,39.72 162.14,39.85 161.71,39.85 161.58,39.98 161.58,44.66 162.11,45.19 162.11,45.85 160.22,47.74 160.22,62.18 159.59,62.81 159.59,67.99 159.76,68.15 160.62,68.15 160.78,68.32 160.78,68.65 160.62,68.81 159.76,68.81 159.59,68.98 159.59,69.31 159.76,69.47 160.62,69.47 160.78,69.64 160.78,69.97 160.62,70.13 159.76,70.13 159.59,70.3 159.59,70.63 159.76,70.79 160.62,70.79 160.78,70.96 160.78,71.29 160.62,71.45 159.76,71.45 159.59,71.62 159.59,71.95 159.76,72.11 160.62,72.11 160.78,72.28 160.78,72.61 160.62,72.77 159.76,72.77 159.59,72.94 159.59,73.27 159.76,73.43 160.62,73.43 160.78,73.6 160.78,74.02 160.66,74.14 159.13,74.14 159,74.27 159,74.65 159.13,74.78 159.88,74.78 160.01,74.9 160.01,75.41 159.88,75.54 158.88,75.54 158.75,75.67 158.75,77.36
  BOTTOM w0.089: v2(157.73,79.92) 158.2,80.39 JCPU1.R2
  BOTTOM w0.165: JDIMM2.121 161.3,26.99 161.04,27.24 161.04,27.78 v2(161.61,28.34)
DDR_HVREF_RST_PCH: length 211.9
  TOP w0.102: QD7.2 165.12,18.3 164.49,18.94 164.49,19.66 164.34,19.81 163.62,19.81 161.26,17.45 161.26,16.04 160.85,15.63 147.57,15.63 146.25,16.95 132.15,16.95 131.81,17.29 QD9.2 128.64,17.29 127.83,18.1 122.27,18.1 119.27,21.09 119.27,22.94 120.29,23.95 CD45.1 120.29,25.5 v2(120.49,25.7) 122.06,27.27 122.06,28.45 122.23,28.63 QD6.2 QD6.5 ; RC104.2 139.3,56.31 v1(139.89,55.72) 140.05,55.56 v2(142.15,55.56)
  IN2 w0.089: 204.73,60.44 204.76,60.46 204.76,60.57 205.42,61.23 205.42,62.82 206.42,63.82 206.58,63.98 v2(206.58,64.51)
  IN2 w0.127: v2(142.15,55.56) 146.35,51.36 183.08,51.36 184.45,52.73 v2(184.45,59.89) ; 204.73,60.44 201.99,57.7 201.99,57.43 200.24,55.68 200.24,54.1 198.78,52.65 v2(195.81,52.65) 195.81,51.95 197.39,50.37 197.39,49.82 196.76,49.19 194.21,49.19 192.13,51.27 v2(191.08,51.27)
  BOTTOM w0.089: UH1.N8 206.49,64.61 v2(206.58,64.51)
  BOTTOM w0.102: v2(142.15,55.56) 122.28,55.56 119.07,52.35 119.07,44.35 119.82,43.6 119.82,26.38 v2(120.49,25.7) ; v2(195.81,52.65) 196.16,53 RH170.2 ; v2(191.08,51.27) 189.71,52.64 189.71,53.88 184.45,59.14 v2(184.45,59.89)
DDR_XDP_SMBCLK_R1: length 3.3
  TOP w0.102: RC26.2 112.92,117.22 112.3,117.22 v2(112.1,117.42)
  BOTTOM w0.102: JXDP1.53 112.84,117.4 112.72,117.27 112.25,117.27 v2(112.1,117.42)
DDR_XDP_SMBDAT_R1: length 3.3
  TOP w0.102: v2(112.1,116.84) 112.24,116.98 112.94,116.98 RC25.2
  BOTTOM w0.102: JXDP1.51 112.74,116.9 112.59,117.04 112.3,117.04 v2(112.1,116.84)
DDR_XDP_WAN_SMBCLK: length 469.2
  TOP w0.102: U27.13 173.42,134.6 173.21,134.39 173.21,134.22 173.19,134.19 173.19,134.12 v2(172.83,133.77) ; v2(269.22,75.81) 269.26,75.81 269.3,75.84 272.14,75.84 273.21,76.92 273.21,78.2 273.65,78.64 275.74,78.64 RH31.1 ; RC26.1 114.55,117.3 116.04,117.3 v2(116.47,117.73)
  IN1 w0.102: v2(188.05,62.25) 187.99,62.25 188.04,62.2 188.79,62.2 189.35,61.64 189.35,61.06 188.51,60.23 188.51,60.17 188.51,55.47 192.38,51.6 192.38,51.6 197.58,46.4 197.58,45.69 198.36,44.92 198.36,41.92 199.11,41.16 199.41,41.16 205.41,35.17 209.2,35.17 210.44,33.93 210.44,33.33 v2(210.37,33.26) 210.85,32.78 211.35,32.78 211.54,32.97 226.43,32.97 226.94,33.48 226.94,43.7 228.44,45.2 231.53,45.2 233.06,46.73 237.14,46.73 237.92,47.51 237.92,49.89 243.58,55.56 244.19,55.56 245.45,56.81 246.43,56.81 246.57,56.94 247.69,58.06 250.64,58.06 251.48,58.9 253.74,58.9 255.82,56.83 256.8,56.83 258.2,58.23 258.2,60.01 259.53,61.34 259.53,62.61 264.08,67.16 264.08,67.44 269.18,72.55 269.18,75.15 268.88,75.45 268.88,75.76 268.93,75.81 v2(269.22,75.81)
  IN2 w0.127: v2(116.47,117.73) 116.51,117.73 116.98,117.26 116.98,109.23 114.16,106.41 114.16,90.71 114.92,89.95 114.92,87.28 115.32,86.88 118.02,86.88 119.17,85.74 119.17,81.47 120,80.64 120,66.55 128.62,57.92 180,57.92 182.77,60.69 186.09,60.69 186.99,61.59 187.46,61.59 188.05,62.18 v2(188.05,62.25) ; v2(210.37,33.26) 210.37,33.17 210.47,33.07 210.51,33.07 210.64,32.94 210.64,32.69 205.62,27.67 189.29,27.67 188.58,26.96 188.25,26.96 188.06,27.15 188.06,27.42 v2(188.27,27.63) ; v2(121.13,14.58) 120.9,14.58 120.55,14.22 120.55,13.97 121.29,13.22 121.29,11.87 120.86,11.44 120.2,11.44 119.82,11.82 119.82,12.59 v2(119.29,13.12)
  IN4 w0.102: v2(116.47,117.73) 117.01,117.73 118.01,118.73 120.2,118.73 121.88,120.41 126.29,120.41 126.83,119.87 126.91,119.79 133.11,119.79 133.45,120.13 137.35,120.13 137.37,120.13 137.42,120.18 138.79,120.18 139.38,120.76 142.13,120.76 142.36,120.54 143.08,120.54 143.79,121.25 148.88,121.25 149.27,120.85 150.25,120.85 150.77,120.33 151.3,120.33 151.91,120.94 156.6,120.94 157.21,120.33 159.56,120.33 160.57,119.32 169.81,119.32 172.84,122.34 172.84,129.95 173.5,130.6 173.5,132.51 173.21,132.79 173.21,133.36 172.83,133.74 v2(172.83,133.77)
  BOTTOM w0.102: R502.2 119.29,13.7 v2(119.29,13.12) ; v2(121.13,14.58) 121.31,14.76 121.96,14.76 122.68,14.03 137.9,14.03 138.11,14.25 141.21,14.25 142.6,15.63 147.03,15.63 148.41,14.25 160.2,14.25 160.8,14.85 167.22,14.85 167.87,15.49 169.15,15.49 169.6,15.94 184.99,15.94 185.41,16.36 185.41,16.56 185.6,16.74 JDIMM2.202 185.6,19.05 185.41,19.23 185.41,20.77 188.07,23.43 188.07,27.43 v2(188.27,27.63) 188.01,27.89 188.01,28.59 187.36,29.24 185.64,29.24 185.41,29.46 185.41,29.56 185.6,29.74 JDIMM1.202 ; QH4.1 188.02,62.3 188.02,62.28 187.99,62.25 v2(188.05,62.25)
  BOTTOM w0.305: U88.4 119.48,12.92 v2(119.29,13.12)
DDR_XDP_WAN_SMBCLK_R2: length 12.4
  TOP w0.102: v2(274.82,76.57) 275.01,76.38 v4(276.5,76.38) 277.1,76.38 277.97,77.25 277.97,78.56 277.76,78.77 277.31,78.77 RH31.2
  BOTTOM w0.102: JXDP2.53 275.16,78.33 274.98,78.51 273.93,78.51 273.24,77.81 273.24,77.25 274.06,76.43 274.06,76.43 274.11,76.38 274.63,76.38 274.69,76.44 v2(274.82,76.57)
DDR_XDP_WAN_SMBDAT: length 469.9
  TOP w0.102: RC25.1 114.69,117.06 116.38,117.06 v2(116.47,117.14) ; v2(173.41,133.74) 173.41,134.1 173.44,134.12 173.44,134.29 173.53,134.39 173.54,134.39 173.68,134.53 173.82,134.53 U27.14 ; v2(269.15,76.42) 269.29,76.42 269.63,76.07 272.04,76.07 272.98,77.01 272.98,78.3 273.55,78.87 275.48,78.87 RH30.1
  IN1 w0.102: v2(189.8,61.64) 189.66,61.5 189.66,60.99 188.74,60.08 188.74,55.56 192.47,51.83 192.48,51.83 197.81,46.49 197.81,45.79 198.59,45.01 198.59,42.01 199.21,41.39 199.5,41.39 205.5,35.39 209.3,35.39 210.66,34.03 210.66,33.56 v2(211.03,33.2) 226.34,33.2 226.72,33.58 226.72,43.8 228.35,45.43 231.43,45.43 232.96,46.96 236.93,46.96 237.69,47.71 237.69,49.98 243.49,55.78 244.1,55.78 245.35,57.04 246.34,57.04 247.59,58.29 250.55,58.29 251.39,59.13 253.84,59.13 255.91,57.06 256.71,57.06 257.97,58.32 257.97,60.1 259.3,61.43 259.3,62.7 263.85,67.25 263.85,67.54 268.96,72.64 268.96,75.05 268.65,75.36 268.65,75.92 v2(269.15,76.42)
  IN2 w0.127: v2(121.13,15.16) 121.05,15.16 120.29,14.4 120.29,13.87 121.04,13.12 121.04,12.01 120.72,11.7 120.33,11.7 120.07,11.95 120.07,12.29 120.18,12.39 120.48,12.39 v2(120.49,12.38) ; v2(189.8,61.64) 187.98,61.64 187.68,61.34 187.1,61.34 186.19,60.44 182.88,60.44 180.11,57.67 128.52,57.67 119.74,66.44 119.74,80.53 118.91,81.36 118.91,85.48 117.77,86.63 115.22,86.63 114.66,87.18 114.66,89.84 113.9,90.61 113.9,106.51 116.72,109.33 116.72,116.89 v2(116.47,117.14) ; v2(211.03,33.2) 210.89,33.06 210.89,32.59 205.72,27.42 189.39,27.42 188.68,26.71 188.14,26.71 187.79,27.06 187.79,27.47 v2(187.63,27.63)
  IN4 w0.102: v2(116.47,117.14) 116.75,117.14 118.1,118.5 120.3,118.5 121.97,120.18 126.19,120.18 126.6,119.77 126.82,119.56 133.2,119.56 133.55,119.9 137.35,119.9 137.46,119.9 137.51,119.95 138.89,119.95 139.47,120.54 142.03,120.54 142.26,120.31 143.18,120.31 143.89,121.02 148.78,121.02 149.18,120.62 150.15,120.62 150.68,120.1 151.4,120.1 152.01,120.71 156.5,120.71 157.11,120.1 159.46,120.1 160.48,119.09 169.91,119.09 173.07,122.25 173.07,129.85 173.73,130.51 173.73,132.6 173.47,132.85 173.47,133.43 173.41,133.48 v2(173.41,133.74)
  BOTTOM w0.102: v2(120.49,12.38) 121.47,12.38 121.78,12.08 R501.2 ; QH4.4 189.97,62.19 189.97,61.88 189.73,61.64 v2(189.8,61.64) ; JDIMM1.200 185,29.74 185.19,29.56 185.19,29.36 185.55,28.99 187.28,28.99 187.78,28.49 187.78,27.78 v2(187.63,27.63) 187.84,27.42 187.84,23.52 185.19,20.86 185.19,19.23 185,19.05 JDIMM2.200 185,16.74 185.19,16.56 185.19,16.46 184.9,16.17 169.5,16.17 169.06,15.72 167.78,15.72 167.13,15.07 160.7,15.07 160.1,14.48 148.51,14.48 147.13,15.86 142.5,15.86 141.12,14.48 138.02,14.48 137.8,14.26 122.78,14.26 122.05,14.99 121.31,14.99 v2(121.13,15.16)
  BOTTOM w0.305: R501.2 120.5,11.01 U88.6
DDR_XDP_WAN_SMBDAT_R2: length 13.6
  TOP w0.102: RH30.2 277.31,78.99 277.86,78.99 278.2,78.65 278.2,77.16 277.19,76.15 274.99,76.15 v2(274.82,75.98)
  BOTTOM w0.102: JXDP2.51 275.16,78.83 275.07,78.74 273.84,78.74 273.01,77.91 273.01,77.16 273.82,76.34 273.82,76.34 274.01,76.15 274.66,76.15 v2(274.82,75.98)
DE_A: length 5.4
  TOP w0.102: U7.7 325.45,130.22 325.78,129.9 325.78,128.68 R554.2 R1686.1 v1(326.4,126.01)
DE_B: length 5.2
  TOP w0.102: U7.8 325.6,130.72 R550.2 R1685.1 326.87,128.51 v1(328.38,128.51)
DEFAULT_OVRDE: length 256.4
  TOP w0.102: v2(275,55.88) 275,55.94 274.55,56.39 U46.A16 ; v1(168.07,167.09) 167.75,167.41 PR856.1
  TOP w0.254: v2(165.39,170.85) 166.69,170.85 167.57,169.98 168.04,169.98 168.31,169.71 168.31,168.9 PR856.1
  IN3 w0.127: v2(275,55.88) 275.1,55.98 278.98,55.98 280.17,57.18 280.17,61.91 276.97,65.11 276.97,101.38 272.75,105.6 272.75,125.47 272.55,125.68 272.55,129.29 271.86,129.98 271.86,135.25 272.15,135.54 272.15,136.94 272.72,137.51 272.72,142.76 272.06,143.42 271.94,143.42 268.42,146.94 268.42,149.68 269.05,150.3 269.05,165.63 268.05,166.63 268.05,168.97 269.16,170.08 269.16,173.45 269.79,174.08 269.79,176.47 262.8,183.46 252.65,183.46 251.49,184.63 248.97,184.63 248.63,184.29 235.6,184.29 231.79,180.48 227.31,180.48 226.72,181.08 220.16,181.08 216.58,177.49 212.5,177.49 212.25,177.24 205.4,177.24 204.66,177.98 202.42,177.98 202.37,178.03 197.83,178.03 197.57,177.76 196.04,177.76 195.77,178.03 194.66,178.03 194.39,177.76 192.23,177.76 190.72,176.25 188.82,176.25 187.32,174.75 183.88,174.75 183.54,175.09 181.06,175.09 180.59,175.56 179.02,175.56 178.75,175.3 177.25,175.3 177.1,175.45 176.31,175.45 176,175.15 174.04,175.15 173.15,176.03 172.66,176.03 171.11,174.47 169.02,174.47 v2(165.39,170.85)
DEFAULT_OVRDE_C2: length 5
  TOP w0.203: PU808.7 164,171.21 164.63,170.57 164.83,170.57
  TOP w0.254: PR856.2 166.63,170.37 v1(166.11,170.37) 165.03,170.37 164.83,170.57
DEVICE_DET#: length 136.4
  TOP w0.102: R1125.2 283.31,101.96 282.63,102.63 282.35,102.63 v2(282.32,102.59) ; R1070.2 277,125.37 277.24,125.62 277.24,125.76 v2(277.25,125.78)
  IN2 w0.127: v2(282.32,102.59) 282.28,102.59 281.83,102.15 281.06,102.15 279.23,103.97 278.37,103.97 278.28,103.89 275.63,103.89 258.4,103.89 v2(257.93,104.36)
  IN3 w0.127: v2(257.93,104.36) 257.93,103.67 248.12,93.85 248.12,87.46 249.31,86.26 249.31,71.64 247.77,70.1 247.77,62.87 248.09,62.55 248.09,61.62 247.34,60.87 247.34,57.31 246.9,56.86 246.9,55.16 245.48,53.75 245.48,51.27 245.05,50.84 245.05,45.19 243.92,44.06 242.72,44.06 238.3,39.64 235.61,39.64 234.19,41.06 JSATA2.8
  BOTTOM w0.102: v2(277.25,125.78) 277.6,126.12 279.03,126.12 279.54,125.62 279.54,112.86 279.38,112.71 279.38,110.81 278.29,109.72 278.29,106.31 280.5,104.1 280.92,104.1 282.32,102.7 v2(282.32,102.59) ; v2(257.93,104.36) v1(257.93,105.16)
DEVICE_DET_R#: length 39.8
  TOP w0.102: v1(295.89,121.39) 295.59,121.69 v2(295.14,121.69) ; U51.B1 292.37,109.91 293.38,108.9 293.38,108.75 v2(293.78,108.34) ; v2(277.29,124.38) 277.21,124.46 R1070.1
  IN2 w0.127: v2(277.29,124.38) 278.13,124.38 278.65,124.9 280.75,124.9 281.29,125.44 282.05,125.44 282.35,125.13 286.14,125.13 286.46,124.81 288.28,124.81 288.74,124.35 288.74,123.86 291.78,120.83 294.28,120.83 v2(295.14,121.69)
  IN4 w0.102: v2(293.78,108.34) 293.91,108.34 295.36,109.79 295.36,116.24 296.38,117.26 296.38,120.46 v2(295.14,121.69)
DGPU_HOLD_RST#: length 141.9
  TOP w0.102: v1(246.49,133.49) 246.03,133.95 v2(246.03,134)
  IN2 w0.127: v2(258.1,135.06) 257.83,135.06 257.4,134.63 254.17,134.63 253.68,134.14 246.17,134.14 v2(246.03,134)
  IN3 w0.127: v2(258.1,135.06) 258.22,135.06 259.9,133.39 259.9,131.23 259.1,130.43 259.1,113.46 256.98,111.34 256.98,108.69 257.18,108.48 257.18,105.22 256.83,104.87 256.83,103.64 247.04,93.85 247.04,86.09 244.09,83.15 244.09,81.6 244.6,81.09 244.6,78.01 244.6,74.02 244.23,73.65 244.23,71.25 243.7,70.72 243.7,60.28 243.42,60.01 243.42,59.8 243.42,59.8 243.42,58.52 238.47,53.57 237.34,53.57 235.87,52.1 229.42,52.1 228.29,53.23 221.7,53.23 220.91,52.44 218.96,52.44 216.25,55.14 215.62,55.14 v2(215.34,55.42)
  BOTTOM w0.089: 212.11,61.52 211.43,62.2 211.43,62.6 UH1.A12
  BOTTOM w0.102: RV33.2 v2(246.03,134) 246.03,133.81 245.86,133.63 UV14.1 ; v2(215.34,55.42) 214.8,55.96 214.8,57.25 214.66,57.39 214.66,58.67 213.15,60.18 213.15,60.23 212.83,60.55 212.83,60.8 212.11,61.52
DGPU_PEX_RST: length 36
  TOP w0.102: v2(226.67,115.24) 226.93,115.51 RV18.1 ; D71.1 242.34,120.49 v2(241.8,119.95) v1(240.77,118.92) 240.77,116.6 v2(241.21,116.17)
  IN1 w0.102: v2(243.04,129.29) 243.05,129.29 243.24,129.1 243.24,121.39 v2(241.8,119.95)
  IN3 w0.102: 237.85,116.92 237.16,116.92 236.77,116.54 227.69,116.54 227.38,116.22
  IN3 w0.127: v2(226.67,115.24) 227.15,115.24 227.38,115.47 227.38,116.22 ; 237.85,116.92 240.46,116.92 v2(241.21,116.17)
  BOTTOM w0.102: v2(243.04,129.29) 243.04,130.59 243.39,130.95 RV29.2 243.82,131.64 243.82,131.99 243.48,132.33 UV14.4
DGPU_PEX_RST_R: length 9.5
  TOP w0.102: RV18.2 227.44,117.22 226.84,117.82 226.84,118.95 226.17,119.62 226.17,120.03 226.36,120.22 v1(226.36,120.33) 226.36,121.04 226.27,121.13 226.27,121.32 225.52,122.07 225.48,122.07 225.2,122.35 v2(224.2,122.35)
  BOTTOM w0.102: UV1.AA30 224.11,123.13 224.11,122.45 v2(224.2,122.35)
DGPU_PWR_EN: length 232.8
  TOP w0.203: v2(247.19,143.71) 247.36,143.54 U103.5
  TOP w0.254: PR688.1 279.51,137.49 v2(279.7,137.68) ; PR681.1 202.19,96.81 202.46,97.08 v1(203.06,97.08) v4(204.12,97.08)
  IN1 w0.254: v4(315.42,168.64) 315.48,168.64 318.17,165.95 318.17,158.52 318.96,157.73 318.96,156.54 v2(318.31,155.89) ; v4(314.12,155.03) 313.09,154 313.09,152.73 310.73,150.37 310.73,146.31 311.26,145.78 311.26,143.95 311.41,143.8 v2(311.41,143.6)
  IN2 w0.254: v2(312.35,138.29) 312,137.93 305.04,137.93 303.51,139.46 294.37,139.46 293.48,138.57 293.41,138.57 293.19,138.35 290.78,138.35 290.11,139.01 287.68,139.01 286.53,140.17 281.26,140.17 280.81,139.72 280.81,138.1 280.39,137.68 v2(279.7,137.68) 279.4,137.68 279.28,137.79 274.9,137.79 274.89,137.81 271.74,137.81 271.7,137.77 271.47,137.77 268.12,134.42 265.34,134.42 265.24,134.31 263.77,134.31 260,130.54 254.78,130.54 254.62,130.38 v2(254.62,130.24)
  IN3 w0.254: v4(204.12,97.08) 204.12,97.07 205.43,97.07 205.58,97.22 207.07,97.22 207.6,96.68 207.6,95.88 209.29,94.18 209.79,94.18 210.12,94.51 210.12,94.54 210.81,95.24 218.26,95.24 222.01,91.49 226.7,91.49 228,90.18 230.14,90.18 230.93,89.4 239.82,89.4 240.83,90.41 240.83,96.45 247.48,103.1 247.48,103.97 249.84,106.34 251.07,106.34 251.58,106.84 251.58,109.84 252.14,110.4 252.14,111.14 253.18,112.18 253.18,112.66 255.71,115.19 255.71,119.06 254.94,119.84 254.94,123.52 254.03,124.42 254.03,128 254.51,128.47 254.95,128.47 255.25,128.78 255.25,129.6 v2(254.62,130.24) 254.62,130.79 254.31,131.09 254.31,135.56 255.42,136.66 255.42,145.6 254.7,146.32 252,146.32 250.58,144.89 247.44,144.89 247.01,144.46 247.01,143.89 v2(247.19,143.71)
  IN4 w0.254: v2(318.31,155.89) 318.21,155.89 316.43,154.11 315.03,154.11 v4(314.12,155.03)
  BOTTOM w0.254: PR696.2 315.07,155.66 PC679.1 314.68,155.59 v4(314.12,155.03) ; PR600.1 313.01,168.74 313.52,169.25 314.7,169.25 315.31,168.64 v4(315.42,168.64) ; v2(311.41,143.6) 311.41,143.14 311.98,142.58 311.98,139.55 312.35,139.18 v2(312.35,138.29)
