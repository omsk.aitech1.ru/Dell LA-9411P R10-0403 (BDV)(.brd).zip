# Allegro board LA-9411P R10-0403.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
+1.35V_MEM_GFX_CHG: length 3
  TOP w0.102: v1(185.11,105.79) 184.89,106.01 184.46,106.01 184.19,106.28 QV11.1
  TOP w0.508: QV11.1 185.43,106.77 RV182.2
+1.35V_MEN_P: length 90.4
  TOP w0.508: PC211.2 PR204.2 v4(215.2,9.21)
  IN1 w0.254: v4(215.2,9.21) 212.48,6.49 204.83,6.49 202.93,4.58 202.93,1.79 202.28,1.14 186.56,1.14 185.53,2.17 185.53,4.33 184.51,5.35 178.29,5.35 177.53,6.11 v4(177.53,8.52)
  IN1 w0.508: v4(211.88,10.93) 213.47,10.93 v4(215.2,9.21)
  IN1 w0.762: 181.21,7.76 181.21,6.74 181.85,6.11 184.89,6.11 186.29,4.71 186.29,3.03 187.41,1.92 201.15,1.92 202.17,2.93 202.17,4.84 204.58,7.25 208.39,7.25 209.53,8.39
  vias: v1(184.77,12.59) v4(177.53,9.28) v4(177.66,10.05) v4(178.25,9.3) v4(178.23,8.57) v4(178.42,10.05) v4(179.66,10.17) v4(180.58,10.05) v4(181.08,9.28) v4(181.34,8.52) v4(181.47,10.05) v4(181.85,9.28) v4(182.23,8.52) v4(182.35,10.05) v4(182.74,9.28) v4(183.12,8.52) v4(183.24,10.05) v4(183.75,9.28) v4(184.01,8.52) v4(184.13,10.05) v4(184.64,9.28) v4(184.89,8.52) v4(185.02,10.05) v4(185.28,9.28) v4(185.78,8.52) v4(185.91,10.68) v4(185.91,10.05) v4(185.91,9.28) v4(186.67,10.68) v4(186.67,10.05) v4(187.52,10.69) v4(187.51,10.02) v4(188.32,10.05) v4(210.1,9.92) v4(210.1,9.22)
+3.3V_ALW: length 968.2
  TOP w0.381: U50.5 277.49,120.28 C720.1 ; C725.1 179.92,152.51 181.54,152.51 U54.5
  TOP w0.406: v2(49.31,183.76) 49.93,183.76 50.51,184.34 PU802.5 ; PU804.5 50.77,190.58 PC801.2 ; v2(47.43,190.04) 47.56,190.04 47.97,189.63 PU803.5 ; PU704.5 91.01,160.78 90.72,161.07 88.69,161.07 88.32,161.44 PC733.2
  TOP w0.457: PU801.5 47.72,185.02 v2(48.32,185.62)
  TOP w0.508: R776.1 277.86,47.83 v2(278.04,48.01) ; v2(258.53,95.01) 259.36,94.18 R1162.1 ; v2(200.13,187.46) 200.77,188.1 R755.2 ; v2(285.56,104.71) 285.56,104.72 285.57,104.74 285.57,105.12 R820.1 ; v2(218.19,57.45) 218.19,57.11 216.78,55.7 216.78,55.05 216.09,54.36 215.5,54.36 v2(214.49,53.35) ; R763.1 277.4,49.68 v2(278.11,49.68) ; PR895.1 147.86,181.84 147.54,182.16 v2(147.54,182.47) ; v2(299.6,116.85) 299.6,116.78 299.37,116.55 R875.1 ; PR868.2 158.69,170.18 v4(159.32,169.56) ; 262.7,42.07 262.7,43.34 263.02,43.67 R761.1 R762.1 ; 262.7,42.07 v2(262.83,41.94) 262.83,40.92 263.14,40.62 R805.1 ; 262.7,42.07 261.17,42.07 260.7,42.54 260.7,46.98 259.35,48.33 R796.1 258.73,48.91 258.66,48.83 v2(258.55,48.83) ; U55.5 170.86,156.79 v2(170.8,156.86) C726.1 ; R920.1 287.56,103.64 v2(287.79,103.87) ; 45.18,187.73 44.42,186.97 44.42,174.78 43.82,174.18 43.82,171.83 46.87,168.78 83.31,168.78 86.6,165.49 88.39,165.49 v2(88.43,165.46) 87.64,164.67 PR748.1 88.32,163.63 PC733.2 ; 45.18,187.73 45.58,187.34 PC802.2 ; 45.18,187.73 v2(45.18,187.88) 45.7,188.4 PR810.1 ; v4(216.77,15.13) 216.77,15.38 216.01,16.14 PR209.1 ; v2(261.78,67.35) 258.97,67.35 258.61,66.98 252.14,66.98 251.47,66.31 250.89,65.73 248.46,65.73 242.24,59.51 242.24,59.07 v2(242.17,59.13) 241.27,58.23 PR2.1 ; R760.1 259.04,58.62 258.61,59.05 v2(258.61,59.12) ; R760.1 259.35,58.62 R798.1 ; R760.1 R768.1 ; v2(278.27,118.29) 278.37,118.19 278.43,118.19 278.9,117.72 R1171.1 ; v2(292.54,100.83) 292.34,100.62 292.32,100.62 292.32,100.11 292.22,100.01 R872.1 ; R839.1 289.45,106.32 289.02,106.76 v2(289.02,107) ; v2(258.61,54.1) 258.86,53.85 259.05,53.85 R778.1 R769.1 ; R937.1 319.9,163.51 318.24,161.86 v2(316.96,161.86) ; RC4.1 135.44,66.26 135.09,65.9 135.09,64.56 131.83,61.31 131.83,38.81 134.17,36.48 134.17,28.82 v2(135.19,27.8) ; 246.29,144.67 245.06,144.67 244.78,144.94 243.37,144.94 242.81,144.39 242.81,143.4 243.34,142.86 243.34,138.11 242.35,137.12 242.35,134.4 v2(242.18,134.24) ; R418.1 R841.1 296.49,111.77 v2(296.48,111.77) 296.48,111.77 R838.1 R420.1 ; v2(228.11,48.18) 228.11,48.09 228.14,48.07 228.14,47.45 227.12,46.43 226.28,46.43 v2(226.03,46.18) 225.58,46.63 219.6,46.63 217.86,44.89 217.86,41.76 214.61,38.51 214.61,32.49 211.95,29.82 v2(211.95,27.62) ; R51.1 284.21,122.59 v2(284.29,122.67) ; v2(276.44,119.11) 276.71,119.38 277.22,119.38 277.62,119.77 C720.1 ; v2(47.43,190.04) 46.85,189.46 PC805.2 ; v2(50.71,191.46) PC801.2 ; R52.2 296.11,109.87 296.49,110.25 v2(296.79,110.25) ; v2(180.65,153.12) 180.27,153.12 179.89,152.74 C725.1 ; U1.2 9.76,216.17 C1.1 9.86,216.78 v2(9.6,217.04) ; R1125.1 283.4,100.72 285.15,100.72 R818.1 285.59,100.52 286.01,100.1 v2(286.01,99.34) ; PR801.1 54.42,190.94 53.81,191.55 v2(53.54,191.55) ; RH247.1 219.18,87.25 219.45,87.52 219.45,89.33 v2(222.8,92.68) ; v2(317.65,136.56) 317.65,136.31 318.13,135.83 C756.1 318.16,135.62 JKB1.4 ; R759.1 278.77,119.52 v2(278.25,119) ; R940.1 v2(50.33,193.23) ; PR24.1 v2(129.78,5.22) ; R774.1 266.68,42.21 v2(266.8,42.32) ; R854.1 v2(296.48,113.55) R856.1 R871.1 ; R814.1 v2(278.47,113.3) ; R834.1 282.11,124.54 v2(281.66,124.99) ; PU702.8 107.17,157.24 106.59,156.65 v2(106.59,156.07) ; v2(300.13,114.64) 300.34,114.44 R24.1 ; R817.1 287.4,124.8 v2(287.93,125.34) ; R932.1 v2(328.89,164.17) ; v2(55.56,187.79) PR807.1 PC804.2 58.09,187.79 58.68,187.2 58.68,182.45 59.93,181.2 68.14,181.2 70.76,183.82 70.76,184.31 71.92,185.47 PR720.1 72.2,185.51 71.51,186.19 71.51,187.92 72.35,188.76 v2(73.45,188.76) ; R800.1 268.69,43.07 269.32,42.44 v2(269.32,42.3) ; v2(278.86,52.96) 278.57,52.96 278.24,53.29 278.24,53.48 277.78,53.94 R771.1 ; PR300.2 v4(236.08,3.31) ; v2(276.46,108.43) 276.94,108.43 277.02,108.36 R828.1 278.15,108.36 278.67,108.88 R827.1
  TOP w1.524: 283.13,129.02 282.32,128.21 278.57,128.21 277.68,129.1 277.68,132.73 277.25,133.16 277.25,138.04 275.56,139.73 273.49,139.73 271.14,137.38 268.69,137.38 266.43,139.64 266.43,140.22 265.35,141.3 263.67,141.3 262.63,140.26 253.61,140.26 250.78,143.09 250.78,144.89 250.19,145.49
  IN1 w0.508: v4(114.94,185.84) 114.6,186.18 107.08,186.18 104.99,188.27 104.99,188.95 103.77,190.17 99.45,190.17 98.62,191 89.61,191 89.14,190.53 78.38,190.53 76.61,188.76 v2(73.45,188.76) ; v2(212.59,50.65) 212.71,50.76 212.71,51.57 v2(214.49,53.35) ; v4(159.32,169.56) 157.69,167.93 157.69,165.62 159.01,164.31 162.07,164.31 162.29,164.08 v2(162.29,163.08)
  IN2 w0.508: v2(266.8,42.32) 266.66,42.18 266.66,41.81 266.43,41.58 263.19,41.58 v2(262.83,41.94) ; v2(172.4,186.41) 172.44,186.45 173.97,186.45 176,188.48 177.66,188.48 180.58,191.4 181.97,191.4 182.35,191.78 189.59,191.78 190.36,191.02 192.9,191.02 193.28,190.64 193.28,189.75 195.05,187.97 195.05,186.96 195.31,186.7 199.37,186.7 v2(200.13,187.46) ; v2(180.65,153.12) 180.09,152.56 175.87,152.56 174.33,154.1 172.13,154.1 171.46,153.43 v2(169.64,153.43) ; v2(242.17,59.13) 244.92,59.13 246.49,60.7 255.34,60.7 255.94,60.11 256.9,60.11 257.98,59.03 258.53,59.03 258.61,59.1 v2(258.61,59.12) ; v2(214.31,6.36) 214.94,5.73 222.53,5.73 223.77,4.49 223.77,2.78 224.53,2.02 234.34,2.02 235.63,3.31 v4(236.08,3.31) ; v2(50.33,193.23) 46.44,197.12 43.8,197.12 34.65,206.26 34.65,207.68 29.7,212.64 21.08,212.64 20.74,212.29 14.78,212.29 10.28,216.8 9.84,216.8 v2(9.6,217.04) ; v2(147.54,182.47) 148.53,182.47 149.08,183.02 153.65,183.02 155.18,181.5 158.1,181.5 158.61,182 v2(158.61,182.51)
  IN3 w0.508: v4(144.25,6.62) 146.6,4.27 151.68,4.27 154.36,1.59 174.61,1.59 175.05,2.03 175.05,4.18 176.49,5.61 185.17,5.61 186.47,4.32 186.47,3 187.88,1.59 200.31,1.59 201.4,2.68 201.4,4.32 203.82,6.74 211.18,6.74 211.44,6.48 211.95,5.98 213.93,5.98 v2(214.31,6.36) ; v2(217.76,49.22) 217.76,49.28 215.5,51.55 213.09,51.55 212.71,51.17 212.71,50.76 v2(212.59,50.65) ; v4(131.55,15.38) 131.54,15.38 128.94,12.78 128.94,11.48 127.62,10.16 127.62,5.84 v2(127.17,5.4) ; v4(114.94,185.84) 116.06,185.84 117.23,187.01 121.73,187.01 122.87,185.86 128.29,185.86 128.32,185.84 129.55,185.84 131.87,188.16 132.38,188.16 133.2,188.99 144.51,188.99 147.54,185.95 v2(147.54,182.47) ; v4(216.77,15.13) 216.77,19.44 211.31,24.9 211.31,26.98 v2(211.95,27.62) ; v2(158.61,182.51) 159.49,181.62 159.49,179.97 160.64,178.83 162.16,178.83 162.92,179.59 165.21,179.59 165.97,180.35 165.97,180.97 167.54,182.54 169.53,182.54 170.1,183.11 171.04,183.11 172.4,184.46 v2(172.4,186.41)
  IN4 w0.508: v2(328.89,164.17) 328.82,164.24 326.63,164.24 326.44,164.43 324.95,164.43 v2(323.55,163.03) ; v2(258.61,54.1) 257.67,53.16 257.67,49.42 258.25,48.83 v2(258.55,48.83) ; v4(216.77,15.13) 216.77,14.91 217.69,14 217.69,13.08 214.36,9.75 214.36,6.41 v2(214.31,6.36) ; v2(321.17,206.34) 321.17,208.24 321.98,209.05 321.98,210.41 321.52,210.87 v2(321.19,210.87) ; v4(290.5,133.68) 290.33,133.85 288.9,133.85 288.02,132.97 288.02,126.17 287.93,126.09 v2(287.93,125.34) ; v2(325.98,158.61) 324.11,160.48 v2(323.66,160.48) ; v2(147.54,182.47) 149.8,180.21 149.8,177.39 151.32,175.88 152.95,175.88 155.02,173.81 v2(155.02,172.06)
  BOTTOM w0.381: v2(212.59,50.65) 212.59,50.7 212.24,51.05 U9.5 ; CV87.1 242.73,134.58 243.15,134.16 243.61,134.16 243.78,133.98 243.78,133.77 243.65,133.63 UV14.5
  BOTTOM w0.406: U58.5 320.81,211.33 321.24,210.9 321.24,210.82
  BOTTOM w0.508: v2(218.19,57.45) 218.3,57.56 218.3,58.23 RH238.1 ; R515.1 v2(226.03,46.18) ; PR119.2 144.64,6.24 v4(144.25,6.62) ; C288.1 213.41,52.28 v2(214.49,53.35) ; v2(217.76,49.22) 217.76,49.01 216.26,47.51 215.12,47.51 R1630.2 ; PR878.1 156.23,170.84 155.79,170.84 155.02,171.6 v2(155.02,172.06) 155.02,172.39 155.18,172.54 PR11.2 ; PR878.1 156.24,170.42 157.11,169.56 v4(159.32,169.56) ; PR878.1 PR880.1 ; v2(323.66,160.48) 323.85,160.67 R848.1 R850.1 ; v4(114.94,185.84) 115.15,185.64 PR6.1 ; v2(285.56,104.71) 285.56,104.46 286.14,103.87 v2(287.79,103.87) 287.79,104.36 289.02,105.59 v2(289.02,107) 290.71,107 292.54,105.17 v2(292.54,100.83) 292.11,100.83 291.26,101.68 287.18,101.68 286.01,100.51 v2(286.01,99.34) ; CV87.1 242.55,134.76 242.18,134.39 v2(242.18,134.24) ; v2(106.59,156.07) 102.57,156.07 101.84,155.33 100.44,155.33 95.23,160.54 92.16,160.54 88.43,164.27 v2(88.43,165.46) ; v2(261.78,67.35) 262.09,67.65 262.09,74.14 259.77,76.45 259.77,78.8 258.78,79.8 258.78,81.26 258.24,81.8 258.24,94.72 v2(258.53,95.01) ; v2(168.05,164.11) 163.32,164.11 v2(162.29,163.08) ; v2(228.11,48.18) 228.11,48.55 229.5,49.94 R1183.1 229.98,50.22 230.5,50.74 235.25,50.74 240.47,55.96 240.47,57.05 239.4,58.11 239.4,59.25 239.97,59.82 241.19,59.82 241.88,59.13 v2(242.17,59.13) ; R855.1 R849.1 325.45,158.64 325.51,158.57 325.94,158.57 v2(325.98,158.61) ; v2(258.61,59.12) 258.61,59.1 257.51,58.01 257.51,55.04 258.45,54.1 v2(258.61,54.1) ; v2(321.19,210.87) 321.24,210.82 320.62,210.2 C778.1 ; v2(127.17,5.4) 127.35,5.22 v2(129.78,5.22)
  vias: v2(168.04,164.77) v2(168.04,157.47) v2(168.07,156.1) v2(168.07,155.46) v2(168.07,154.83) v2(169.16,164.17) v2(169.15,163.59) v2(169.15,162.95) v2(169.19,164.79) v2(282.67,186.59) v2(283.31,186.6) v2(283.54,176.72) v2(284.03,186.55) v2(286.49,181.9) v2(286.65,172.36) v2(287.08,181.9) v2(287.24,172.85) v2(287.21,172.16) v2(299.82,189.14) v2(299.82,188.56) v2(300.4,189.14) v2(300.4,188.56) v2(306.68,188) v2(306.68,187.36) v2(306.69,188.68) v2(307.32,188.68) v2(307.31,188) v2(307.31,187.35) v2(307.96,188.68) v2(307.95,188) v2(307.98,187.35) v2(323.1,199.89) v2(323.17,197.93) v2(323.17,197.35) v2(323.39,199.34) v2(323.45,166.16) v2(323.52,167.31) v2(323.76,197.35) v2(323.76,196.76) v2(323.76,196.18) v2(323.97,199.34) v2(325.75,199.33) v2(326.33,199.33) v2(326.78,198.95) v2(326.8,198.36) v2(326.8,197.78) v2(327.34,198.06) v3(249.13,145.73) v3(284.78,175.29) v3(290.56,129.43) v4(132.06,16.01) v4(132.44,15.38) v4(132.95,16.01) v4(133.33,15.38) v4(133.84,16.01) v4(134.22,15.38) v4(134.73,16.01) v4(136,15.51) v4(136.89,15.51) v4(137.27,16.14) v4(137.78,15.51) v4(138.29,16.14) v4(138.67,15.51) v4(139.56,15.51) v4(229.69,98.55) v4(230.36,98.56) v4(231.01,98.56) v4(231.69,98.56) v4(232.33,98.56) v4(232.96,98.56) v4(233.6,98.56) v4(234.26,98.56) v4(290.36,133.04) v4(290.36,132.37) v4(290.99,133.04) v4(290.99,132.37) v4(291.19,133.74)
+3.3V_ALW2: length 865.5
  TOP w0.381: v2(37.2,173.85) PU809.5 37.2,172.54 37.36,172.38 PC818.2
  TOP w0.406: v2(63.47,172.57) 63.65,172.75 PU807.5
  TOP w0.508: PR747.1 71.97,184.59 71.41,184.04 v2(71.41,184) ; v2(265.26,108.58) 273.53,108.58 v2(274.6,107.52) ; v2(239.61,86.66) 239.33,86.39 PR808.1 239.37,85.86 240.09,85.14 PR800.2 ; v2(290.97,103.83) 290.97,103.33 290.51,102.87 R874.2 ; v4(153.14,177.69) 153.14,178.74 PR894.1 ; PR875.1 158.11,173.42 158.76,174.07 v2(158.77,174.07) 159.32,174.07 159.52,174.27 159.52,178.07 158.85,178.74 158.78,178.74 156.5,181.03 154.5,181.03 154.2,181.33 v2(152.18,181.33) ; v2(215.69,48.84) 215.6,48.76 v2(215.6,45.67) ; v2(171.33,115.47) 172.59,115.47 175.34,112.71 176.97,112.71 177.96,111.72 RV81.2 ; v2(217.84,40.8) 215.25,38.21 215.25,31.74 213,29.49 v2(213,27.5) 213.17,27.33 214.85,27.33 216.24,25.95 v2(216.24,24.79) ; RC97.1 139.2,72.38 v2(138.36,72.38) ; PR829.1 59.7,176.29 v2(59.86,176.45) 59.71,176.61 PR849.1 ; v2(208.38,50.4) 208.38,50.31 208.78,49.91 208.78,48.89 209.79,47.89 209.79,47.24 208.97,46.42 v2(208.28,46.42) ; PR824.2 63.81,173.68 63.47,173.34 v2(63.47,172.57) ; v2(157.65,161.82) 157.65,161.65 157.23,161.23 PR862.1 PR846.1 ; PC114.2 v4(150.29,3.57) ; PR823.2 PC812.2 66.33,172.3 66.54,172.52 v2(66.91,172.52) ; PR726.1 90.01,167.14 89.59,167.56 89.59,168.38 90.58,169.37 v2(90.65,169.37) ; PR733.1 102.83,165.24 102.88,165.29 104.3,165.29 104.75,164.85 v2(104.75,164.72) ; v2(165.49,161.42) 165.49,161.43 164.68,162.24 v3(164.68,163.97) 164.68,166.52 v4(164.04,167.16) 163.69,167.51 PR848.1 ; PR864.1 168.33,171.27 v2(168.08,171.02)
  IN1 w0.508: v2(63.47,172.57) 63.53,172.52 v2(66.91,172.52) ; v2(158.77,174.07) 154.71,174.07 152.23,171.59 151.41,171.59 149.69,169.87 131.61,169.87 130.22,171.26 123.81,171.26 122.91,170.37 121.55,169 v4(117.92,169) 117.57,169 117.34,169.23 114.42,169.23 113.58,168.39 105.74,168.39 v2(105.06,169.06) 104.39,168.39 100.02,168.39 100.01,168.38 96.86,168.38 v2(96.34,167.85) 91.86,167.85 90.65,169.06 v2(90.65,169.37) ; v2(106.79,148.73) 106.32,149.2 106.32,149.33 104.15,151.5 104.15,155.22 101.88,157.49 v2(101.58,157.49)
  IN2 w0.508: v2(63.47,172.57) 63.47,175.54 62.35,176.66 60.07,176.66 v2(59.86,176.45) ; v2(217.84,40.8) 217.84,43.4 215.6,45.63 ; v2(238.69,82.74) 238.69,82.69 239.43,81.95 242.82,81.95 245.44,79.34 v2(245.69,79.34) 247.61,79.34 248.29,80.02 254.6,80.02 255.49,79.13 v2(262.36,79.13) ; v2(215.6,45.67) 215.6,45.63 ; 215.6,45.63 214.96,44.98 209.71,44.98 v2(208.28,46.42) ; v2(194.69,47.43) 193.91,47.43 193.4,47.94 127.07,47.94 118.94,56.07 v2(118.94,60.62)
  IN3 w0.508: v2(165.49,161.42) 166.29,160.62 166.29,138.94 166.81,138.42 166.81,129.25 171.33,124.73 v2(171.33,115.47) ; v2(290.97,103.83) 289.5,102.37 283.95,102.37 283.55,101.97 281.11,101.97 280.42,102.65 280.42,103.03 280.07,103.39 279.66,103.39 278.85,104.2 276.74,104.2 274.6,106.35 v2(274.6,107.52) ; v2(66.91,172.52) 66.91,172.55 70.42,176.06 70.42,183.39 71.03,184 v2(71.41,184) ; v2(168.08,171.02) 168.03,171.02 165.82,168.81 164.56,168.81 163.93,168.18 163.93,167.38 164.04,167.26 v4(164.04,167.16) ; v4(150.29,3.57) 146.95,3.57 146.13,2.76 146.12,2.76 145.96,2.59 145.39,2.59 144.37,1.57 130.86,1.57 130.84,1.6 117.08,1.6 113.41,5.27 113.41,11.54 114.51,12.65 114.51,28.23 108.66,34.09 108.66,59 112.59,62.94 112.9,62.94 113.72,63.76 v2(113.72,64.19) ; v2(238.69,82.74) 239.16,83.2 239.16,86.21 v2(239.61,86.66) ; v2(215.69,48.84) 216.16,48.37 227.01,48.37 228.56,49.92 236.85,49.92 238.4,51.47 239.42,51.47 246.38,58.43 246.38,72.22 247.37,73.21 247.37,78.21 246.24,79.34 v2(245.69,79.34)
  IN4 w0.508: v2(106.79,148.73) 106.79,142.53 110.43,138.88 110.43,121.2 109.32,120.08 109.32,96.72 115.13,90.91 115.13,85.98 117.03,84.09 117.03,71.74 115.96,70.68 v2(115.96,67.74) ; v2(152.18,181.33) 152.19,181.33 153.14,180.38 v4(153.14,177.69) ; v2(158.77,174.07) 158.77,171.48 157.72,170.42 157.72,161.89 v2(157.65,161.82) ; v2(96.34,167.85) 95.65,167.16 95.65,163.88 96.02,163.51 98.99,163.51 99.47,163.03 v2(99.47,161.11) ; v2(37.2,173.85) 37.2,174.14 38.08,175.03 46.07,175.03 46.17,174.93 58.52,174.93 59.86,176.28 v2(59.86,176.45)
  BOTTOM w0.203: PU100.3 150.73,4.01 v4(150.29,3.57)
  BOTTOM w0.381: CH11.1 207.8,52.44 207.8,52.95 207.36,53.39 207.36,53.62 UH2.5
  BOTTOM w0.508: v4(117.92,169) 117.92,168.54 PR816.2 ; R909.1 232.05,26.71 231.75,27.01 228.19,27.01 227.41,26.24 216.85,26.24 216.24,25.63 v2(216.24,24.79) ; v2(262.36,79.13) 262.54,79.13 263,79.59 263,80.33 262.64,80.68 261.98,80.68 261.45,81.21 261.45,81.89 260.79,82.55 260.79,90.14 261.09,90.45 261.09,98.49 262.49,99.89 262.49,105.82 v2(265.26,108.58) ; v2(208.28,46.42) 207.63,47.07 206.7,47.07 206.24,46.6 202.91,46.6 202.21,47.31 195.73,47.31 195.6,47.43 v2(194.69,47.43) ; v2(208.38,50.4) 208.38,50.4 207.35,51.44 207.35,51.99 CH11.1 ; v2(90.65,169.37) 90.65,169.38 89.87,170.15 83.72,170.15 82.92,170.95 77.58,170.95 v2(76.82,170.19) 76.18,170.19 74.53,171.84 67.59,171.84 v2(66.91,172.52) ; v4(150.29,3.57) 150.22,3.5 PR103.1 ; v2(158.77,174.07) 158.82,174.12 159.14,173.8 160.28,173.8 161.58,175.09 163.84,175.09 164.19,174.74 164.19,168.55 163.93,168.29 163.93,167.27 v4(164.04,167.16) ; v2(99.47,161.11) 99.47,160.76 100.35,159.88 100.35,159.02 101.58,157.78 v2(101.58,157.49) ; v2(104.75,164.72) 104.75,168.74 v2(105.06,169.06) ; R509.1 218.27,41.24 v2(217.84,40.8) ; v2(138.36,72.38) 138.34,72.35 138.34,71.89 136.04,69.6 117.81,69.6 v2(115.96,67.74) 113.71,65.49 113.71,64.2 v2(113.72,64.19) 113.72,63.87 114.83,62.76 116.66,62.76 118.8,60.62 v2(118.94,60.62)
+3.3V_ALW2_C2:
  vias: v1(163.2,170.24)
+3.3V_ALW_5048: length 81.7
  TOP w0.254: C707.1 267.28,44.6 267,44.88 267,45.92 266.94,45.99 U46.A54
  TOP w0.279: C710.1 260.58,51.09 262.14,51.09 262.43,51.39 U46.A43 ; U46.B30 266.19,56.33 266.52,55.99 266.77,55.99 266.81,55.96 v2(266.86,55.96) ; v2(272.04,59.03) 271.94,58.92 U46.A17 ; U46.B5 272.5,50.64 272.27,50.87 v2(272.02,50.87)
  TOP w0.381: v2(263.9,60.29) 263.99,60.29 C706.1
  TOP w0.508: v2(267.68,45.22) C707.1 ; C710.1 260.51,50.81 260.83,50.49 v2(261.32,50.49) ; v2(272.04,59.03) 272.14,59.13 C705.1 ; C709.1 277.96,51.23 v2(278.85,51.23) ; v2(270.95,60.25) 270.95,60.69 C708.1
  IN1 w0.508: v2(278.85,51.23) 278.94,51.23 279.48,51.78 279.48,53.62 279.47,53.63 279.47,55.55 280.21,56.29 280.21,59.4 279.19,60.41 277.48,60.41 277.41,60.34 v2(277.18,60.34) ; v2(261.32,50.49) 261.16,50.49 259.89,51.76 259.89,53.5 260,53.61 260,54.58 261.5,56.08 262.28,56.08 263.7,57.51 264.69,57.51 265.18,58 ; 265.18,58 265.44,58 266.21,57.23 266.21,56.16 266.44,55.93 266.78,55.93 266.81,55.96 v2(266.86,55.96) ; 265.18,58 264.49,58.7 264.49,59.92 264.12,60.29 v2(263.9,60.29)
  IN2 w0.508: v2(278.85,51.23) 278.62,51.46 276.8,51.46 276.31,50.96 274.06,50.96 273.71,51.32 272.86,51.32 272.4,50.87 v2(272.02,50.87)
  BOTTOM w0.508: v2(267.68,45.22) 267.68,44.84 266.9,44.06 262.97,44.06 261.64,45.39 261.64,47.51 260.71,48.44 260.71,50.08 261.12,50.49 v2(261.32,50.49) ; v2(277.18,60.34) 277.17,60.34 v1(273.92,60.34) 273.35,60.34 v2(272.04,59.03) 270.95,60.12 v2(270.95,60.25) 270.01,61.19 265.45,61.19 264.55,60.29 v2(263.9,60.29)
+3.3V_ALW_PCH: length 368.6
  TOP w0.254: CH2.1 276.92,80.37 276.4,79.84 275.36,79.84 275.31,79.79 274.14,79.79 273.69,80.24 v2(273.66,80.24) ; CH43.1 208.75,70.33 209.7,70.33 v2(209.76,70.39)
  TOP w0.381: v2(215.63,85.43) 215.81,85.61 RH240.1
  TOP w0.457: CH45.1 209.8,71.43 v2(209.88,71.43)
  TOP w0.508: RC12.1 134.86,67.14 133.59,65.87 v2(133.59,64.27) ; v2(216.85,65.32) 216.85,64.6 RH41.1 216.61,62.81 216.42,62.62 216.42,62.12 217.03,61.51 v2(217.03,60.35) ; v2(221.13,59.37) 221.13,59.11 217.43,55.41 217.43,54.52 v2(216.26,53.35) ; v2(232.01,49.03) 232.08,48.96 232.08,47.52 229.72,45.17 v2(225.93,45.17) ; v2(195.47,57.66) 195.47,58 195.9,58.43 RH73.1 RH128.2 ; RC11.1 v2(115.44,114.57)
  TOP w1.016: 308.72,139.84 308.82,139.74 314.59,139.74 314.75,139.9 316.53,139.9 317.99,141.36 317.99,145.55 319.77,147.33 319.77,157.49 321.4,159.12 321.4,163.11 321.04,163.46
  IN1 w0.254: v2(207.79,63.77) 207.79,63.58 207.53,63.32 207.41,63.32 206.96,62.87 206.55,62.87 206.29,62.6 206.29,60.96 207.34,59.91 207.34,57.33 208.17,56.49 208.17,53.23 205.55,50.6 205.55,50.53 v2(204.94,49.92)
  IN1 w0.508: v2(209.88,71.43) 210.77,71.43 v2(210.9,71.56) ; v2(216.26,53.35) 216.33,53.29 v2(216.33,49.61)
  IN2 w0.457: v2(217.03,60.35) 217.38,60.71 219.78,60.71 v2(220.47,60.02) ; v2(115.08,101.21) 115.12,101.17 115.12,97.14 117.48,94.78 117.48,92.91 120.47,89.93 120.47,82.17 121.2,81.43 121.2,68.61 123.95,65.86 132,65.86 v2(133.59,64.27) ; v2(232.01,49.03) 232.01,47.92 231.78,47.69 231.78,46.88 230.23,45.33 228.81,45.33 225.15,48.98 222.14,48.98 220.45,50.67 217.34,50.67 216.33,49.66 v2(216.33,49.61) ; v2(304.4,110.63) 304.4,108.34 302.42,106.36 294.3,106.36 294.11,106.55 292.51,106.55 292.04,107.02 290.43,107.02 289.84,107.62 287.96,107.62 287.46,107.12 287.28,107.12 286.53,106.37 283.87,106.37 283.71,106.54 282.43,106.54 281.51,107.45 280.11,107.45 279.85,107.71 278.52,107.71 278.25,107.44 v2(277.39,107.44)
  IN2 w0.508: 105.65,148.98 105.65,149.49 97.14,158 92.45,158 90.35,160.1 90.35,160.36 90.04,160.67 86.99,160.67 85.07,162.59 85.07,166 82.28,168.8 49.26,168.8 v2(47.61,170.45) ; v2(347.61,189.83) 340.44,189.83 337.4,192.87 335.21,192.87 334.25,191.91 v2(326.12,191.91)
  IN3 w0.254: v2(215.02,85.38) 214.38,85.38 213.98,84.98 213.98,83.98 212.76,82.77 212.76,79.84 212.9,79.7 212.9,79.17 212.63,78.9 212.54,78.9 209.61,75.97 v2(208.78,75.97) ; v2(210.9,71.56) 210.9,72.57 209.71,73.76 209.71,74.76 213.3,78.36 213.3,81.66 v2(213.7,82.05) ; v2(221.13,59.37) 221.04,59.46 218.27,59.46 218,59.19 217.32,59.19 215.01,61.51 214.33,61.51 212.89,62.95 212.89,67.42 210.74,69.57 210.74,70.19 210.54,70.39 v2(209.76,70.39)
  IN3 w0.508: v2(209.44,50.3) 209.93,49.82 213.39,49.82 213.65,50.08 215.86,50.08 v2(216.33,49.61)
  IN4 w0.508: v2(220.47,60.02) 220.48,60.02 v2(221.13,59.37)
  BOTTOM w0.254: v2(273.66,80.24) 274.24,80.83 JXDP2.43 ; v2(220.47,60.02) 220.47,60.78 220.03,61.22 RH35.1 ; UH1.AJ32 208.84,76.03 v2(208.78,75.97) 208.72,75.9 UH1.AJ30 ; 215.33,66.74 215.33,66.7 215.62,66.41 215.76,66.41 v2(216.85,65.32)
  BOTTOM w0.279: v2(273.66,80.24) 272.96,80.94 271.98,80.94 271.86,80.83 JXDP2.44 269.43,80.83 268.99,81.26 268.99,81.32 v2(269.03,81.36)
  BOTTOM w0.508: RH167.1 190.02,60.13 v2(190.02,59.34) ; v2(217.03,60.35) 217.1,60.27 217.1,59.42 RH237.1 ; v2(192.35,58.45) 192.05,58.14 192.05,57.75 RH197.2 ; RH122.2 198.03,59.96 v2(197.53,59.46) ; v2(232.01,49.03) 232.01,49.71 231.78,49.94 R514.1 ; v2(216.33,49.61) 216.33,50.25 R1622.2 ; R513.1 v2(225.93,45.17) 225.84,45.08 225.84,44.45 226.14,44.15 R510.1 ; R1624.2 213.43,47.71 v2(213.43,47.05)
  vias: v2(47.23,170.95) v2(106.15,148.48) v2(106.15,147.84) v2(115.04,101.87) v2(184.51,94.37) v2(184.51,93.79) v2(185.66,65.29) v2(186.15,64.88) v2(188.2,78.24) v2(188.83,78.16) v2(195.19,53.27) v2(196.54,54.16) v2(198.01,53.68) v2(199.37,57.61) v2(225.73,85.74) v2(226.17,85.33) v2(250.78,140.98) v2(250.78,140.4) v2(254.86,116.66) v2(254.87,115.96) v2(254.87,82.56) v2(254.91,81.93) v2(276.46,118.12) v2(276.46,117.49) v2(276.39,106.31) v2(304.78,111.14) v2(308.34,141.24) v2(308.75,141.65) v2(322.18,164.1) v2(322.18,163.46) v2(325.86,209.56) v2(326.12,192.54) v2(326.5,209.56) v2(326.63,180.35) v2(327.26,180.35) v3(208.01,44.44)
+3.3V_ALW_PCH_JTAG: length 165.1
  TOP w0.381: v2(273.63,79.48) 273.05,78.89 271.93,78.89 271.66,78.63 RH52.1
  IN2 w0.508: v2(258.11,72.99) 258.39,72.71 271.11,72.71 272.98,74.58 272.98,78.87 273.59,79.48 v2(273.63,79.48)
  IN3 w0.508: v2(193.39,58.58) 193.35,58.58 192.05,57.28 192.05,55.31 192.24,55.12 192.24,51.37 198.76,44.85 199.5,44.85 202.9,41.45 208.02,41.45 209.03,40.45 211.75,40.45 222.61,29.59 222.61,27.37 228.33,21.65 231.25,21.65 232.37,20.52 244.23,20.52 250.63,26.93 250.63,28.49 252.06,29.92 253.53,29.92 257.93,34.32 257.93,38.89 258.15,39.1 258.15,42.56 255.88,44.83 255.88,46.36 255.27,46.97 255.27,52.45 255.08,52.64 255.08,54.13 254.29,54.92 254.29,57.15 254.16,57.28 254.16,59.95 254.16,64.72 258.77,69.33 258.77,72.33 v2(258.11,72.99)
  BOTTOM w0.127: v1(196.01,59.56) 195.79,59.78 RH48.1
  BOTTOM w0.508: v2(193.39,58.58) 193.96,59.15 RH46.2 194.02,60.28 RH50.1 RH48.1
+3.3V_ALW_VTR: length 90
  TOP w0.254: C777.1 280.6,120.38 280.95,120.04 281.55,120.04 282.48,119.11 282.48,118.04 282.61,117.91 U51.B35 ; U51.A41 281.33,113.66 281.17,113.5 280.26,113.5 C781.1 ; 286.05,121.52 286.59,120.98 286.59,119.79 286.72,119.67 U51.A26 ; U51.B3 291.66,110.91 v2(291.45,110.7) ; C776.1 294.92,115.4 294.68,115.16 U51.A11 ; U51.A52 285.22,108.07 285.09,107.94 285.09,107.36 284.02,106.29
  TOP w0.508: v2(284.22,107.21) 284.02,107.01 C780.1 ; v2(285.95,120.87) 286.05,120.97 C759.1 ; v2(279.95,112.62) 280.06,112.72 C781.1 ; v2(294.3,110.46) 294.36,110.46 294.78,110.88 C774.1 ; C776.1 294.33,115.84 v2(294.28,115.78) ; C777.1 279.8,120.61 C782.1 278.67,120.98 278.37,121.28 278.13,121.28 v2(278.13,121.29)
  IN3 w0.508: v2(279.95,112.62) 279.95,115.67 279.14,116.48 279.14,120.27 v2(278.13,121.29) ; v2(284.22,107.21) 284.18,107.18 283.65,107.18 283.36,107.46 283.36,108.18 284.06,108.88 290.25,108.88 290.76,109.4 293.27,109.4 293.46,109.21 294.01,109.21 294.45,109.64 294.45,110.32 v2(294.3,110.46)
  IN4 w0.508: v2(294.3,110.46) 294.36,110.46 294.93,111.04 294.93,114.83 294.28,115.49 v2(294.28,115.78)
  BOTTOM w0.508: v2(285.95,120.87) 286.11,120.87 287.04,121.79 291.87,121.79 292.74,120.92 292.74,117.94 294.28,116.41 v2(294.28,115.78) ; v2(294.65,100.83) 294.65,104.61 295.73,105.69 297.66,105.69 298.23,106.26 298.23,107.38 297.09,108.52 296.25,108.52 v2(294.3,110.46) ; v2(284.22,107.21) 284.06,107.05 283.62,107.05 283.04,106.46 282.47,106.46 281.99,106.94 281.99,108.05 282.1,108.16 282.1,112.71 281.55,113.26 280.5,113.26 279.95,112.71 v2(279.95,112.62)
  vias: v1(295.64,100.47)
+3.3V_CARD:
  vias: v2(267.58,37.03) v2(267.58,36.39) v2(268.88,35.83) v2(270.51,34.44) v2(270.51,33.85) v2(270.52,33.25) v2(282.11,34.58) v2(282.14,33.38) v2(282.24,34.01) v3(283.07,33.46)
+3.3V_CARDAUX: length 22.5
  TOP w0.102: v2(282.22,36.28) v3(282.22,35.59)
  TOP w0.254: C646.1 281.24,31.89 282.56,31.89 283.39,31.06 JEXP1.16
  TOP w0.279: U41.15 275.99,36.95 C642.1
  TOP w0.508: C642.1 276.27,37.24 C643.1 276.88,39.1 v2(276.88,39.2) ; v2(282.06,32.4) C646.1
  IN1 w0.508: v2(282.06,32.4) 283.15,33.49 283.15,35.34 v2(282.22,36.28)
  IN3 w0.508: v2(282.22,36.28) 282.22,36.64 281.39,37.46 281.39,37.74 279.93,39.2 v2(276.88,39.2)
+3.3V_LAN: length 430.5
  TOP w0.254: v2(297.16,202.83) 297.17,202.82 U32.39 ; v2(297.81,199.53) 298.31,199.53 298.62,199.85 U32.1 ; v2(300.34,199.28) 300.12,199.49 U32.4 ; v2(307.36,203.71) 307.39,203.73 307.39,203.11 U32.21 ; U32.14 v2(305.12,199.32) ; U32.30 v2(302.62,204.74) ; U32.8 v2(302.12,199.28)
  TOP w0.508: RH175.1 194.81,57.33 194.41,57.67 RH174.1 194.35,57.8 194.02,57.8 v2(193.76,58.06) ; v2(317.37,206.67) 316.4,207.63 v2(313.66,207.63) ; v2(257.88,170.78) 259.01,170.78 259.93,171.69 259.93,175.59 260.51,176.17 264.22,176.17 264.97,175.42 264.97,170.78 265.85,169.9 268.5,169.9 269.78,171.18 269.78,173.09 270.34,173.65 270.34,176.99 270.53,177.18 270.53,183.25 v2(270.32,183.46)
  IN1 w0.508: v2(302.62,204.74) 302.6,204.74 302.04,204.18 298.51,204.18 v2(297.16,202.83) ; v2(315.2,218.9) 315.2,220.71 313.89,222.02 313.89,225.49 312.12,227.26 JLOM1.12
  IN2 w0.508: v2(305.12,199.32) 305.35,199.32 307.36,201.33 v2(307.36,203.71) 307.6,203.95 308.87,203.95 310.42,205.5 310.57,205.5 311.09,206.02 312.01,206.02 313.62,207.63 v2(313.66,207.63) ; v2(270.32,183.46) 270.32,183.32 270.7,182.94 274.16,182.94 274.91,182.19 277.4,182.19 278.24,183.03 289.5,183.03 v2(289.8,183.32)
  IN3 w0.508: JLOM1.9 297.36,225.95 295.51,225.95 294.75,225.18 294.75,214.13 295.51,213.37 v2(295.51,213.03) ; v2(289.8,183.32) 290.41,183.93 301.82,183.93 303.22,185.33 303.22,192.76 302.41,193.57 302.41,199 v2(302.12,199.28) ; v2(297.81,199.53) 298.19,199.91 299.7,199.91 v2(300.34,199.28) 302.12,199.28 v2(302.12,199.28) ; v2(302.12,199.28) 305.09,199.28 v2(305.12,199.32) ; v2(257.88,170.78) 258.43,170.22 258.43,166.4 259.43,165.4 259.43,144.79 260.9,143.31 260.9,141.36 262.11,140.16 262.11,129.35 262.34,129.12 262.34,125.07 262.34,120.61 261.12,119.39 261.12,112.69 261.35,112.46 261.35,111.95 261.31,111.91 261.31,111.14 260.75,110.57 260.75,108.58 261.34,107.99 261.34,101.84 257.23,97.74 257.23,81.32 257.64,80.91 257.64,79.93 257.23,79.53 257.23,72.44 258.1,71.57 258.1,69.66 253.26,64.82 253.26,62.96 253.5,62.71 253.5,57.03 253.58,56.96 253.58,53.35 254.44,52.48 254.44,52.38 254.59,52.22 254.59,48.2 254.39,47.99 254.39,44.45 255.13,43.71 255.76,43.71 257.51,41.96 257.51,39.51 257.06,39.05 257.06,35.47 255.57,33.98 255.57,32.93 253.2,30.56 251.8,30.56 250,28.75 250,27.19 243.96,21.16 232.64,21.16 231.51,22.29 228.6,22.29 223.25,27.64 223.25,29.94 211.1,42.09 203.16,42.09 199.76,45.48 199.02,45.48 192.87,51.63 192.87,55.39 192.68,55.57 192.68,56.99 v2(193.76,58.06)
  IN4 w0.508: v2(295.51,213.03) 295.77,212.78 295.77,204.23 v2(297.16,202.83) 297.81,202.18 v2(297.81,199.53) ; v2(315.2,218.9) 314.71,218.41 314.71,208.37 313.98,207.63 v2(313.66,207.63)
  BOTTOM w0.356: C478.1 312.42,207.85 U15.5
  BOTTOM w0.508: v2(307.36,203.71) 307.17,203.52 307.17,202.86 C473.1 ; R558.1 321.62,191.99 v2(321.67,192.04) R553.1 ; v2(313.66,207.63) 313.65,207.64 313.32,207.64 313,207.96 C478.1 ; R545.1 R546.1 317.65,205.36 317.65,205.82 317.37,206.1 v2(317.37,206.67) ; v2(302.12,199.28) 302.12,199.29 C474.1 ; C482.1 314.8,218.01 C481.1 315.45,218.64 v2(315.2,218.9) ; C1167.1 v2(295.51,213.03) ; C472.1 v2(297.16,202.83) ; R549.1 v2(319.64,192.11) ; R556.1 v2(316.59,192.04)
  vias: v2(300.34,198.62) v2(307.13,190.77) v2(307.73,190.74) v3(312.53,192.44)
+3.3V_LAN_OUT: length 17.2
  IN2 w0.508: 312.97,197.52 312.66,197.84 312.66,198.37 313.29,199.01 v2(313.29,199.02) ; 312.97,197.52 v2(313.27,197.52) ; 312.97,197.52 312.58,197.13 312.58,196.32 313.57,195.33 315.87,195.33 v2(316.09,195.11)
  IN3 w0.508: v2(314.51,203.8) 314.51,202.78 312.68,200.95 312.68,199.63 v2(313.29,199.02)
  BOTTOM w0.203: v2(314.51,203.8) 314.72,203.58 U31.29
  BOTTOM w0.254: U31.15 312.99,197.62 313.09,197.52 v2(313.27,197.52) ; U31.19 313.09,199.22 v2(313.29,199.02)
  vias: v1(315.58,194.45) v2(316.09,194.5)
+3.3V_M: length 341.4
  TOP w0.254: v2(204,69.74) 203.95,69.78 203.38,69.78 201.8,68.2 201.8,67.76 202.37,67.19 CH59.1
  TOP w0.457: 282.85,126.12 284.29,127.56 v2(284.32,127.56)
  TOP w0.508: v2(189.29,55.66) 189.48,55.47 v3(189.48,48.45) 189.48,41.57 v2(188.77,40.86) ; 282.85,126.12 282.35,125.63 R837.1
  IN2 w0.254: v2(189.29,55.66) 190.34,56.72 190.34,57.92 190.89,58.47 190.89,58.56 192.45,60.12 193.78,60.12 194,60.34 195.05,60.34 196.27,61.56 196.27,62.59 200.58,66.89 201.16,66.89 201.8,67.53 201.8,68.2 203.38,69.78 203.95,69.78 v2(204,69.74)
  IN2 w0.762: 282.99,127.69 282.38,127.69 282.05,128.02 276.16,128.02 274.43,126.29
  IN3 w0.762: 262.66,116.95 262.66,111.37 261.51,110.22 261.51,108.95 262.1,108.36 262.1,100.96 260.74,99.6 260.74,99.13 260.74,95.16 258.05,92.47 258.05,81.6 258.4,81.24 258.4,79.11 259.53,77.98 259.53,69.02 254.92,64.41 254.92,60.26 254.92,58.94 255.05,58.81 255.05,55.23 255.84,54.44 255.84,52.95 256.03,52.76 256.03,47.29 256.8,46.51 256.8,44.98 259,42.79 259,39.7 259.6,39.1 259.6,35.46 259.01,34.87 259.01,34.32 252,27.31 252,26.07 251.31,25.37 250.43,25.37 244.68,19.63 231.35,19.63 230.37,20.62 228.27,20.62 221.85,27.04 221.85,29.27 211.44,39.69 208.71,39.69 208,40.4 200.73,40.4 199.67,41.47 ; 284.72,128.59 284.72,128.98 286.44,130.71 291.32,130.71 291.99,131.38 291.99,133.24 293.81,135.05 302.83,135.05 308.11,140.33 311.88,140.33 318.71,147.17 318.71,153.36 319.62,154.26 319.62,160.57 318.6,161.59 318.6,166.09 317.79,166.9 317.79,168.16 318.23,168.6 318.23,171.89 316.83,173.29 314.63,173.29 313.61,174.31 313.58,174.31 313.36,174.54 313.36,175.65 316.14,178.43 316.14,182.12 317,182.98 317,184.95 315.87,186.08 315.87,188.62 316.06,188.81 316.06,189.44 314.75,190.75 314.75,193.14 312.31,195.58 310.04,195.58 309.04,196.57 305.39,196.57
  BOTTOM w0.254: UH1.AD12 204.28,69.57 204.12,69.74 v2(204,69.74)
  BOTTOM w0.305: RH185.1 201.75,41.78 202.18,41.35 JSPI1.16
  BOTTOM w0.508: v2(188.77,40.86) 189.06,40.56 196.97,40.56 197.89,41.48 198.05,41.48 198.9,42.33 v2(199.07,42.33)
  vias: v2(199.77,42.47) v2(262.57,118.52) v2(262.59,117.89) v2(273.53,126.61) v2(273.52,126.02) v2(284.91,127.83) v2(304.53,196.9)
+3.3V_OZ_IO_LDO: length 3.8
  TOP w0.203: C800.2 247.71,40.8 248.1,41.2 248.97,41.2 249.12,41.35 U38.25
  TOP w0.254: C800.2 247.51,40.07 C566.2
+3.3V_PCIE_FLASH: length 32.3
  TOP w0.102: v2(294.5,178.06) v3(293.14,178.06)
  TOP w0.508: v2(294.5,178.06) 294.74,177.82 294.74,177.14 C625.2 ; C621.1 313.8,183.51 v2(313.41,183.12) ; v2(318.63,177.36) 318.39,177.13 C623.1 ; C626.1 312.53,183.32 v2(312.75,183.11)
  BOTTOM w1.016: 306.26,174.28 305.29,174.28 304.96,173.95 294.31,173.95 293.39,174.87 293.39,176.26 293.37,176.29 ; 318.6,174.94 317.94,174.28 307.34,174.28
  vias: v2(306.28,175.2) v2(306.92,175.2)
+3.3V_PCIE_WWAN: length 91.5
  TOP w0.254: R563.1 326.2,131.72 U7.10
  TOP w0.508: R564.1 v2(320.11,132.92) ; R563.1 C412.1 C400.1 326.4,133.92 325.48,133.92 v2(324.47,132.91) ; R550.1 v2(328.05,129.92) ; R560.1 v2(322.66,136.51) ; v2(338.56,201.43) 338.95,201.82 C614.1 ; R554.1 v2(328.05,128.05) ; R565.1 R567.1 317.79,130.02 v2(317.19,130.62)
  IN4 w0.508: v2(343.46,207.49) 343.46,203.92 337.87,198.32 337.87,195.24 339.24,193.87 339.24,185.58 338.12,184.47 338.12,167.73 335.09,164.69 335.09,160.01 332.9,157.82 332.9,155.94 326.63,149.67 326.63,148.96 322.7,145.03 322.7,138.99
  BOTTOM w0.508: C610.1 v2(350.38,200.16)
  vias: v2(320.38,128.97) v2(320.39,128.36) v2(329.57,206.5) v2(330.18,206.26) v2(330.82,206.26) v2(334.12,206.26) v2(334.75,206.26) v2(335.34,206.26) v2(344.1,207.49) v2(345.3,207.53) v3(332.52,207.35)
+3.3V_RP1: length 16.7
  IN3 w0.508: v2(343.77,216.29) 343.77,217.82 v2(344.41,218.45)
  BOTTOM w0.254: C1537.1 334.83,221.5 336.02,221.5 336.28,221.75 337.04,221.75 337.31,221.48 U92.13
  BOTTOM w0.508: v2(337.29,224.92) R3725.1 R3724.1 ; v2(337.55,214.01) R3705.1 R3706.1 ; R3723.1 R3726.1 v2(341.36,224.97) ; R3707.1 v2(334.5,214.01) ; R3709.1 v2(332.39,223.66) ; R3703.1 344.03,218.07 v2(344.41,218.45) ; R3708.1 333.23,217.06 v2(332.6,216.42) ; R3704.1 v2(341.61,214.01) ; v2(335.14,222.14) C1537.1
  vias: v1(329.95,209.05) v2(343.14,216.29)
+3.3V_RP2: length 14.9
  TOP w0.102: v2(335.54,187.78) 335.22,188.1 v1(335.01,188.1)
  BOTTOM w0.254: C1522.1 332.21,193.87 332.21,191.48 331.86,191.13 U90.13 ; v2(326.2,188.05) 326.77,188.63 U90.1
  BOTTOM w0.508: R3694.1 R3692.1 335.22,188.1 v2(335.54,187.78) ; v2(335.52,192.16) R3693.1 R3679.1 ; R3677.1 v2(323.07,193.18) ; R3675.1 v2(323.07,190.13) ; v2(332.93,193.99) C1522.1 ; R3678.1 v2(325.99,195.59) ; v2(335.52,185.05) R3695.1 ; v2(325.74,184.85) R3673.1
  vias: v2(323.2,186.58) v2(325.74,184.16)
+3.3V_RP3: length 13.6
  IN1 w0.508: v2(335.5,191.1) 335.87,190.73 335.87,189.86 v2(335.44,189.43)
  BOTTOM w0.254: v2(344.47,192.54) 344.07,192.14 U95.13 ; U95.1 v2(338.54,189.64)
  BOTTOM w0.508: R3772.1 R3767.1 v2(335.5,191.1) ; R3758.1 335.49,189.32 335.44,189.37 v2(335.44,189.43) ; R3769.1 339.33,186.18 v2(338.62,186.18) ; v2(335.1,196.16) 335.92,196.16 336.16,195.92 R3777.1 ; v2(347.61,188.61) R3780.1 R3774.1 ; v2(347.61,193.17) 347.23,193.55 347.06,193.55 346.92,193.69 R3771.1 ; R3762.1 v2(347.61,191.66) ; R3778.1 v2(339.34,196.51) ; R3768.1 v2(347.61,184.54)
  vias: v1(344.27,198.58)
+3.3V_RP4: length 13.5
  TOP w0.102: v2(33.89,190.64) v1(33.13,190.64)
  BOTTOM w0.254: C1542.1 33.36,187.41 33.75,187.41 34.17,187 U94.13
  BOTTOM w0.508: R3739.1 R3752.1 v2(38.97,190.64) ; v2(38.21,178.1) R3735.1 ; R3744.1 v2(29.38,182) ; R3747.1 v2(42.02,190.64) ; v2(31.1,178.09) R3738.1 ; v2(34.15,177.94) R3750.1 R3737.1 ; R3733.1 R3746.1 v2(33.89,190.64) ; C1542.1 31.15,188.91 v2(31.1,188.86)
  vias: v2(40.88,181.24) v2(41.51,181.24) v2(41.51,180.61)
+3.3V_RTC_LDO: length 344
  TOP w0.102: v4(150.22,1.28) v1(150.22,2.17)
  IN2 w0.508: v2(251.98,5.12) 252.34,4.75 252.34,2.31 251.32,1.28 224.52,1.28 v2(224.4,1.4) ; v2(200.58,2.81) 199.18,1.41 187.38,1.41 185.81,2.98 185.81,4.44 184.89,5.36 176.61,5.36 175.51,4.25 175.51,1.73 175.08,1.3 154.28,1.3 153.47,2.11 150.81,2.11 150.22,1.52 v4(150.22,1.28)
  IN3 w0.508: v2(251.98,5.12) 261.64,5.12 271.48,14.96 278.09,14.96 280.49,17.36 280.49,17.88 286.11,23.51 287.99,23.51 289.14,24.65 289.14,36.74 288.02,37.86 286.67,37.86 283.83,40.7 283.83,43.03 289.71,48.91 289.71,58.43 286.33,61.81 285.74,61.81 279.7,67.85 279.7,93.6 282.87,96.77 286.11,96.77 287.62,98.29 288.25,98.29 290.15,100.18 303.46,100.18 314.69,111.4 314.69,115.25 319.69,120.26 324.7,120.26 327.11,122.67 327.11,136.85 328.33,138.07 328.33,154.36 329.41,155.44 v2(329.56,155.44)
  IN4 w0.508: v2(200.58,2.81) 200.58,3.12 204.43,6.97 212.17,6.97 213.42,5.73 222.53,5.73 223.77,4.49 223.77,2.11 224.44,1.43 v2(224.4,1.4)
  BOTTOM w0.508: PR103.2 v4(150.22,1.28) ; v2(329.56,155.44) 328.99,156.01 326.06,156.01 PD3.3
+3.3V_RUN: length 770.9
  TOP w0.203: C26.1 179.24,171.98 180.54,171.98 180.87,172.31 U6.32 ; U19.37 26.87,198.55 26.65,198.33 26.65,197.32 C31.1 ; C1503.2 247.73,49.72 248.67,48.78 249.04,48.78 249.13,48.69 249.15,48.69 249.47,48.37 249.47,48.35 249.52,48.31 U38.11 ; C25.1 183.29,169.71 183.29,170.93 183.46,171.09 U6.4 ; U6.23 183.86,176.61 C28.1 ; U38.13 247.85,47.04 247.4,47.49 246.34,47.49 C1501.2 ; C27.1 179.61,173.62 180.04,174.05 180.26,174.05 180.8,173.51 U6.29
  TOP w0.305: C51.1 266.29,85.57 JUSH1.8
  TOP w0.381: v2(213.57,63.05) 213.11,63.5 213.11,63.57 213.1,63.58 ; UH3.5 187.96,66.45 187.96,67.06 188.36,67.46 CH12.1
  TOP w0.508: v2(212.53,72.22) 212.38,72.08 211.81,72.08 CH27.1 ; RH256.1 RH255.1 219.39,81.18 v2(220.63,82.42) ; v2(214.67,54.69) 214.16,55.2 ; 214.16,55.2 213.55,54.59 RH203.2 RH202.2 ; 214.16,55.2 RH328.1 ; C1501.2 245.73,48.15 246.08,48.5 246.08,48.76 v2(246.09,48.76) ; v2(213.57,63.05) 213.81,62.81 213.81,62.19 213.14,61.52 212.75,61.52 211.75,62.52 RH208.2 RH207.2 ; C1504.2 244.18,49.48 243.95,49.71 v2(243.95,50.05) ; QV5.2 180.53,107.39 179.94,107.98 179.94,110.97 177.39,113.53 176.81,113.53 174.85,115.48 174.85,121.68 177.87,124.7 180.01,124.7 180.67,125.36 180.67,126.47 v2(180.68,126.48) ; R799.1 285.21,126.96 285.31,127.06 v2(285.31,127.23) ; v2(211.77,69.69) 211.53,69.45 211.53,68.98 CH48.1 ; v2(334.48,182.82) 334.68,182.82 336.66,180.84 R1099.1 ; R822.1 R829.1 285.58,98.51 286.52,98.51 R1197.1 286.77,98.68 287.73,97.73 288.64,97.73 v2(289.1,97.27) ; v2(346.13,179.36) 347.99,177.51 v2(349.14,177.51) ; R737.2 268.59,191 269.38,191.78 273.79,191.78 274.38,191.2 277.22,191.2 278.75,189.67 282.63,189.67 284.62,191.66 v2(296.93,191.66) ; PR679.1 200.66,89.6 200.9,89.84 v4(200.9,89.8) ; CD43.1 CD44.1 183.78,26.1 184.3,25.57 184.3,25.25 v2(184.95,24.6) 185.03,24.67 RD12.2 ; R86.1 25.76,207.96 25.42,208.31 v2(24.75,208.31) R80.1 ; v2(114.16,125.29) 114.99,126.12 130.54,126.12 131.43,125.23 RC52.1 ; v2(25.51,194.89) R85.1 ; v2(215.34,56.12) 215.09,56.37 215.09,57.09 RH257.1 ; v2(187.05,41.44) 187.56,41.95 CD21.1 CD22.1 ; C29.1 C28.1 183.21,176.72 v2(183.02,176.91) ; PR691.2 PR627.1 316.29,166.16 315.44,167.01 v4(315.44,167.77) ; R61.1 185.16,168.45 185.16,167.84 v2(185.11,167.79) ; v2(26.78,208.29) R79.1 ; R1118.1 299.6,111.51 299.6,111.06 v2(299.64,111.02) 299.64,110.68 299.39,110.43 R1169.1 v2(300.13,108.93) ; R73.1 16.94,206.39 17.57,205.75 v3(17.57,204.76) v2(17.57,203.57) ; RH168.1 RH193.1 190.83,67.05 190.54,66.76 v2(190.22,66.76) ; R1700.1 244.67,45.19 244.1,45.19 v2(244.08,45.16) ; C1503.2 247.51,49.24 v2(247.14,48.87) ; C1502.2 247.25,51.88 246.73,52.4 v2(246.73,52.44) ; v2(256.07,171.87) 256.47,171.46 258.8,171.46 259.27,171.93 259.27,175.83 260.25,176.81 264.51,176.81 266.73,174.59 267.62,174.59 268.55,173.66 269.02,173.66 269.38,174.02 269.38,174.73 269.02,175.09 v2(268.87,175.09) ; v2(281.24,136.99) PR685.1 ; C27.1 179.13,174.05 v2(180.22,175.15) ; v2(267.9,62.6) 267.9,62.31 267.57,61.98 R780.1 267.64,61.75 R777.1 ; CH12.1 188.91,68 v2(188.91,68.02) RH199.1 RH198.2 188.18,69.77 RH34.1 ; v2(27.54,197.14) C31.1 ; RH90.1 191.07,63.23 v2(191.3,63.45) ; R516.1 116.29,45.61 116.7,46.01 116.7,47.13 v2(116.89,47.32) ; v2(267.71,40.06) 267.71,40.08 267.68,40.11 R772.1 ; C25.1 183.12,169.51 182.52,168.91 v2(182.52,167.92) ; v2(244.12,47.41) 244.39,47.13 R894.1 ; R72.1 21.32,203.82 v2(21,204.14) ; RH245.1 225.18,60.73 225.18,61.26 224.08,62.36 223.62,62.36 v2(223.38,62.12) 222.31,62.12 221.74,62.69 221.55,62.69 218.11,66.13 216.31,66.13 ; CH49.1 203.41,70.56 v2(203.41,70.41) ; v2(275.42,62.92) 275.9,63.4 278.29,63.4 280.22,61.47 280.22,56.91 279.33,56.02 R782.1 ; C26.1 179.03,171.24 v2(179.07,171.2) ; v2(27.8,208.28) R65.1 ; PR400.1 236.33,108.7 235.99,109.04 v4(234.64,109.04) ; v2(194.12,62.76) 194.6,63.23 RH225.2 194.54,63.41 194.54,64.31 RH125.1 ; v2(264.53,94.18) 264.52,94.18 264.52,94.18 R1161.1 ; v2(265.48,84.72) 265.91,84.72 266.3,85.12 C51.1 ; RH205.2 189.04,62.2 v2(188.57,62.67) 188.03,63.21 RH204.2 ; CH65.1 208.49,76.59 v2(208.32,76.42) ; v2(189.53,67.39) RH194.1
  IN1 w0.254: v2(213.9,71.75) 213.9,72.54 216.15,74.79 216.15,74.96 216.43,75.23 216.43,75.82 216.25,76 216.25,77.54 219.87,81.17 219.87,81.66 v2(220.63,82.42)
  IN1 w0.508: v2(344.19,166.13) 345.05,166.13 345.4,166.47 345.4,168 344.94,168.45 344.94,174.29 v2(345.39,174.75) 345.74,175.09 345.74,178.97 v2(346.13,179.36) ; v2(208.02,47.89) 208.15,48.02 208.15,49.68 207.66,50.17 207.66,50.68 209.6,52.61 210.03,52.61 210.28,52.36 211.34,52.36 213.68,54.69 v2(214.67,54.69) 214.67,55.62 215.16,56.12 v2(215.34,56.12) ; v2(213.57,63.05) 213.55,63.05 213.39,63.21 213.38,63.21 213.04,63.56 213.04,63.57 212.96,63.64 212.96,65.47 213.52,66.03 213.52,67.11 211.56,69.06 211.56,69.48 v2(211.77,69.69) ; v2(179.07,171.2) 179.05,171.19 179.05,171.01 182.14,167.92 v2(182.52,167.92) ; v2(197.37,176.72) 197.8,176.29 197.8,172.48 197.09,171.77 v2(197.09,171.75) ; v2(21,204.14) 21,204.06 20.51,203.57 v2(17.57,203.57)
  IN2 w0.254: v2(185.78,63) 185.58,62.8 185.58,62.32 185.91,61.99 186.94,61.99 187.95,63 188.32,63
  IN2 w0.508: 254.11,126.89 253.73,127.27 253.73,129.17 254.19,129.63 255.84,129.63 256.23,130.02 260.36,130.02 263.93,133.59 266.59,133.59 266.84,133.83 268.49,133.83 271.95,137.3 274.67,137.3 274.69,137.29 278.14,137.29 278.43,136.99 v2(281.24,136.99) ; v2(215.34,56.12) 215.58,56.35 215.58,56.96 v2(216.1,57.48) ; v2(127.52,100.06) 127.38,100.2 126.55,100.2 123.24,103.52 121.17,103.52 120.26,104.43 120.26,106.13 118.68,107.71 118.68,118.64 114.39,122.92 114.39,125.05 v2(114.16,125.29) 113.27,126.17 113.27,135.57 109.71,139.13 109.71,146.02 111.77,148.08 111.77,152.7 111.44,153.03 v4(111.1,153.03) ; v2(220.63,82.42) 221.08,81.97 221.08,78.59 222.55,77.12 v2(224.05,77.12) ; v2(251.95,53.71) 249.68,53.71 249.14,53.17 247.47,53.17 v2(246.73,52.44) ; v2(275.42,62.92) 275.43,62.93 275.43,63.5 274.48,64.45 273.29,64.45 272.72,63.88 271.64,63.88 271.23,63.47 268.78,63.47 v2(267.9,62.6) ; v2(246.44,42.47) 247.02,41.88 253.12,41.88 254.26,43.03 254.26,43.6 255.23,44.56 v2(255.33,44.56) ; v2(296.5,122.33) 295.69,122.33 295.69,122.36 291.73,126.33 290.18,126.33 289.28,127.23 v2(285.31,127.23) ; v2(333.56,169.41) 334.7,170.55 334.7,172.72 336.73,174.75 v2(345.39,174.75)
  IN3 w0.254: v2(212.53,72.22) 212.53,73.91 214.36,75.74 214.68,75.74 215.39,76.45 215.39,80.2 217.24,82.06 v2(217.24,82.22) ; v2(203.41,70.41) 203.38,70.44 203.38,72.1 202.47,73.01 201.35,73.01 199.15,75.22 199.06,75.31 198.9,75.31 193.89,80.33 193.89,81.72 193.16,82.45 v2(192.55,82.45) ; v2(205.39,87.88) 205.39,87.86 205.23,87.69 205.23,82.54 207.18,80.58 207.18,80.48 208.33,79.34 208.33,78.92 207.96,78.55 207.96,76.79 v2(208.32,76.42)
  IN3 w0.508: v2(187.05,41.44) 187.63,40.87 187.63,39.32 189.11,37.83 189.11,29.5 189.21,29.4 189.21,26.1 187.71,24.6 v2(184.95,24.6) ; v2(247.14,48.87) 246.53,49.48 246.53,52.23 v2(246.73,52.44) ; v2(289.1,97.27) 289.1,97.41 290.55,98.86 304.72,98.86 311.49,105.63 312.39,105.63 v2(312.47,105.7) ; v2(217.74,59.75) 220.29,62.29 223.2,62.29 v2(223.38,62.12) ; v2(324.67,176.96) 324.65,176.94 324.65,169.05 324.26,168.67 v2(324.26,168.54)
  IN4 w0.381: v2(180.22,175.15) 179.31,174.23 179.31,171.44 v2(179.07,171.2)
  IN4 w0.508: v2(314.47,158.51) 315.44,159.47 v4(315.44,167.77) 315.74,168.07 320.95,168.07 321.03,168 321.66,168 322.22,168.55 322.22,168.95 322.62,169.34 323.59,169.34 324.26,168.67 v2(324.26,168.54) ; v2(299.64,111.02) 299.64,111.54 301.56,113.46 301.56,117.27 v2(296.5,122.33) ; v2(281.24,136.99) 281.24,135.66 282.52,134.38 284.13,134.38 285.72,132.79 285.72,127.77 285.31,127.37 v2(285.31,127.23)
  BOTTOM w0.254: UH1.R30 212.47,72.17 v2(212.53,72.22) 212.53,72.69 UH1.R32 ; UH1.L24 211.63,69.54 v2(211.77,69.69) ; 207.8,76.37 208.27,76.37 v2(208.32,76.42) 208.38,76.48 UH1.AK32 ; v2(213.9,71.75) 213.9,71.73 213.78,71.61 213.32,71.61 UH1.M31
  BOTTOM w0.356: JDIMM2.199 184.7,25.15 184.95,24.9 v2(184.95,24.6) ; QH4.2 v2(188.57,62.67) QH4.5 ; JDIMM1.199 184.7,40.64 184.85,40.79 184.85,41.68 185.1,41.93 186.09,41.93 186.61,41.41 187.03,41.41 v2(187.05,41.44)
  BOTTOM w0.381: v2(208.02,47.89) 207.83,47.7 206.44,47.7 205.91,47.17 203.27,47.17 202.55,47.89 196.04,47.89 195.74,48.2 v2(194.01,48.2)
  BOTTOM w0.508: R501.1 122.08,10.1 122.47,10.49 122.47,13.08 v2(121.69,13.87) ; R502.1 120.05,14.82 120.28,15.05 v2(120.28,15.34) ; v2(224.05,77.12) RH88.1 RH89.1 ; v2(118.98,5.82) R503.1 ; R508.1 120,6.32 119.68,6.01 119.68,5.85 v2(119.67,5.84) ; v2(314.47,158.51) 314.51,158.47 PR692.1 ; v2(349.14,177.51) 349.64,178 R1100.1 ; v4(315.44,167.77) 315.13,167.77 314.7,168.2 314.7,168.21 314.17,168.74 PR620.1 ; v2(254.78,126.89) 254.59,127.08 254.54,127.08 254.19,127.43 254.19,128.33 247.82,134.7 247.46,134.7 247.39,134.76 RV33.1 ; v2(264.53,94.18) 264.52,94.18 264.52,94.18 264.4,94.06 264.4,85.18 264.85,84.72 v2(265.48,84.72) 266.17,84.02 266.17,64.33 v2(267.9,62.6) ; v2(269.34,37.11) 269.34,37.11 269.34,38.25 268.61,38.98 268.61,39.16 v2(267.71,40.06) ; v2(214.67,54.69) 214.31,55.05 212.87,55.05 RH254.2 ; R159.1 R160.1 179.15,165.8 178.85,166.1 178.14,166.1 v2(178.06,166.03) ; RH199.1 v2(188.91,68.02) 188.91,68 CH12.1 ; v2(268.87,175.09) 268.84,175.12 R739.2 ; v2(191.44,65.48) 191.49,65.48 191.65,65.65 192.01,65.65 RH224.1 ; v2(194.82,62.08) RH133.1 ; PR519.2 112.31,153.03 v4(111.1,153.03) ; RH200.1 194.67,63.29 194.66,63.29 v2(194.12,62.76) ; v2(300.13,108.93) 307.53,108.93 310.75,105.7 v2(312.47,105.7) ; v2(197.37,176.72) 197.37,177.42 197.15,177.63 R1530.1 R1539.1 ; v2(194.01,48.2) 190.88,48.2 189.28,49.8 185.34,49.8 184.96,49.42 184.96,43.83 185.77,43.01 186.47,43.01 187.05,42.43 v2(187.05,41.44) ; v2(117.33,87.9) 117.66,88.23 R38.1 R30.1 ; v2(190.22,66.76) 190.47,67.01 190.87,67.01 RH193.1 ; R1081.1 R1082.1 344.28,166.04 v2(344.19,166.13)
  vias: v2(30.15,206.06) v2(46.08,182.64) v2(46.08,182) v2(116.45,19.18) v2(116.45,18.58) v2(116.89,48.72) v2(116.89,47.95) v2(117.06,18.57) v2(176.87,166) v2(177.45,166) v2(177.66,167.35) v2(181.05,126.97) v2(181.34,175.79) v2(181.38,126.44) v2(190,164.08) v2(190.65,164.09) v2(191.19,60.32) v2(191.28,164.11) v2(204.67,70.9) v2(254.78,126.14) v2(254.8,125.49) v2(255.41,126.83) v2(255.43,126.23) v2(255.79,56.31) v2(255.93,55.73) v2(264.27,34.25) v2(264.27,33.67) v2(264.9,34.43) v2(269.03,36.55) v2(269.13,127.75) v2(269.11,127.08) v2(269.11,126.45) v2(269.22,34.07) v2(269.24,33.46) v2(269.25,32.84) v2(269.65,127.43) v2(269.67,126.81) v2(269.63,36.54) v2(322.08,204.43) v2(322.11,203.85) v2(322.66,204.46) v2(322.72,203.87) v2(323.25,204.46) v2(323.3,203.87) v2(323.55,203.29) v2(324.82,211.52) v2(324.82,210.93) v2(324.82,210.32) v2(324.82,209.74) v2(324.82,209.16) v2(325.33,211.82) v2(325.36,211.19) v2(326.5,212.61) v2(327.13,212.86) v2(332.99,169.77) v2(332.99,169.16) v2(333.33,168.62) v2(333.66,182.23) v2(333.75,182.83) v2(334.3,182.22) v2(335.07,195.52) v2(335.1,194.91)
+3.3V_RUN_CARD:
  vias: v1(247.18,43.4) v2(245.19,31.66) v2(245.55,44.12) v2(245.6,31.25) v2(246.16,44.12) v2(258.57,31.47) v2(259.16,31.48)
+3.3V_RUN_DVDD: length 2.1
  TOP w0.254: U74.3 336.89,173.09 v2(336.79,172.99) ; U74.9 v2(336.55,170.09)
  vias: v1(337.75,171.69)
+3.3V_RUN_EDP: length 26.1
  TOP w0.508: v2(176.55,144.96) 176.58,144.96 176.89,145.28 R107.2 ; v2(172.93,144.36) 172.58,144.72 R105.2
  IN2 w0.508: v2(168.26,143.18) 169.44,144.36 v2(172.93,144.36) 173.87,144.36 174.56,145.05 176.46,145.05 v2(176.55,144.96)
  IN2 w1.016: 179.88,129.08 179.1,129.08 176.37,126.35 170.46,126.35 169.31,127.5 168.84,127.5
  BOTTOM w0.508: v2(168.25,138.99) 168.52,138.71 169.6,138.71 169.99,139.09 R110.1
  vias: v1(167.11,151.65) v2(168.05,152.23) v2(168.08,151.61) v2(168.25,142.54) v2(168.32,129.26) v2(168.32,128.66) v2(180.72,129.3) v2(181.31,129.3)
+3.3V_RUN_FFS: length 6.9
  TOP w0.102: v2(116.87,13.41) v1(116.87,14.03)
  BOTTOM w0.305: 121.18,10.19 121.18,10.38 121,10.55 U88.7 ; 121.18,10.19 121.05,10.05 U88.8 ; 121.18,10.19 121.18,9.65 v2(121.27,9.56) ; C388.1 116.25,10.05 U88.14 ; C387.1 117.98,13.65 U88.1
  BOTTOM w0.508: C388.1 116.37,9.99 v2(116.84,9.52)
  vias: v2(116.87,12.8)
+3.3V_RUN_GFX: length 206.2
  TOP w0.508: v2(242.16,114.49) RV57.1 ; RV57.1 243.38,114.3 QV4.3 ; RV57.1 LV30.1 ; v2(230.27,113.11) 230.28,113.12 230.28,113.44 230.58,113.73 RV84.2 ; v2(230.12,128.78) 229.76,128.78 229.28,129.26 229.28,130.59 229.16,130.72 RV79.1 ; PR606.2 PR611.2 PR613.2 v4(305.8,169.61) ; RV96.1 223.72,125.45 v2(223.5,125.67) ; v2(244.31,136.6) 244.18,136.47 244.18,135.75 244.61,135.32 244.91,135.32 245.32,134.91 246.19,134.91 247.07,134.02 247.07,133.01 246.54,132.47 244.84,132.47 243.49,131.13 243.49,130.72 242.68,129.91 241.88,129.91 v2(241.49,130.3) ; v2(228.51,125.66) 228.51,125.45 227.97,124.92 RV41.2
  IN1 w0.508: v2(310.12,145.15) 309.69,145.58 309.69,151.37 309.34,151.71 309.34,153.78 309.99,154.43 309.99,157.49 308.94,158.54 308.94,161.75 308.72,161.97 308.72,166.69 306.47,168.94 306.42,168.94 306.05,169.31 306.05,169.35 v4(305.8,169.61) ; v2(230.27,113.11) 231.9,114.73 236.83,114.73 237.4,115.3 239.48,115.3 240.29,114.49 v2(242.16,114.49) ; v2(244.34,139.84) 244.25,139.84 ; 244.25,139.84 243.66,139.24 243.66,136.98 244.04,136.6 v2(244.31,136.6) ; 244.25,139.84 243.57,140.53 243.57,141.9 244.43,142.76 244.85,142.76 v2(245.03,142.94)
  IN2 w0.508: v2(241.49,130.3) 239.75,132.04 236.1,132.04 233.49,129.43 230.76,129.43 230.31,128.98 230.31,128.97 v2(230.12,128.78) 230.12,128.45 229.65,127.98 229.65,127.81 229.14,127.3 229.14,126.19 228.61,125.66 v2(228.51,125.66) 228.51,125.76 227.95,126.33 227.43,126.33 226.27,125.16 225.05,125.16 224.86,124.97 224.21,124.97 v2(223.5,125.67) ; v2(310.12,145.15) 309.99,145.02 309.17,145.02 308.08,143.93 304.54,143.93 303.52,142.9 300.71,142.9 300.71,142.9 289.25,142.9 285.8,146.35 274.57,146.35 274.33,146.6 262.7,146.6 260.96,144.86 254.84,144.86 253.41,146.28 253.15,146.55 251.97,146.55 250.21,144.79 250.21,144.28 248.67,142.74 245.23,142.74 v2(245.03,142.94)
  BOTTOM w0.508: 308.38,171.95 308.85,171.48 PR608.2 ; 308.38,171.95 306.98,171.95 306.51,171.48 306.51,170.32 v4(305.8,169.61) ; 308.38,171.95 308.83,172.4 311.04,172.4 311.45,172 311.45,171.22 PR604.2 PR602.2 ; RV102.1 v2(244.34,139.84) ; RV29.1 241.99,131.2 241.49,130.7 v2(241.49,130.3) 241.09,130.7 RV97.1 RV86.1 RV87.1 RV141.1 241.82,127.65 242.29,127.18 242.29,125.08 241.55,124.35 ; RV95.1 241.55,124.35 ; 241.55,124.35 242.64,124.35 243.39,123.6 243.39,118.67 241.92,117.2 241.92,114.73 v2(242.16,114.49) ; v2(244.31,136.6) 244.31,136.61 243.82,136.61 RV103.1
  vias: v3(245.3,140.73)
