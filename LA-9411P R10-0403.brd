# Allegro board LA-9411P R10-0403.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
PEG_CRX_GTX_C_P3: length 20.1
  TOP w0.102: v2(220.54,123.2) 220.66,123.31 220.66,123.44 220.51,123.6 220.34,123.6 220.12,123.38 220.12,120.78 220.66,120.24 220.66,119.13 218.33,116.8 218.08,116.8 217.81,116.53
  TOP w0.127: 217.81,116.53 213.83,112.55 213.83,111.65 213.43,111.25 212.89,111.25 212.76,111.12 212.76,110.77 212.89,110.64 213.05,110.64 213.28,110.41 213.28,109.82 CV7.1
  BOTTOM w0.102: UV1.U30 220.26,123.6 220.54,123.32 v2(220.54,123.2)
PEG_CRX_GTX_C_P4: length 21.7
  TOP w0.102: v2(219.43,121.38) 219.33,121.38 219.27,121.32 219.27,120.89 219.73,120.43 219.73,120.42 219.88,120.27 219.88,119.25 218.77,118.14 217.44,118.14 216.67,117.37 216.67,116.75 216.68,116.74 216.68,116.71
  TOP w0.127: 216.68,116.71 216.68,116.53 211.83,111.67 v4(211.83,110.62) 211.83,107.38 210.97,106.52 210.97,106.4 CV9.1
  BOTTOM w0.102: UV1.T33 218.73,121.32 218.73,121.43 218.96,121.66 219.24,121.66 219.43,121.47 v2(219.43,121.38)
PEG_CRX_GTX_C_P5: length 21.8
  TOP w0.102: 219.14,119.31 219.15,119.32 219.15,119.34 219.21,119.4 219.21,119.42 219.25,119.45 219.25,119.99 218.82,120.42 218.82,123.55 218.89,123.62 219.08,123.62 219.16,123.55 219.35,123.55 219.44,123.46 219.44,123.32 v2(219.4,123.28)
  TOP w0.127: CV11.1 209.93,109.87 209.93,110.93 215.45,116.45 v4(215.45,116.84) 215.45,118.51 215.84,118.9 218.73,118.9 219.14,119.31
  BOTTOM w0.102: v2(219.4,123.28) 219.4,123.41 219.1,123.71 218.96,123.71 UV1.T30
PEG_CRX_GTX_C_P6: length 22.7
  TOP w0.102: v2(218.17,120.93) 217.95,120.71 217.95,120.62 217.95,120.52 217.9,120.46 217.9,120.45 217.89,120.44
  TOP w0.127: 217.89,120.44 216.96,119.51 215.47,119.51 213.81,117.85 v4(213.81,116.19) 213.81,115.92 208.64,110.75 208.64,108.18 209.01,107.81 209.01,107.12 208.64,106.74 207.74,106.74 207.64,106.65 207.64,106.48 CV14.1
  BOTTOM w0.102: UV1.P33 217.65,121.31 217.7,121.36 218.33,121.36 218.44,121.26 218.44,121.06 218.31,120.93 v2(218.17,120.93)
PEG_CRX_GTX_C_P7: length 22.3
  TOP w0.102: 212.29,117.82 212.29,117.83 212.28,117.84 212.28,119.03 213.38,120.13 216.37,120.13 217.62,121.39 217.62,123.5 217.73,123.6 217.86,123.6 217.97,123.49 218.04,123.49 218.17,123.36 v2(218.17,123.21)
  TOP w0.127: CV16.1 206.69,109.8 206.69,109.93 212.29,115.54 212.29,117.82
  BOTTOM w0.102: v2(218.17,123.21) 217.65,123.21 217.57,123.29 217.57,123.52 UV1.P30
PEG_CRX_GTX_N0: length 80
  TOP w0.127: v2(218.4,107.53) 218.23,107.7 218.23,108.14 218.61,108.53 CV2.2
  IN1 w0.089: v2(161.73,107.92) 161.97,107.92 162.06,108.01 162.06,108.23 161.98,108.32 160.92,108.32 159.95,109.28 159.95,110.44 160.18,110.67 160.18,112.14 160.54,112.5 160.84,112.5 161.13,112.79 161.13,113.5 162.14,114.5 162.14,114.99 162.34,115.2 162.34,115.34 162.32,115.36 162.32,115.43 162.3,115.44 162.3,115.46
  IN1 w0.127: 162.3,115.46 162.3,115.84 165.8,119.34 174.48,119.34 178.84,114.99 180.13,114.99 184.13,110.98 184.13,110.6 185.19,109.54 188.23,109.54 190.7,107.07 201.02,107.07 206,112.05 214.55,112.05 218.4,108.2 v2(218.4,107.53)
  BOTTOM w0.089: v2(161.73,107.92) 161.26,107.45 JCPU1.M29
PEG_CRX_GTX_N1: length 80
  TOP w0.127: CV3.2 217.59,104.69 217.59,104.23 v2(217.76,104.06)
  IN1 w0.089: 173.59,111.3 173.49,111.3 173.47,111.32 167.38,111.32 166.4,110.34 165.46,110.34 165.35,110.23 165.35,109.7 164.94,109.29 164.58,109.29 164.36,109.07 164.36,107.54 164.14,107.31 163.43,107.31 163.34,107.22 163.34,106.94 163.41,106.87 163.68,106.87 v2(163.73,106.92)
  IN1 w0.127: v2(217.76,104.06) 217.76,103.49 217.33,103.06 210.5,103.06 209.28,101.84 194.91,101.84 194.76,101.69 194.76,101.36 194.49,101.09 182.15,101.09 181.53,100.47 181.53,99.43 181.26,99.16 180.21,99.16 179.94,99.43 179.94,99.83 179.81,99.96 178.67,99.96 178.54,99.83 178.54,98.87 178.28,98.6 173.92,98.6 173.66,98.87 173.66,99.88 173.92,100.15 175.09,100.15 175.22,100.28 175.22,100.99 175.09,101.12 174.05,101.12 173.78,101.39 173.78,111.14 173.63,111.3 173.59,111.3
  BOTTOM w0.089: JCPU1.K28 163.26,106.45 v2(163.73,106.92)
PEG_CRX_GTX_N2: length 77.5
  TOP w0.127: CV6.2 214.29,104.69 214.29,104.23 v2(214.46,104.06)
  IN1 w0.089: v2(161.73,108.92) 161.73,109.05 161.6,109.18 161.5,109.18 161.16,109.53 161.16,112.16 161.16,112.16 161.16,112.17 161.58,112.59 161.58,113.2 162.71,114.33 162.71,114.84 163.03,115.16
  IN1 w0.127: 163.03,115.16 163.23,115.37 163.23,115.71 166.11,118.59 174.11,118.59 181.58,111.12 182.7,111.12 183.35,110.48 183.35,109.73 186.25,106.82 186.96,106.82 187.46,106.32 192.17,106.32 200.56,106.32 200.56,106.32 200.76,106.32 200.76,106.32 201.18,106.32 201.33,106.32 206.31,111.3 213.05,111.3 215.86,108.49 215.86,106.13 214.46,104.74 v2(214.46,104.06)
  BOTTOM w0.089: JCPU1.M31 v2(161.73,108.92)
PEG_CRX_GTX_N3: length 77.4
  TOP w0.127: v2(212.86,107.5) 212.86,107.49 213.01,107.63 213.01,108.16 CV8.2
  IN1 w0.089: 173.59,112.54 173.58,112.54 173.56,112.52 166.38,112.52 166.14,112.28 166.14,111.64 166,111.51 164.32,111.51 164.13,111.32 164.13,109.69 163.96,109.52 163.31,109.52 163.08,109.29 163.08,109.01 162.99,108.92 v2(162.73,108.92)
  IN1 w0.127: v2(212.86,107.5) 212.86,107.49 213.2,107.15 213.2,106.89 212.84,106.53 211.69,106.53 210.36,105.19 209.33,105.19 208.87,104.74 208.87,103.15 208.59,102.87 194.35,102.87 193.63,102.16 183.04,102.16 182.91,102.28 182.91,102.75 182.65,103.02 181.39,103.02 181.12,102.75 181.12,101.54 181,101.41 180.17,101.41 180.04,101.54 180.04,102.75 179.78,103.02 177.62,103.02 177.35,102.75 177.35,101.03 177.22,100.9 176.41,100.9 176.28,101.03 176.28,101.94 176.03,102.2 175.07,102.2 174.94,102.32 174.94,103.17 175.07,103.3 176.05,103.3 176.32,103.57 176.32,104.35 176.05,104.62 174.96,104.62 174.79,104.8 174.79,111.62 173.87,112.54 173.59,112.54
  BOTTOM w0.089: JCPU1.L30 162.26,108.45 v2(162.73,108.92)
PEG_CRX_GTX_N4: length 72.8
  TOP w0.127: v2(210.57,104.06) 210.57,104.04 210.72,104.19 210.72,104.7 CV10.2
  IN1 w0.089: 164.3,115.17 164.29,115.16 164.27,115.16 164.22,115.12 164.2,115.12 163.41,114.33 163.41,114.14 162.33,113.06 162.33,111.68 162.09,111.44 161.83,111.44 161.73,111.34 v2(161.73,110.92)
  IN1 w0.127: 164.3,115.17 166.62,117.49 173.78,117.49 185.94,105.33 192.58,105.33 200.35,105.33 201.59,105.33 201.95,105.33 205.9,109.28 213.66,109.28 214.87,108.08 214.87,107.12 213.39,105.65 212.01,105.65 210.92,104.56 210.92,104.41 210.57,104.07 v2(210.57,104.06)
  BOTTOM w0.089: JCPU1.M33 v2(161.73,110.92)
PEG_CRX_GTX_N5: length 72.7
  TOP w0.127: v2(209.56,107.5) 209.56,107.49 209.7,107.63 209.7,108.16 CV12.2
  IN1 w0.089: 166.65,114.72 166.14,114.21 166.14,113.77 165.9,113.54 165.44,113.54 165.13,113.23 165.13,112.73 164.91,112.51 163.47,112.51 163.14,112.19 163.14,110.57 163.05,110.47 162.75,110.47 162.64,110.58 162.64,110.83 v2(162.73,110.92)
  IN1 w0.127: 166.65,114.72 173.78,114.72 175.65,112.85 175.65,106.32 176.85,105.12 178.8,105.12 180.04,103.87 180.75,103.87 180.82,103.81 185.12,103.81 185.39,103.54 185.39,103.03 185.52,102.91 185.9,102.91 186.03,103.03 186.03,103.54 186.29,103.81 186.88,103.81 187.14,103.54 187.14,103.03 187.27,102.91 187.65,102.91 187.78,103.03 187.78,103.54 188.05,103.81 188.63,103.81 188.9,103.54 188.9,103.03 189.02,102.91 189.4,102.91 189.53,103.03 189.53,103.54 189.8,103.81 190.38,103.81 190.65,103.54 190.65,103.03 190.78,102.91 191.16,102.91 191.28,103.03 191.28,103.34 191.55,103.61 192.13,103.61 192.4,103.34 192.4,103.03 192.53,102.91 192.91,102.91 193.04,103.03 193.04,103.54 193.31,103.81 205.14,103.81 205.41,104.08 205.41,104.85 205.72,105.17 207.16,105.17 207.29,105.29 207.29,106.84 207.55,107.11 208.35,107.11 208.62,106.84 208.62,106.16 208.75,106.03 209.77,106.03 209.9,106.16 209.9,107.15 209.56,107.49 v2(209.56,107.5)
  BOTTOM w0.089: JCPU1.L32 162.26,110.45 v2(162.73,110.92)
PEG_CRX_GTX_N6: length 63
  TOP w0.127: v2(207.3,104.06) 207.3,104.04 207.44,104.19 207.44,104.68 CV15.2
  IN2 w0.089: 167.23,108.5 167.19,108.5 167.17,108.52 166.5,108.52 166.14,108.16 166.14,107.75 165.94,107.55 164.58,107.55 164.36,107.76 164.36,108.67 164.33,108.7 164.33,112.32 162.59,114.06 162.59,115 162.19,115.4 161.6,115.4 161.36,115.16 161.36,114.92 v2(161.17,114.73)
  IN2 w0.14: 167.23,108.5 168.38,108.5 168.52,108.64 170.24,108.64 170.44,108.43 171.84,108.43 172.31,108.9 174.23,108.9 175.36,110.03 178.22,110.03 182.15,106.1 182.15,105.93 183.17,104.91 187.24,104.91 187.42,105.09 194.64,105.09 195.44,104.29 203.6,104.29 203.89,104 203.89,103.45 204.03,103.31 204.45,103.31 204.59,103.45 204.59,104 204.89,104.29 205.49,104.29 206.45,103.34 207.45,103.34 207.62,103.5 207.62,103.72 207.3,104.04 v2(207.3,104.06)
  BOTTOM w0.089: v2(161.17,114.73) 161.35,114.55 161.35,114.16 161.54,113.97 161.54,113.61 161.38,113.45 JCPU1.M35
PEG_CRX_GTX_N7: length 63.4
  TOP w0.127: CV17.2 206.4,108.16 206.4,107.63 206.26,107.49 v2(206.26,107.5)
  IN1 w0.089: v2(162.73,112.92) 162.52,112.7 162.52,112.56 162.59,112.48 162.84,112.48 163.13,112.77 163.13,112.95 163.54,113.36 163.72,113.36 164.13,113.77 164.13,114.22 164.84,114.93 164.84,114.96 164.86,114.97
  IN1 w0.127: 164.86,114.97 166.8,116.92 173.22,116.92 176.44,113.7 176.44,111.1 176.68,110.86 177.25,110.86 177.52,110.59 177.52,109.75 177.25,109.49 176.6,109.49 176.44,109.32 176.44,107.05 176.56,106.92 178.9,106.92 179.03,107.05 179.03,107.45 179.3,107.72 181.63,107.72 182.05,107.3 182.05,104.95 182.18,104.83 192.79,104.83 192.79,104.83 199.94,104.83 200.14,104.83 201.8,104.83 203.82,104.83 204.29,105.3 204.29,106.28 204.91,106.9 206.26,106.9 206.42,107.06 206.42,107.33 v2(206.26,107.5)
  BOTTOM w0.089: v2(162.73,112.92) 162.26,112.45 JCPU1.L34
PEG_CRX_GTX_P0: length 80
  TOP w0.127: CV1.2 217.96,108.16 217.96,107.64 217.81,107.5 v2(217.81,107.51)
  IN1 w0.089: v2(162.73,107.92) 162.73,107.8 162.57,107.63 162.34,107.63 162.26,107.71 162.26,108.32 162.06,108.52 161,108.52 160.16,109.37 160.16,110.35 160.38,110.58 160.38,112.06 160.62,112.29 160.93,112.29 161.34,112.7 161.34,113.41 162.34,114.41 162.34,114.91 162.54,115.11 162.54,115.46
  IN1 w0.127: 162.54,115.46 162.54,115.74 165.9,119.1 174.38,119.1 178.74,114.74 180.03,114.74 183.89,110.88 183.89,110.5 185.09,109.3 188.13,109.3 190.6,106.83 200.77,106.83 201.12,106.83 206.1,111.81 214.45,111.81 218.16,108.1 218.16,107.88 217.81,107.54 v2(217.81,107.51)
  BOTTOM w0.089: JCPU1.L29 162.26,107.45 v2(162.73,107.92)
PEG_CRX_GTX_P1: length 80
  TOP w0.127: CV4.2 217.32,104.7 217.32,104.19 217.18,104.04 v2(217.18,104.06)
  IN1 w0.089: v2(162.73,106.92) 163.06,106.92 163.13,106.99 163.13,107.31 163.34,107.52 164.05,107.52 164.16,107.62 164.16,109.16 164.49,109.5 164.86,109.5 165.15,109.79 165.15,110.31 165.38,110.54 166.32,110.54 167.3,111.52 173.54,111.52 173.56,111.54 173.59,111.54
  IN1 w0.127: 173.59,111.54 173.73,111.54 174.02,111.24 174.02,101.49 174.15,101.36 175.19,101.36 175.46,101.09 175.46,100.18 175.19,99.91 174.02,99.91 173.9,99.78 173.9,98.97 174.02,98.84 178.18,98.84 178.3,98.97 178.3,99.93 178.57,100.2 179.92,100.2 180.18,99.93 180.18,99.53 180.31,99.4 181.16,99.4 181.29,99.53 181.29,100.57 182.05,101.33 194.39,101.33 194.52,101.46 194.52,101.79 194.81,102.08 209.18,102.08 210.4,103.3 217.23,103.3 217.52,103.59 217.52,103.7 217.18,104.05 v2(217.18,104.06)
  BOTTOM w0.089: v2(162.73,106.92) 162.26,106.45 JCPU1.L28
PEG_CRX_GTX_P2: length 77.6
  TOP w0.127: CV5.2 214.02,104.7 214.02,104.19 213.88,104.04 v2(213.88,104.06)
  IN1 w0.089: 163.2,114.99 163.19,114.98 163.16,114.98 163.12,114.94 163.09,114.94 162.91,114.76 162.91,114.25 161.78,113.12 161.78,112.5 161.36,112.08 161.36,112.08 161.36,112.08 161.36,109.61 161.59,109.38 161.96,109.38 162.14,109.56 162.14,109.77 161.98,109.92 v2(161.73,109.92)
  IN1 w0.127: v2(213.88,104.06) 213.88,104.07 214.22,104.41 214.22,104.84 215.62,106.23 215.62,108.39 212.95,111.06 206.41,111.06 201.43,106.08 201.28,106.08 201.28,106.08 200.66,106.08 200.66,106.08 200.46,106.08 200.46,106.08 192.27,106.08 187.36,106.08 186.86,106.58 186.15,106.58 183.1,109.63 183.1,110.38 182.6,110.88 181.48,110.88 174.01,118.35 166.21,118.35 163.47,115.61 163.47,115.26 163.2,114.99
  BOTTOM w0.089: v2(161.73,109.92) 161.73,109.72 162.01,109.45 JCPU1.L31
PEG_CRX_GTX_P3: length 77.5
  TOP w0.127: CV7.2 213.27,108.13 213.27,107.67 v2(213.44,107.5)
  IN1 w0.089: 173.59,112.3 173.57,112.3 173.55,112.32 166.47,112.32 166.34,112.19 166.34,111.56 166.09,111.3 164.41,111.3 164.34,111.23 164.34,109.61 164.05,109.32 163.4,109.32 163.28,109.2 163.28,109 163.36,108.92 v2(163.73,108.92)
  IN1 w0.127: v2(213.44,107.5) 213.44,106.79 212.94,106.29 211.79,106.29 210.46,104.95 209.43,104.95 209.11,104.64 209.11,103.05 208.69,102.63 194.45,102.63 193.73,101.92 182.94,101.92 182.67,102.18 182.67,102.65 182.55,102.78 181.49,102.78 181.36,102.65 181.36,101.44 181.1,101.17 180.07,101.17 179.8,101.44 179.8,102.65 179.68,102.78 177.72,102.78 177.59,102.65 177.59,100.93 177.32,100.66 176.31,100.66 176.04,100.93 176.04,101.84 175.93,101.96 174.97,101.96 174.7,102.22 174.7,103.27 174.97,103.54 175.95,103.54 176.08,103.67 176.08,104.25 175.95,104.38 174.86,104.38 174.54,104.7 174.54,111.52 173.76,112.3 173.59,112.3
  BOTTOM w0.089: JCPU1.K30 163.26,108.45 v2(163.73,108.92)
PEG_CRX_GTX_P4: length 72.7
  TOP w0.127: v2(211.16,104.06) 210.99,104.23 210.99,104.69 CV9.2
  IN1 w0.089: v2(161.73,111.92) 161.73,111.77 161.86,111.65 162,111.65 162.12,111.77 162.12,113.14 163.2,114.22 163.2,114.41 164.13,115.34
  IN1 w0.127: 164.13,115.34 166.52,117.73 173.88,117.73 186.04,105.57 192.48,105.57 200.45,105.57 200.45,105.57 201.49,105.57 201.49,105.57 201.85,105.57 205.8,109.52 213.76,109.52 215.11,108.18 215.11,107.02 213.49,105.41 212.11,105.41 211.16,104.46 v2(211.16,104.06)
  BOTTOM w0.089: JCPU1.L33 v2(161.73,111.92)
PEG_CRX_GTX_P5: length 72.7
  TOP w0.127: CV11.2 209.97,108.13 209.97,107.67 v2(210.14,107.5)
  IN1 w0.089: v2(162.73,109.92) 162.73,110.13 162.87,110.27 163.13,110.27 163.35,110.48 163.35,112.1 163.55,112.31 164.99,112.31 165.34,112.65 165.34,113.14 165.53,113.33 165.98,113.33 166.34,113.69 166.34,114.12 166.69,114.48 166.72,114.48
  IN1 w0.127: v2(210.14,107.5) 210.14,106.06 209.87,105.79 208.65,105.79 208.38,106.06 208.38,106.74 208.25,106.87 207.65,106.87 207.53,106.74 207.53,105.19 207.26,104.93 205.82,104.93 205.65,104.75 205.65,103.98 205.24,103.57 193.41,103.57 193.28,103.44 193.28,102.93 193.01,102.67 192.43,102.67 192.16,102.93 192.16,103.24 192.03,103.37 191.65,103.37 191.53,103.24 191.53,102.93 191.26,102.67 190.68,102.67 190.41,102.93 190.41,103.44 190.28,103.57 189.9,103.57 189.77,103.44 189.77,102.93 189.5,102.67 188.92,102.67 188.66,102.93 188.66,103.44 188.53,103.57 188.15,103.57 188.02,103.44 188.02,102.93 187.75,102.67 187.17,102.67 186.9,102.93 186.9,103.44 186.78,103.57 186.39,103.57 186.27,103.44 186.27,102.93 186,102.67 185.42,102.67 185.15,102.93 185.15,103.44 185.02,103.57 180.72,103.57 180.65,103.63 179.94,103.63 178.7,104.88 176.75,104.88 175.41,106.22 175.41,112.75 173.68,114.48 166.72,114.48
  BOTTOM w0.089: v2(162.73,109.92) 163.2,110.39 JCPU1.K32
PEG_CRX_GTX_P6: length 63
  TOP w0.127: v2(207.88,104.06) 207.71,104.23 207.71,104.69 CV14.2
  IN2 w0.089: v2(161.76,114.67) 161.58,114.85 161.58,115.07 161.69,115.19 162.1,115.19 162.38,114.91 162.38,113.97 164.12,112.23 164.12,108.79 164.12,108.61 164.14,108.58 164.14,107.67 164.49,107.33 166.03,107.33 166.36,107.66 166.36,108.08 166.59,108.31 167.08,108.31 167.15,108.23 167.18,108.23
  IN2 w0.14: 167.18,108.23 168.49,108.23 168.63,108.37 170.12,108.37 170.33,108.17 171.95,108.17 172.42,108.64 174.34,108.64 175.47,109.77 178.11,109.77 181.89,105.99 181.89,105.82 183.06,104.64 187.35,104.64 187.53,104.82 194.53,104.82 195.33,104.03 203.49,104.03 203.63,103.89 203.63,103.34 203.92,103.04 204.56,103.04 204.86,103.34 204.86,103.89 205,104.03 205.38,104.03 206.34,103.07 207.56,103.07 207.88,103.39 v2(207.88,104.06)
  BOTTOM w0.089: v2(161.76,114.67) 161.58,114.49 161.58,114.25 161.77,114.06 161.77,113.68 162,113.45 JCPU1.L35
PEG_CRX_GTX_P7: length 63.4
  TOP w0.127: CV16.2 206.67,108.13 206.67,107.67 v2(206.84,107.5)
  IN1 w0.089: 165.03,114.8 164.96,114.73 164.93,114.73 164.33,114.13 164.33,113.69 163.8,113.16 163.63,113.16 163.33,112.86 163.33,112.69 162.92,112.28 162.81,112.28 162.73,112.2 v2(162.73,111.92)
  IN1 w0.127: 165.03,114.8 166.9,116.67 173.12,116.67 176.2,113.6 176.2,111 176.58,110.62 177.15,110.62 177.27,110.49 177.27,109.85 177.15,109.73 176.5,109.73 176.2,109.42 176.2,106.95 176.46,106.68 179,106.68 179.27,106.95 179.27,107.35 179.4,107.48 181.53,107.48 181.81,107.2 181.81,104.85 182.08,104.58 192.89,104.58 192.89,104.58 199.84,104.58 200.04,104.58 201.9,104.58 203.92,104.58 204.53,105.2 204.53,106.18 205.01,106.65 206.36,106.65 206.66,106.96 206.66,107.32 v2(206.84,107.5)
  BOTTOM w0.089: JCPU1.K34 163.2,112.39 v2(162.73,111.92)
PEG_CTX_GRX_C_N0: length 80.2
  IN2 w0.089: v2(164.73,113.92) 164.82,114.01 164.98,114.01 165.1,113.89 165.1,113.66 164.79,113.36 164.6,113.36 164.32,113.64 164.32,114.42 165.36,115.46 165.38,115.46
  IN2 w0.14: v2(216.15,104.45) 216.15,104.47 217.39,105.71 217.39,105.73 219.1,107.44 219.1,110.37 215.56,113.91 209.68,113.91 209.6,113.98 207.02,116.56 202.34,116.56 200.5,114.72 194.86,114.72 193.94,113.79 186.46,113.79 185.61,114.65 185.61,120.21 182.98,122.83 175.23,122.83 172.53,120.14 170.06,120.14 165.38,115.46
  BOTTOM w0.089: v2(164.73,113.92) 164.89,113.92 165.2,113.61 JCPU1.H35
  BOTTOM w0.127: v2(216.15,104.45) 216.3,104.6 216.3,104.83 216.06,105.07 CC2.2
PEG_CTX_GRX_C_N1: length 80.4
  IN2 w0.089: v2(165.73,112.92) 165.73,113.16 166.06,113.49 166.27,113.49 166.36,113.4 166.36,112.96 165.9,112.5 165.53,112.5 165.35,112.67 165.35,113.32 165.81,113.78 165.81,114.32 166.74,115.26 166.81,115.26 167.01,115.46
  IN2 w0.14: v2(216.78,107.91) 216.78,107.92 217.1,108.24 217.1,110.85 214.94,113 209.46,113 208.48,113.99 207.35,113.99 207.06,114.28 207.06,115.16 206.93,115.29 206.48,115.29 206.36,115.16 206.36,114.44 206.07,114.16 205.41,114.16 205.13,114.44 205.13,115.26 205,115.39 204.55,115.39 204.43,115.26 204.43,114.76 204.14,114.48 203.48,114.48 203.2,114.76 203.2,115.07 202.91,115.35 202.35,115.35 200.87,113.87 195.16,113.87 194.28,112.99 186.13,112.99 184.81,114.32 184.81,119.76 182.52,122.05 175.65,122.05 175.22,121.62 175.22,121.43 175.68,120.97 175.68,120.55 175.22,120.1 174.81,120.1 174.35,120.55 174.15,120.55 173.64,120.04 173.64,119.85 174.11,119.38 174.11,118.98 173.64,118.51 173.24,118.51 172.77,118.98 170.53,118.98 167.01,115.46
  BOTTOM w0.089: v2(165.73,112.92) 165.26,112.45 JCPU1.H34
  BOTTOM w0.127: v2(216.78,107.91) 216.96,108.08 216.96,108.18 216.62,108.52 CC4.2
PEG_CTX_GRX_C_N2: length 74.1
  IN2 w0.089: v2(164.73,111.92) 164.88,111.92 165.15,111.66 165.15,111.58 165.43,111.3 166.11,111.3 166.35,111.54 166.35,112.07 166.58,112.29 166.98,112.29 167.35,112.66 167.35,114.59 168.04,115.28 168.06,115.28
  IN2 w0.14: v2(212.85,104.45) 212.85,104.47 213.18,104.8 213.18,105.66 213.61,106.1 215.09,106.1 215.37,106.38 215.37,109.93 213.17,112.14 200.53,112.14 200.09,111.7 193.38,111.7 192.88,112.19 189.78,112.19 189.29,111.7 185.95,111.7 185.42,112.23 185.42,112.59 183.84,114.16 183.84,118.99 181.57,121.26 177.5,121.26 173.97,117.73 170.51,117.73 168.06,115.28
  BOTTOM w0.089: JCPU1.J33 164.26,111.45 v2(164.73,111.92)
  BOTTOM w0.127: CC6.2 212.81,105.07 213.05,104.83 213.05,104.66 v2(212.85,104.45)
PEG_CTX_GRX_C_N3: length 74.4
  IN2 w0.089: 169.31,115.27 169.3,115.26 169.26,115.26 169.22,115.21 169.18,115.21 168.41,114.44 168.35,114.38 168.35,111.65 168,111.3 166.98,111.3 165.97,110.3 165.4,110.3 165.22,110.48 165.22,110.76 165.05,110.92 v2(164.73,110.92)
  IN2 w0.14: v2(213.86,107.91) 213.99,108.03 213.99,110.13 212.91,111.2 211.44,111.2 211.3,111.06 211.3,110.77 211,110.48 210.36,110.48 210.07,110.77 210.07,111.06 209.93,111.2 209.51,111.2 209.37,111.06 209.37,110.77 209.07,110.48 208.43,110.48 208.14,110.77 208.14,111.06 208,111.2 207.58,111.2 207.44,111.06 207.44,110.77 207.14,110.48 206.5,110.48 206.21,110.77 206.21,111.06 206.07,111.2 200.82,111.2 200.5,110.88 193.07,110.88 192.59,111.37 190.11,111.37 189.63,110.88 184.82,110.88 182.43,113.27 182.43,113.79 183.03,114.39 183.03,115.23 182.8,115.46 182.33,115.46 181.59,114.72 178.79,114.72 177.49,116.01 177.05,116.01 176.75,116.31 176.75,118.72 176.63,118.85 176.25,118.85 176.12,118.72 176.12,116.3 175.84,116.01 175.28,116.01 174.99,116.31 174.99,116.93 174.86,117.06 174.42,117.06 174.29,116.93 174.29,116.31 173.99,116.01 173.29,116.01 172.99,116.31 172.99,116.8 172.87,116.93 172.42,116.93 172.29,116.8 172.29,116.31 172,116.01 171.36,116.01 170.9,116.47 170.51,116.47 169.93,115.89 169.55,115.51 169.31,115.27
  BOTTOM w0.089: v2(164.73,110.92) JCPU1.H32
  BOTTOM w0.127: CC8.2 213.71,108.52 214.04,108.19 214.04,108.08 v2(213.86,107.91)
PEG_CTX_GRX_C_N4: length 61.7
  IN2 w0.089: v2(164.73,109.92) 165.07,109.92 165.13,109.87 165.13,109.58 165.39,109.32 165.97,109.32 166.33,109.68 166.33,110.04 166.6,110.31 168.97,110.31 169.36,110.7 169.36,113.13 169.55,113.32 170.61,113.32 172.39,115.09
  IN2 w0.14: v2(209.55,104.45) 209.75,104.66 209.75,105.66 211.67,107.58 211.67,108.75 210.73,109.69 200.69,109.69 200.19,109.18 195.53,109.18 195.06,109.65 189.63,109.65 189.19,109.21 185.09,109.21 183.84,110.46 183.84,110.73 180.67,113.91 178.46,113.91 177.27,115.09 172.39,115.09
  BOTTOM w0.089: JCPU1.J31 164.26,109.45 v2(164.73,109.92)
  BOTTOM w0.127: v2(209.55,104.45) 209.72,104.63 209.72,104.76 209.42,105.07 CC10.2
PEG_CTX_GRX_C_N5: length 62
  IN2 w0.089: 173.59,114.03 172.86,113.3 171.58,113.3 171.34,113.07 171.34,112.69 170.97,112.32 170.57,112.32 170.33,112.08 170.33,109.63 170.01,109.31 166.54,109.31 166.15,108.91 166.15,108.8 166.23,108.72 166.54,108.72 v2(166.73,108.92)
  IN2 w0.14: v2(210.56,107.91) 210.56,107.92 210.88,108.24 210.88,108.42 210.71,108.6 209.94,108.6 209.79,108.45 209.79,108.21 209.5,107.92 208.93,107.92 208.64,108.21 208.64,108.78 208.52,108.9 207.25,108.9 206.54,108.19 205.72,108.19 205.58,108.05 205.58,107.38 205.28,107.09 204.64,107.09 204.35,107.38 204.35,107.72 204.22,107.85 203.78,107.85 203.65,107.72 203.65,107.38 203.35,107.09 202.71,107.09 202.42,107.38 202.42,108.67 202.21,108.88 201.12,108.88 200.44,108.19 196.73,108.19 195.72,107.18 187.32,107.18 186.67,107.82 184.66,107.82 182.89,109.59 182.89,110.34 182.37,110.86 181.99,110.86 179.86,112.99 179.42,112.99 179.27,112.84 179.27,112.52 178.96,112.22 178.06,112.22 177.71,112.57 177.71,113.5 176.95,114.26 173.82,114.26 173.59,114.03
  BOTTOM w0.089: v2(166.73,108.92) 166.26,108.45 JCPU1.G30
  BOTTOM w0.127: v2(210.56,107.91) 210.74,108.08 210.74,108.22 210.43,108.52 CC12.2
PEG_CTX_GRX_C_N6: length 42.3
  IN2 w0.089: 173.59,110.6 173.39,110.6 173.1,110.31 171.47,110.31 171.13,110.65 171.13,111.29 171,111.42 170.77,111.42 170.65,111.29 170.65,111.01 v2(170.73,110.92)
  IN2 w0.14: 173.59,110.6 178.39,110.6 182.71,106.28 182.71,106.11 183.39,105.43 186.99,105.43 187.17,105.61 195,105.61 195.32,105.28 206.35,105.28 206.56,105.07 206.56,104.79 206.24,104.47 v2(206.24,104.45)
  BOTTOM w0.089: JCPU1.C33 v2(170.73,110.92)
  BOTTOM w0.127: v2(206.24,104.45) 206.42,104.63 206.42,104.76 206.12,105.07 CC14.2
PEG_CTX_GRX_C_N7: length 42.4
  IN2 w0.089: 173.59,112.56 173.58,112.56 173.57,112.55 172.51,112.55 172.13,112.16 172.13,111.31 v2(171.73,110.92)
  IN2 w0.14: 173.59,112.56 176.27,112.56 177.17,111.66 179.55,111.66 184.06,107.15 186.61,107.15 187.1,106.66 195.62,106.66 195.91,106.37 206.84,106.37 207.58,107.11 207.58,107.57 207.26,107.89 v2(207.26,107.91)
  BOTTOM w0.089: v2(171.73,110.92) 171.26,110.45 JCPU1.B32
  BOTTOM w0.127: v2(207.26,107.91) 207.44,108.08 207.44,108.22 207.13,108.52 CC16.2
PEG_CTX_GRX_C_P0: length 80.2
  IN2 w0.089: v2(164.73,112.92) 164.73,112.92 164.11,113.55 164.11,114.56 165.01,115.46
  IN2 w0.14: v2(216.73,104.45) 216.73,104.68 217.66,105.6 217.66,105.62 219.36,107.33 219.36,110.48 215.67,114.17 209.79,114.17 207.13,116.83 202.23,116.83 200.39,114.99 194.75,114.99 193.83,114.06 186.57,114.06 185.87,114.76 185.87,120.32 183.09,123.1 175.12,123.1 172.42,120.4 169.95,120.4 165.01,115.46
  BOTTOM w0.089: JCPU1.J35 v2(164.73,112.92)
  BOTTOM w0.127: v2(216.73,104.45) 216.57,104.62 216.57,104.79 216.85,105.07 CC1.2
PEG_CTX_GRX_C_P1: length 80.4
  IN2 w0.089: v2(166.73,112.92) 166.63,112.92 165.99,112.28 165.44,112.28 165.13,112.59 165.13,113.41 165.59,113.87 165.59,114.41 166.63,115.46
  IN2 w0.14: 166.63,115.46 170.42,119.24 172.88,119.24 173.35,118.78 173.53,118.78 173.84,119.09 173.84,119.27 173.38,119.74 173.38,120.16 174.04,120.82 174.46,120.82 174.92,120.36 175.11,120.36 175.41,120.66 175.41,120.86 174.96,121.31 174.96,121.73 175.54,122.31 182.63,122.31 185.07,119.88 185.07,114.43 186.24,113.26 194.17,113.26 195.05,114.13 200.76,114.13 202.24,115.62 203.02,115.62 203.46,115.18 203.46,114.87 203.59,114.74 204.03,114.74 204.16,114.87 204.16,115.38 204.44,115.66 205.11,115.66 205.39,115.38 205.39,114.55 205.52,114.43 205.96,114.43 206.09,114.55 206.09,115.27 206.37,115.55 207.04,115.55 207.32,115.27 207.32,114.39 207.46,114.26 208.59,114.26 209.57,113.27 215.05,113.27 217.37,110.96 v2(217.37,107.91)
  BOTTOM w0.089: JCPU1.G34 166.26,112.45 v2(166.73,112.92)
  BOTTOM w0.127: v2(217.37,107.91) 217.23,108.05 217.23,108.22 217.53,108.52 CC3.2
PEG_CTX_GRX_C_P2: length 74.1
  IN2 w0.089: 167.86,115.46 167.86,115.42 167.13,114.69 167.13,112.75 166.89,112.51 166.49,112.51 166.14,112.16 166.14,111.63 166.02,111.52 165.52,111.52 165.36,111.67 165.36,111.82 165.43,111.89 v2(165.76,111.89)
  IN2 w0.14: 167.86,115.46 170.4,117.99 173.86,117.99 177.39,121.53 181.68,121.53 184.11,119.1 184.11,114.27 185.68,112.7 185.68,112.34 186.06,111.96 189.18,111.96 189.67,112.46 192.99,112.46 193.49,111.96 199.97,111.96 200.42,112.41 213.28,112.41 213.55,112.13 215.64,110.05 215.64,106.27 215.2,105.83 213.72,105.83 213.44,105.55 213.44,104.47 v2(213.43,104.45)
  BOTTOM w0.089: v2(165.76,111.89) 165.32,111.45 JCPU1.H33
  BOTTOM w0.127: CC5.2 213.58,105.07 213.32,104.8 213.32,104.57 v2(213.43,104.45)
PEG_CTX_GRX_C_P3: length 74.4
  IN2 w0.089: v2(165.73,110.92) 165.58,110.92 165.43,110.77 165.43,110.57 165.49,110.52 165.88,110.52 166.89,111.52 167.92,111.52 168.13,111.74 168.13,114.47 169.12,115.46
  IN2 w0.14: 169.12,115.46 169.28,115.62 169.74,116.08 170.4,116.74 171.01,116.74 171.47,116.28 171.89,116.28 172.03,116.42 172.03,116.91 172.31,117.2 172.98,117.2 173.26,116.91 173.26,116.42 173.4,116.28 173.88,116.28 174.02,116.42 174.02,117.04 174.31,117.32 174.97,117.32 175.26,117.04 175.26,116.42 175.39,116.28 175.73,116.28 175.85,116.41 175.85,118.83 176.14,119.11 176.74,119.11 177.02,118.83 177.02,116.42 177.16,116.28 177.61,116.28 178.9,114.99 181.48,114.99 182.22,115.72 182.91,115.72 183.29,115.34 183.29,114.28 182.7,113.68 182.7,113.39 184.93,111.15 189.52,111.15 190,111.63 192.7,111.63 193.19,111.15 200.39,111.15 200.71,111.47 206.18,111.47 206.47,111.17 206.47,110.88 206.61,110.74 207.03,110.74 207.17,110.88 207.17,111.17 207.47,111.47 208.11,111.47 208.4,111.17 208.4,110.88 208.54,110.74 208.96,110.74 209.1,110.88 209.1,111.17 209.4,111.47 210.04,111.47 210.34,111.17 210.34,110.88 210.47,110.74 210.89,110.74 211.03,110.88 211.03,111.17 211.33,111.47 213.03,111.47 214.26,110.24 214.26,108.1 v2(214.45,107.91)
  BOTTOM w0.089: v2(165.73,110.92) JCPU1.G32
  BOTTOM w0.127: v2(214.45,107.91) 214.31,108.05 214.31,108.23 214.6,108.52 CC7.2
PEG_CTX_GRX_C_P4: length 61.8
  IN2 w0.089: 172.37,115.36 172.35,115.33 172.29,115.33 172.14,115.19 172.14,115.16 170.52,113.54 169.46,113.54 169.14,113.22 169.14,110.79 168.88,110.53 166.51,110.53 166.49,110.51 166.11,110.13 166.11,109.77 165.88,109.54 165.48,109.54 165.34,109.67 165.34,109.81 165.45,109.92 v2(165.73,109.92)
  IN2 w0.14: v2(210.13,104.45) 210.02,104.57 210.02,105.55 211.93,107.47 211.93,108.86 210.84,109.96 200.58,109.96 200.08,109.45 195.64,109.45 195.17,109.92 189.52,109.92 189.08,109.47 185.2,109.47 184.11,110.57 184.11,110.85 180.78,114.17 178.57,114.17 177.38,115.36 172.37,115.36
  BOTTOM w0.089: JCPU1.H31 165.26,109.45 v2(165.73,109.92)
  BOTTOM w0.127: v2(210.13,104.45) 209.99,104.59 209.99,104.76 210.29,105.07 CC9.2
PEG_CTX_GRX_C_P5: length 62.1
  IN2 w0.089: 173.4,114.22 173.4,114.21 173.4,114.18 173.35,114.13 173.35,114.1 172.77,113.52 171.49,113.52 171.13,113.16 171.13,112.78 170.88,112.53 170.48,112.53 170.11,112.17 170.11,109.72 169.92,109.52 166.45,109.52 166.02,109.09 165.85,108.92 v2(165.73,108.92)
  IN2 w0.14: v2(211.15,107.91) 211.15,108.53 210.82,108.86 209.83,108.86 209.52,108.56 209.52,108.32 209.39,108.19 209.04,108.19 208.91,108.32 208.91,108.89 208.63,109.17 207.14,109.17 206.43,108.46 205.61,108.46 205.31,108.16 205.31,107.49 205.17,107.35 204.75,107.35 204.62,107.49 204.62,107.83 204.33,108.11 203.67,108.11 203.38,107.83 203.38,107.49 203.24,107.35 202.82,107.35 202.68,107.49 202.68,108.78 202.32,109.14 201.01,109.14 200.33,108.46 196.62,108.46 195.61,107.45 187.43,107.45 186.78,108.09 184.77,108.09 183.16,109.7 183.16,110.45 182.48,111.12 182.1,111.12 179.97,113.26 179.31,113.26 179,112.95 179,112.63 178.85,112.48 178.17,112.48 177.97,112.68 177.97,113.61 177.06,114.53 173.71,114.53 173.4,114.22
  BOTTOM w0.089: v2(165.73,108.92) 165.26,108.45 JCPU1.H30
  BOTTOM w0.127: v2(211.15,107.91) 211.01,108.05 211.01,108.22 211.31,108.52 CC11.2
PEG_CTX_GRX_C_P6: length 42.2
  IN2 w0.089: v2(170.73,111.92) 170.73,111.73 170.84,111.63 171.09,111.63 171.34,111.38 171.34,110.74 171.56,110.53 173.01,110.53 173.35,110.87 173.59,110.87
  IN2 w0.14: 173.59,110.87 178.5,110.87 182.98,106.39 182.98,106.22 183.5,105.7 186.88,105.7 187.06,105.87 195.11,105.87 195.43,105.55 206.46,105.55 206.83,105.18 v2(206.83,104.45)
  BOTTOM w0.089: v2(170.73,111.92) 170.8,111.92 171.2,111.51 JCPU1.B33
  BOTTOM w0.127: CC13.2 206.98,105.07 206.69,104.77 206.69,104.59 v2(206.83,104.45)
PEG_CTX_GRX_C_P7: length 42.5
  IN2 w0.089: 173.59,112.29 173.58,112.29 173.56,112.32 173.49,112.32 173.48,112.33 172.6,112.33 172.34,112.07 172.34,111.14 172.57,110.92 v2(172.73,110.92)
  IN2 w0.14: v2(207.84,107.91) 207.84,107 206.95,106.11 195.8,106.11 195.51,106.39 186.99,106.39 186.5,106.88 183.95,106.88 179.44,111.39 177.06,111.39 176.16,112.29 173.59,112.29
  BOTTOM w0.089: JCPU1.A32 172.26,110.45 v2(172.73,110.92)
  BOTTOM w0.127: v2(207.84,107.91) 207.7,108.05 207.7,108.22 208.01,108.52 CC15.2
PEG_CTX_GRX_N0: length 17
  BOTTOM w0.102: 222.93,116.22 222.93,117.65 222.75,117.83 222.75,118.12 222.65,118.23 222.65,118.6 UV1.Y37
  BOTTOM w0.127: CC2.1 216.33,106.39 216.33,106.58 216.63,106.88 218.52,106.88 218.89,107.26 218.89,111.4 v4(220.36,112.87) 222.93,115.44 222.93,116.22
PEG_CTX_GRX_N1: length 16.8
  BOTTOM w0.102: 222.12,116.22 222.12,116.55 221.88,116.78 221.88,118.19 221.97,118.28 221.97,118.5 221.94,118.53 221.94,119.01 222.06,119.12 222.06,119.23 221.95,119.33 221.78,119.33 221.65,119.2 UV1.W36
  BOTTOM w0.127: 222.12,116.22 222.12,115.75 v4(221.29,114.92) 218.78,112.41 218.03,112.41 217.78,112.15 217.78,111.74 218.12,111.4 218.12,110.89 217.99,110.77 217.76,110.77 216.91,111.62 216.26,111.62 215.96,111.32 215.96,110.39 216.24,110.12 216.71,110.12 216.87,109.95 216.87,109.73 CC4.1
PEG_CTX_GRX_N2: length 19.1
  BOTTOM w0.102: 221.17,116.22 221.17,116.23 221.18,116.24 221.18,116.32 221.19,116.34 221.19,116.91 221.43,117.14 221.43,117.85 221.1,118.18 221.1,118.59 220.9,118.8 UV1.V37
  BOTTOM w0.127: CC6.1 212.99,106.35 212.99,106.67 213.25,106.93 215.09,106.93 215.34,107.18 215.34,107.79 215.18,107.94 v4(215.18,111.56) 215.18,111.96 215.62,112.39 216.59,112.39 217.38,113.18 218.45,113.18 221.17,115.9 221.17,116.22
PEG_CTX_GRX_N3: length 18.8
  BOTTOM w0.102: UV1.U36 220.05,119.2 220.12,119.28 220.35,119.28 220.43,119.2 220.43,119.1 220.27,118.94 220.27,118.62 220.39,118.51 220.39,118.28 220.23,118.12 220.23,116.94 219.91,116.62 219.91,116.34 219.9,116.32 219.9,116.24 219.88,116.23 219.88,116.22
  BOTTOM w0.127: CC8.1 214.05,109.83 214.05,110.04 213.97,110.12 213.88,110.12 213.6,110.4 213.6,111 213.88,111.28 214.25,111.28 214.41,111.44 214.41,111.89 214.31,111.99 213.9,111.99 213.64,112.26 213.64,112.92 213.89,113.18 214.49,113.18 214.59,113.29 214.59,113.88 214.95,114.24 v4(215.21,114.24) 215.48,114.24 215.76,113.95 215.76,113.3 215.89,113.17 216.27,113.17 216.4,113.3 216.4,113.95 216.68,114.24 217.22,114.24 217.5,113.96 217.86,113.96 219.88,115.98 219.88,116.22
PEG_CTX_GRX_N4: length 19.8
  BOTTOM w0.102: 218.92,116.22 218.92,116.26 219.77,117.11 219.77,117.91 219.5,118.17 219.5,118.54 UV1.T37
  BOTTOM w0.127: 218.92,116.22 218.92,116.14 217.81,115.04 214.65,115.04 212.82,113.21 v4(212.82,110.65) 212.82,108.73 211.04,106.95 210.02,106.95 209.71,106.64 209.71,106.37 CC10.1
PEG_CTX_GRX_N5: length 19.8
  BOTTOM w0.102: 218.28,116.66 218.3,116.68 218.32,116.68 218.6,116.96 218.6,118.07 218.75,118.23 218.75,118.55 218.74,118.57 218.74,119.04 218.79,119.09 218.79,119.21 218.7,119.3 218.55,119.3 218.45,119.2 UV1.R36
  BOTTOM w0.127: CC12.1 210.75,109.83 210.75,111.1 211.04,111.39 211.92,111.39 212.05,111.51 212.05,111.9 211.92,112.02 210.69,112.02 210.41,112.31 210.41,112.91 210.69,113.19 211.92,113.19 212.05,113.32 v4(212.05,114.24) 212.05,115.13 212.78,115.86 217.48,115.86 217.95,116.33 218.28,116.66
PEG_CTX_GRX_N6: length 22.9
  BOTTOM w0.102: UV1.P37 217.65,118.79 217.87,118.57 217.87,118.24 217.95,118.16 217.95,117.28 217.65,116.98 217.13,116.98 216.76,116.61 211.45,116.61 211.41,116.57 211.4,116.57 211.34,116.52 211.32,116.52 211.31,116.51
  BOTTOM w0.127: 211.31,116.51 211.21,116.41 211.02,116.22 210.03,116.22 209.63,115.82 v4(209.63,114.62) 209.63,110.3 208.75,109.41 208.75,107.24 208.5,107 206.74,107 206.45,106.71 206.45,106.41 CC14.1
PEG_CTX_GRX_N7: length 22.7
  BOTTOM w0.102: UV1.N36 216.94,119.29 217.17,119.29 217.23,119.23 217.23,119.1 217.12,118.99 217.12,118.56 217.15,118.52 217.15,118.27 216.81,117.92 216.81,117.91 215.99,117.09 209.7,117.09 209.15,116.55
  BOTTOM w0.127: CC16.1 207.49,109.87 207.49,111.28 207.77,111.56 208.73,111.56 208.86,111.69 208.86,112.07 208.73,112.19 207.77,112.19 207.49,112.48 207.49,113.08 207.77,113.36 v4(208.28,113.36) 208.73,113.36 208.86,113.49 208.86,113.87 208.73,114 207.77,114 207.49,114.28 207.49,114.88 209.01,116.41 209.15,116.55
PEG_CTX_GRX_P0: length 17.1
  BOTTOM w0.102: 223.2,116.22 223.2,116.23 223.19,116.24 223.19,116.32 223.17,116.34 223.17,117.7 222.96,117.92 222.96,118.21 222.85,118.32 222.85,118.42 222.94,118.52 223.13,118.52 UV1.AA38
  BOTTOM w0.127: 223.2,116.22 223.2,115.33 219.16,111.29 v4(219.16,108.32) 219.16,107.15 218.63,106.62 216.74,106.62 216.59,106.47 216.59,106.37 CC1.1
PEG_CTX_GRX_P1: length 16.8
  BOTTOM w0.102: UV1.Y35 222.26,119.4 222.26,119.04 222.15,118.92 222.15,118.67 222.22,118.6 222.22,118.19 222.12,118.1 222.12,116.88 222.36,116.65 222.36,116.34 222.37,116.32 222.37,116.24 222.39,116.23 222.39,116.22
  BOTTOM w0.127: CC3.1 217.14,109.89 217.14,110.06 216.82,110.38 216.35,110.38 216.23,110.5 216.23,111.21 216.37,111.35 216.8,111.35 217.65,110.5 218.11,110.5 218.38,110.78 v4(218.38,111.1) 218.38,111.51 218.04,111.85 218.04,112.04 218.14,112.14 218.89,112.14 222.39,115.64 222.39,116.22
PEG_CTX_GRX_P2: length 19.1
  BOTTOM w0.102: UV1.W38 221.65,118.46 221.55,118.55 221.41,118.55 221.31,118.46 221.31,118.26 221.67,117.9 221.67,117.04 221.43,116.81 221.43,116.22
  BOTTOM w0.127: CC5.1 213.65,106.01 213.25,106.4 213.25,106.56 213.36,106.67 215.2,106.67 215.6,107.07 215.6,107.9 215.45,108.05 215.45,111.85 215.73,112.13 216.7,112.13 217.49,112.92 v4(217.98,112.92) 218.56,112.92 221.43,115.79 221.43,116.22
PEG_CTX_GRX_P3: length 18.8
  BOTTOM w0.102: UV1.V35 220.73,119.6 220.63,119.49 220.63,119.01 220.52,118.89 220.52,118.7 220.63,118.58 220.63,118.21 220.47,118.05 220.47,116.84 220.15,116.52 220.15,116.22
  BOTTOM w0.127: 220.15,116.22 220.15,115.87 217.97,113.69 217.39,113.69 217.11,113.97 216.79,113.97 216.66,113.84 v4(216.66,113.53) 216.66,113.19 216.38,112.9 215.78,112.9 215.49,113.19 215.49,113.84 215.37,113.97 215.06,113.97 214.86,113.77 214.86,113.17 214.6,112.92 214,112.92 213.9,112.81 213.9,112.37 214.01,112.26 214.42,112.26 214.68,112 214.68,111.33 214.36,111.02 213.99,111.02 213.86,110.89 213.86,110.51 213.99,110.38 214.09,110.38 214.32,110.15 214.32,109.79 CC7.1
PEG_CTX_GRX_P4: length 19.8
  BOTTOM w0.102: UV1.U38 220.05,118.45 219.93,118.57 219.79,118.57 219.71,118.48 219.71,118.26 219.98,117.98 219.98,116.98 219.22,116.22
  BOTTOM w0.127: CC9.1 209.98,106.39 209.98,106.53 210.13,106.68 211.15,106.68 213.09,108.62 v4(213.09,112.46) 213.09,113.1 214.76,114.77 217.92,114.77 219.19,116.03 219.19,116.19 219.22,116.22
PEG_CTX_GRX_P5: length 19.8
  BOTTOM w0.102: 218.22,116.22 218.49,116.49 218.49,116.51 218.84,116.86 218.84,118.01 218.97,118.14 218.97,118.64 218.95,118.67 218.95,118.95 219,119 219,119.34 UV1.T35
  BOTTOM w0.127: 218.22,116.22 218.14,116.14 217.6,115.6 212.89,115.6 212.31,115.02 212.31,113.21 212.03,112.92 v4(211.49,112.92) 210.8,112.92 210.68,112.8 210.68,112.42 210.8,112.29 212.03,112.29 212.31,112.01 212.31,111.4 212.03,111.12 211.15,111.12 211.02,110.99 211.02,109.79 CC11.1
PEG_CTX_GRX_P6: length 22.9
  BOTTOM w0.102: UV1.R38 218.45,118.4 218.45,118.45 218.35,118.55 218.16,118.55 218.07,118.47 218.07,118.33 218.16,118.24 218.16,117.14 217.75,116.74 217.23,116.74 216.86,116.37 211.55,116.37 211.5,116.32 211.4,116.22
  BOTTOM w0.127: 211.4,116.22 211.13,115.95 210.14,115.95 209.9,115.71 v4(209.9,112.84) 209.9,110.19 209.01,109.3 209.01,107.13 208.61,106.73 206.85,106.73 206.71,106.59 206.71,106.35 CC13.1
PEG_CTX_GRX_P7: length 22.6
  BOTTOM w0.102: UV1.P35 217.43,119.38 217.43,119.01 217.32,118.9 217.32,118.7 217.4,118.62 217.4,118.2 217.05,117.86 217.05,117.81 216.1,116.85 209.83,116.85 209.2,116.22
  BOTTOM w0.127: 209.2,116.22 207.75,114.77 207.75,114.39 207.88,114.26 208.84,114.26 209.13,113.98 209.13,113.38 208.84,113.1 207.88,113.1 207.75,112.97 207.75,112.59 207.88,112.46 208.84,112.46 209.13,112.18 209.13,111.57 208.84,111.29 v4(208.4,111.29) 207.88,111.29 207.75,111.16 207.75,109.75 CC15.1
PHASE1: length 35.6
  IN2 w1.016: 145.52,136.54 145.52,139.71 143.62,141.62 143.62,151.78 142.86,152.54 131.21,152.54 128.92,154.83 125.33,154.83
  vias: v1(144.25,135.9) v4(123.68,154.95) v4(124.32,154.95) v4(136.25,134.7) v4(136.51,135.46) v4(136.95,136.03) v4(137.02,134.7) v4(137.27,135.46) v4(137.71,136.03) v4(137.78,134.7) v4(138.03,135.46) v4(138.48,136.03) v4(138.54,134.7) v4(138.79,135.46) v4(139.24,136.03) v4(139.3,134.7) v4(139.56,135.46) v4(142.35,135.52) v4(142.73,134.76) v4(143.05,134.12) v4(143.11,135.52) v4(143.49,134.76) v4(143.87,135.52) v4(143.81,134.12) v4(144.25,134.76) v4(144.57,134.12) v4(144.64,135.52) v4(145.02,134.76) v4(145.33,134.12) v4(145.4,135.52) v4(145.78,134.76)
PHASE1_VGA: length 29.2
  IN1 w1.016: 306.18,159.78 306.18,159.4 307.2,158.38 307.2,153.31 306.69,152.81 306.69,150.44 302.94,146.7 292.59,146.7 290.05,149.24
  vias: v1(285.1,154.95) v4(286.88,156.6) v4(286.88,155.84) v4(286.88,155.08) v4(286.88,151.14) v4(286.88,150.38) v4(286.88,149.62) v4(287.64,156.6) v4(287.64,155.84) v4(287.64,155.08) v4(287.64,151.14) v4(287.64,150.38) v4(287.64,149.62) v4(288.02,154.44) v4(288.4,156.6) v4(288.4,155.84) v4(288.4,155.08) v4(288.4,151.14) v4(288.4,150.38) v4(288.4,149.62) v4(289.16,156.6) v4(289.16,155.84) v4(289.16,151.14) v4(289.16,150.38) v4(289.16,149.62) v4(306.94,160.34) v4(307.64,160.6)
PHASE2: length 16.6
  IN4 w1.016: 128.89,136.66 124.57,140.98 124.57,146.57 122.92,148.22 122.92,150.76
  vias: v1(122.92,151.27) v4(122.16,152.16) v4(122.54,151.65) v4(122.98,136.16) v4(123.05,134.76) v4(123.43,135.52) v4(123.81,134.76) v4(124.19,135.52) v4(124.51,136.16) v4(124.57,134.76) v4(124.95,135.52) v4(125.27,136.16) v4(125.33,134.76) v4(125.71,135.52) v4(126.03,136.16) v4(126.09,134.76) v4(126.47,135.52) v4(129.14,135.52) v4(129.52,134.76) v4(129.9,135.52) v4(130.28,134.76) v4(130.67,135.52) v4(130.98,136.09) v4(131.05,134.76) v4(131.43,135.52) v4(131.75,136.09) v4(131.81,134.76) v4(132.19,135.52) v4(132.57,134.76) v4(132.63,136.09) v4(133.02,135.33)
PHASE2_VGA: length 20
  IN1 w1.016: 289.12,160.01 289.67,160.01 297.06,167.4 302.5,167.4 303.64,166.26 303.64,165.24 304.15,164.73 304.4,164.73
  vias: v1(284.59,158.51) v4(285.95,160.32) v4(285.95,159.56) v4(285.95,158.8) v4(285.99,161.81) v4(286.3,167.14) v4(286.29,166.41) v4(286.75,161.81) v4(286.71,160.32) v4(286.71,159.56) v4(286.71,158.8) v4(286.94,167.14) v4(287.05,166.41) v4(287.47,160.32) v4(287.47,159.56) v4(287.47,158.8) v4(287.51,161.81) v4(287.7,167.14) v4(287.78,166.38) v4(288.27,161.81) v4(288.23,160.32) v4(288.23,159.56) v4(288.23,158.8) v4(288.46,167.14) v4(289.23,167.14) v4(305.8,164.35) v4(306.43,164.35)
PHASE3: length 17.4
  IN2 w1.016: 158.1,136.28 158.1,144.5 161.02,147.42 161.02,151.49 160.31,152.2
  vias: v1(158.61,152.67) v4(148.83,134.89) v4(149.26,135.62) v4(149.21,134.19) v4(149.59,134.89) v4(149.97,135.65) v4(149.97,134.19) v4(150.35,134.89) v4(150.73,135.65) v4(150.73,134.19) v4(151.11,134.89) v4(151.49,135.65) v4(151.49,134.19) v4(151.87,134.89) v4(152.26,135.65) v4(152.26,134.19) v4(155.43,135.39) v4(155.43,134.63) v4(155.62,133.93) v4(156.19,135.39) v4(156.19,134.63) v4(156.38,133.93) v4(156.95,135.39) v4(156.95,134.63) v4(157.15,133.93) v4(157.72,135.39) v4(157.72,134.63) v4(157.91,133.93) v4(158.48,135.39) v4(158.48,134.63) v4(158.67,133.93) v4(159.46,152.48) v4(159.52,153.16)
PLTRST_EMB#: length 203.7
  TOP w0.102: v2(184.48,62.78) 184.43,62.78 v1(182.82,64.38) 182.39,64.81 182.39,67.61 183.76,68.97 184.78,68.97 185.03,69.22 RH113.1 ; v2(239.57,26.06) 239.42,26.06 238.87,26.61 238.87,30.11 239.47,30.71 239.47,42.75 239.21,43.01 JSATA2.28
  IN2 w0.127: v2(268.93,31.57) 268.33,30.98 265.98,30.98 265.45,31.51 262,31.51 259.3,28.82 256,28.82 255.23,29.59 250.05,29.59 247.65,27.19 244.34,27.19 243.76,26.61 241.45,26.61 240.9,26.06 v2(239.57,26.06)
  IN4 w0.102: v2(268.93,31.57) 268.92,31.57 268.08,30.73 268.08,27.66 266.45,26.03 265.27,26.03 264.87,25.63 264.49,25.63 264.33,25.47 264.33,25.32 264.76,24.9 264.76,24.75 264.61,24.61 264.47,24.61 264.04,25.04 263.9,25.04 263.76,24.89 263.76,24.75 264.18,24.32 264.18,24.18 264.04,24.04 263.89,24.04 263.47,24.46 263.32,24.46 263.18,24.32 263.18,24.17 263.61,23.75 263.61,23.6 263.46,23.46 263.32,23.46 262.89,23.89 262.75,23.89 262.61,23.74 262.61,23.6 263.03,23.17 263.03,23.03 262.89,22.89 262.74,22.89 262.32,23.31 262.17,23.31 262.03,23.17 262.03,23.02 262.45,22.6 262.45,22.45 262.31,22.31 262.17,22.31 261.74,22.74 261.6,22.74 261.45,22.59 261.45,22.45 261.88,22.02 261.88,21.88 261.74,21.74 261.59,21.74 261.17,22.16 261.02,22.16 260.88,22.02 260.88,21.87 261.3,21.45 261.3,21.3 261.16,21.16 261.02,21.16 260.59,21.58 260.45,21.58 260.3,21.44 260.3,21.3 260.73,20.87 260.73,20.73 260.59,20.58 260.44,20.58 260.02,21.01 259.87,21.01 259.73,20.87 259.73,20.72 260.15,20.3 260.15,20.15 260.01,20.01 259.87,20.01 259.44,20.43 259.3,20.43 259.15,20.29 259.15,20.15 259.58,19.72 259.58,19.58 259.44,19.43 259.29,19.43 258.87,19.86 258.72,19.86 258.58,19.72 258.58,19.57 259,19.15 259,19 258.86,18.86 258.72,18.86 258.29,19.28 258.15,19.28 258,19.14 258,19 258.43,18.57 258.43,18.43 258.29,18.28 258.14,18.28 257.72,18.71 257.57,18.71 257.43,18.57 257.43,18.42 257.85,18 257.85,17.85 257.71,17.71 257.57,17.71 257.14,18.13 257,18.13 256.27,17.41 231.99,17.41 230.9,18.5 229.95,18.5 229.34,17.89 227.45,17.89 226.87,18.48 223.52,18.48 222.33,17.3 215.05,17.3 191.88,40.47 191.88,43.77 184.46,51.18 184.46,59.18 184.86,59.57 184.86,60.08 184.98,60.21 185.5,60.21 185.62,60.34 185.62,60.54 185.5,60.67 184.79,60.67 184.66,60.79 184.66,60.98 184.79,61.11 185.5,61.11 185.62,61.23 185.62,61.53 185.45,61.7 184.8,61.7 184.67,61.82 184.67,62.65 184.54,62.78 v2(184.48,62.78)
PLTRST_GPU#: length 117.2
  TOP w0.102: v2(190.61,88.28) 190.61,87.58 v1(190.32,87.29) 190.04,87.01 190.04,81.15 190.76,80.42 190.76,78.29 188.91,76.44 188.91,74.05 187.76,72.9 186.45,72.9 185.89,72.33 185.89,70.29 RH114.1
  IN4 w0.102: v2(190.61,88.28) 190.8,88.09 198.51,88.09 200.47,90.04 200.47,90.56 200.52,90.61 200.52,94.3 205.04,98.83 208.91,98.83 210.06,99.98 214.21,99.98 214.61,99.58 221.22,99.58 222.55,100.91 230.99,100.91 232.4,102.32 236.62,102.32 237.14,101.8 242.45,101.8 243.09,102.44 243.09,107.19 243.86,107.96 243.86,130.11 v2(244.42,130.67)
  BOTTOM w0.102: UV14.2 245.96,132.98 246.24,132.7 246.24,131.61 245.93,131.31 245.17,131.31 244.53,130.67 v2(244.42,130.67)
PLTRST_LAN#: length 343
  TOP w0.102: RH111.1 183.9,67.97 183.21,67.27 183.21,66.28 v2(184.48,65.01)
  IN2 w0.127: v2(317.71,202.96) 315.35,202.96 314.88,202.49 310.68,202.49 309.85,201.66 309.85,200.32 308.4,198.87 307.49,198.87 304.35,195.73 304.35,192.66 302.79,191.1 301.79,191.1 300.88,190.19 300.88,187.97 298.6,185.69 288.57,185.69 v2(288.2,185.32) ; v2(289.3,177.37) 289.06,177.37 288.36,176.67 288.03,176.67 285.05,173.68 v2(285.05,173.42)
  IN3 w0.127: v2(289.3,177.37) 289.3,180.66 288.82,181.14 288.82,184.7 v2(288.2,185.32)
  IN4 w0.102: v2(285.05,173.42) 285.05,173.99 284.68,174.36 278.66,174.36 278.62,174.32 277.26,174.32 276.44,173.49 276.44,173.47 274.62,171.65 273.17,171.65 272.07,170.55 272.07,166.56 271.45,165.94 271.45,151.14 271.86,150.72 271.86,147.04 271.32,146.49 271.32,138.39 270.62,137.69 270.62,131.18 270.95,130.85 270.95,129.59 271.76,128.78 271.76,124.85 270.97,124.06 270.97,119.74 271.76,118.95 271.76,112.53 271.27,112.03 271.27,100.7 270.51,99.94 270.51,99.36 267.04,95.9 267.04,94.06 265.71,92.72 265.71,92.67 265.67,92.64 265.67,88.92 265.29,88.54 265.28,88.54 264.4,87.66 264.4,80.14 264.74,79.8 264.74,74.81 264.42,74.49 264.42,71.67 264.85,71.23 264.85,65.03 266.33,63.56 266.33,63.02 267.95,61.4 267.95,60.1 268.3,59.75 268.3,58.17 268.16,58.03 268.16,54.88 268.64,54.39 268.64,50.81 269.34,50.11 269.34,48.21 268.46,47.33 267.88,47.33 267.17,46.62 267.17,44.63 266.38,43.84 266.38,41.25 266.16,41.03 266.16,34.01 265.16,33.01 265.16,29.96 255.43,20.23 246.31,20.23 245.75,19.67 232.82,19.67 231.46,21.03 222.16,21.03 221.37,20.24 215.19,20.24 201.66,33.78 201.66,35.78 194.79,42.65 194.79,44.02 187.59,51.21 187.59,58.85 187.81,59.07 187.81,61.11 189.65,62.95 189.65,63.71 189.21,64.15 188.07,64.15 187.81,64.41 187.32,64.41 186.8,63.89 186.3,63.89 186.12,64.07 186.09,64.07 185.74,64.43 185.4,64.43 185.35,64.43 184.77,65.01 v2(184.48,65.01)
  BOTTOM w0.102: U31.36 317.52,202.77 v2(317.71,202.96)
PLTRST_MMI#: length 212.4
  TOP w0.102: v2(247.25,46.37) 247.38,46.24 U38.15 ; RH110.1 183.81,66.26 v2(184.43,65.65)
  IN1 w0.102: v2(242.32,28.85) 241.96,29.22 241.96,31.04 242.86,31.94 242.86,40.13 242.67,40.32 242.67,43.94 243.19,44.46 243.95,44.46 244.24,44.75 244.25,44.75 244.48,44.99 244.48,45 244.81,45.33 244.81,45.96 245.7,46.85 246.88,46.85 247.25,46.48 v2(247.25,46.37)
  IN2 w0.127: v2(267.58,31.8) 267.51,31.8 267.19,31.48 266.2,31.48 265.66,32.02 261.79,32.02 259.09,29.32 256.23,29.32 255.46,30.1 249.84,30.1 247.48,27.74 244.17,27.74 243.55,27.11 242.76,27.11 242.32,27.55 v2(242.32,28.85)
  IN4 w0.102: v2(267.58,31.8) 266.91,31.13 266.91,29.92 266.71,29.72 266.71,28.66 265.58,27.53 265.03,27.53 255.91,18.41 232.35,18.41 230.95,19.81 222.86,19.81 221.67,18.63 221.55,18.74 221.38,18.74 221.26,18.63 221.26,18.42 221.16,18.32 220.96,18.32 220.86,18.42 220.86,18.63 220.74,18.74 220.57,18.74 220.45,18.63 220.45,18.42 220.35,18.32 220.15,18.32 220.05,18.42 220.05,18.63 219.93,18.74 219.76,18.74 219.64,18.63 219.64,18.42 219.54,18.32 219.33,18.32 219.23,18.42 219.23,18.63 219.11,18.74 218.95,18.74 218.83,18.63 218.83,18.42 218.72,18.32 218.52,18.32 218.42,18.42 218.42,18.63 218.3,18.74 218.13,18.74 218.01,18.63 218.01,18.42 217.91,18.32 217.71,18.32 217.61,18.42 217.61,18.63 217.49,18.74 217.32,18.74 217.2,18.63 217.2,18.42 217.1,18.32 216.9,18.32 216.79,18.42 216.79,18.63 216.67,18.74 216.51,18.74 216.39,18.63 216.39,18.44 216.26,18.32 216.05,18.32 215.92,18.44 215.92,18.67 215.84,18.74 214.97,18.74 199.7,34.01 199.7,34.32 200.11,34.72 200.11,34.98 199.95,35.14 199.8,35.14 199.26,34.6 199.12,34.6 198.98,34.75 198.98,34.89 199.52,35.43 199.52,35.57 199.37,35.72 199.23,35.72 198.69,35.18 198.55,35.18 198.4,35.32 198.4,35.47 198.94,36.01 198.94,36.15 198.8,36.29 198.65,36.29 198.11,35.75 197.97,35.75 197.83,35.9 197.83,36.04 198.37,36.58 198.37,36.72 198.22,36.87 198.08,36.87 197.54,36.33 197.4,36.33 197.25,36.47 197.25,36.62 197.79,37.16 197.79,37.3 197.65,37.44 197.5,37.44 196.96,36.9 196.82,36.9 196.68,37.05 196.68,37.19 197.22,37.73 197.22,37.87 197.07,38.02 196.93,38.02 196.39,37.48 196.24,37.48 196.1,37.62 196.1,37.77 196.64,38.31 196.64,38.45 196.5,38.59 196.35,38.59 195.83,38.07 195.66,38.07 195.54,38.19 195.54,38.35 196.07,38.88 196.07,39.02 195.92,39.17 195.78,39.17 195.24,38.63 195.09,38.63 194.95,38.77 194.95,38.92 195.77,39.73 195.77,39.95 195.5,40.21 195.36,40.21 194.53,39.38 194.35,39.38 194.21,39.51 194.21,39.69 195.05,40.52 195.05,40.67 194.9,40.81 194.76,40.81 193.92,39.97 193.75,39.97 193.63,40.09 193.63,40.26 194.47,41.1 194.47,41.24 194.33,41.39 194.18,41.39 193.77,40.97 193.63,40.97 193.48,41.12 193.48,41.26 193.9,41.67 193.9,41.82 193.42,42.3 193.42,43.6 186.35,50.66 186.35,51.52 186.25,51.62 185.61,51.62 185.5,51.72 185.5,51.92 185.61,52.03 186.25,52.03 186.35,52.13 186.35,52.33 186.25,52.43 185.61,52.43 185.5,52.53 185.5,52.74 185.61,52.84 186.25,52.84 186.35,52.94 186.35,53.14 186.25,53.24 185.61,53.24 185.5,53.35 185.5,53.55 185.61,53.65 186.25,53.65 186.35,53.75 186.35,53.96 186.25,54.06 185.61,54.06 185.5,54.16 185.5,54.36 185.61,54.46 186.25,54.46 186.35,54.57 186.35,54.77 186.25,54.87 185.61,54.87 185.5,54.97 185.5,55.17 185.61,55.28 186.25,55.28 186.35,55.38 186.35,55.58 186.25,55.68 185.61,55.68 185.5,55.78 185.5,55.99 185.61,56.09 186.25,56.09 186.35,56.19 186.35,56.39 186.25,56.5 185.61,56.5 185.5,56.6 185.5,56.8 185.61,56.9 186.25,56.9 186.35,57 186.35,57.21 186.25,57.31 185.61,57.31 185.5,57.41 185.5,57.61 185.61,57.71 186.25,57.71 186.35,57.82 186.35,59.42 186.59,59.66 186.59,63 186.19,63.4 186.19,63.43 185.95,63.66 185.92,63.66 185.57,64.02 185.18,64.02 184.64,64.57 184.15,64.57 183.97,64.74 183.97,65.19 v2(184.43,65.65)
