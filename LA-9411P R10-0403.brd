# Allegro board LA-9411P R10-0403.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
LAN_TX1-: length 18.8
  TOP w0.089: R47.1 300.98,195.38 300.71,195.38 300.64,195.31 300.64,193.97 v2(300.88,193.72)
  IN1 w0.089: v2(300.88,193.72) 300.88,192.89 301.43,192.34 304.97,192.34 305.9,193.27 305.9,195.47 307.29,196.86 308.81,196.86 309.61,197.66 310.68,198.73 311.22,198.73 v2(311.39,198.89)
  BOTTOM w0.089: v2(311.39,198.89) 311.46,198.82 U31.18
LAN_TX1-R: length 4.6
  TOP w0.089: R47.2 301.1,196.18 300.78,196.49 300.78,197.53 301.51,198.25 v4(301.51,198.75) 301.51,199.53 301.62,199.65 U32.7
LAN_TX2+: length 15
  TOP w0.089: R48.1 303.29,195.1 303.29,194.54 303.35,194.49 v2(303.35,193.72)
  IN1 w0.089: v2(310.88,199.53) 310.68,199.73 309.92,199.73 309.43,199.25 309.18,199 307.88,199 304.78,195.9 304.78,193.61 304.45,193.28 303.81,193.28 303.36,193.72 v2(303.35,193.72)
  BOTTOM w0.089: U31.20 311.74,199.62 311.67,199.69 311.04,199.69 v2(310.88,199.53)
LAN_TX2+R: length 4.7
  TOP w0.089: U32.9 302.62,199.79 302.71,199.7 302.71,197.72 v4(302.91,197.53) 302.96,197.48 303.44,197 303.47,196.96 303.47,196.52 R48.2
LAN_TX2-: length 15
  TOP w0.089: v2(303.93,193.72) 303.64,194.01 303.64,194.61 303.58,194.67 303.58,195.38 303.64,195.44 303.84,195.44 R49.1
  IN1 w0.089: v2(303.93,193.72) 303.93,193.72 304.12,193.54 304.35,193.54 304.53,193.72 304.53,196 307.78,199.25 309.08,199.25 309.18,199.35 309.81,199.99 310.7,199.99 v2(310.88,200.16)
  BOTTOM w0.089: v2(310.88,200.16) 311.06,199.99 311.68,199.99 311.71,200.02 U31.21
LAN_TX2-R: length 4.6
  TOP w0.089: R49.2 303.77,196.43 303.77,197.08 303.44,197.41 303.44,197.41 303.08,197.77 303,197.84 v4(303,199.15) 303,199.68 303.12,199.8 U32.10
LAN_TX3+: length 14.9
  TOP w0.089: R50.1 306.7,195.26 306.87,195.09 306.87,194.63 307.28,194.21 307.28,194.11 v2(306.99,193.81)
  IN1 w0.089: v2(311.39,200.8) 311.58,200.99 311.9,200.99 312.2,200.69 312.2,197.23 310.75,195.78 307.72,195.78 307.25,195.31 307.25,194.07 v2(306.99,193.81)
  BOTTOM w0.089: v2(311.39,200.8) 311.41,200.82 U31.23
LAN_TX3+R: length 6.4
  TOP w0.089: U32.11 303.62,199.8 303.72,199.71 303.72,198.96 303.72,198.62 v4(304.64,197.7) 305.12,197.22 305.46,197.22 306.43,197.22 306.52,197.13 306.78,196.87 306.78,196.52 R50.2
LAN_TX3-: length 14.9
  TOP w0.089: v2(307.58,193.81) 307.58,194.33 307.16,194.75 307.16,195.1 R53.1
  IN1 w0.089: v2(307.58,193.81) 307.5,193.89 307.5,195.2 307.83,195.53 310.85,195.53 312.45,197.13 312.45,200.79 312,201.24 311.58,201.24 v2(311.39,201.43)
  BOTTOM w0.089: v2(311.39,201.43) 311.6,201.22 U31.24
LAN_TX3-R: length 6.4
  TOP w0.089: R53.2 307.07,196.43 307.07,196.99 v4(306.73,197.33) 306.55,197.51 305.34,197.51 305.24,197.51 305.05,197.7 305.05,197.7 304.96,197.79 304.08,198.68 304.01,198.74 304.01,198.84 304.01,198.84 304.01,199.71 304.12,199.82 U32.12
LANCLK_REQ#: length 361.1
  TOP w0.102: RH125.2 v2(194.72,65.43) 194.43,65.43 RH20.1
  IN1 w0.102: v2(194.72,65.43) 196.46,63.69 197.22,63.69 197.67,64.13 198.41,64.13 v2(198.51,64.03)
  IN4 w0.102: v2(331.54,196.43) 332.15,196.43 332.52,196.06 332.52,184.04 330.01,181.52 330.01,174.87 329.78,174.64 329.78,171.54 329.08,170.84 326.29,170.84 323.92,173.2 321.42,173.2 320.77,172.55 318.35,172.55 318.21,172.41 314.62,172.41 313.86,171.65 312.12,171.65 311.14,170.68 310.73,170.68 309.95,169.9 307.06,169.9 306.29,170.66 305.07,170.66 304.06,171.68 298.21,171.68 297.8,172.09 296.09,172.09 293.34,174.84 278.47,174.84 278.45,174.82 276.94,174.82 275.71,173.58 274.37,173.58 270.71,169.91 269.79,169.91 269.18,169.3 269.18,167.13 269.55,166.76 269.55,149.87 269.18,149.5 269.18,145.82 268.52,145.15 268.52,139.4 268.93,138.99 268.93,130.3 269.18,130.04 269.18,128.83 270.12,127.89 270.12,126.69 269.18,125.75 269.18,119.14 270.12,118.2 270.12,113.42 269.62,112.91 269.62,102.62 268.94,101.94 268.94,101.26 268.35,100.66 268.35,100.06 267.69,99.4 267.69,98.82 265.41,96.55 265.41,95.64 264.92,95.15 264.92,95.09 264.68,94.85 264.16,94.85 261.13,91.82 261.13,78.05 260.84,77.76 260.84,66.71 261.6,65.95 261.6,59.89 261.22,59.51 261.22,58.53 261.54,58.2 261.76,58.2 262.52,57.45 262.52,48.22 262.38,48.08 262.38,47.75 261.59,46.96 261.59,45.1 261.07,44.58 261.07,36.36 255.95,31.24 255.95,28.53 252.43,25.01 251.03,25.01 250.15,24.14 241.66,24.14 240.89,23.37 234.36,23.37 231.17,26.56 217.08,26.56 213.34,30.29 213.34,32.91 207.87,38.38 207.87,39.62 203.18,44.31 202.76,44.31 200.83,46.24 199.08,46.24 193.65,51.68 193.65,53.84 193.2,54.28 193.2,55.99 192.88,56.31 192.88,56.84 193.04,57 194.17,57 195.36,58.19 195.63,58.19 197.79,60.36 197.79,62.04 198.51,62.76 v2(198.51,64.03)
  BOTTOM w0.089: 200.43,66.74 200.33,66.64 200,66.64 199.69,66.33
  BOTTOM w0.102: 199.69,66.33 198.77,65.41 198.77,64.94 198.51,64.68 v2(198.51,64.03) ; v2(331.54,196.43) 331.08,196.89 v1(330.23,196.89) 330.01,197.12 327.26,197.12 327.03,196.89 326.2,196.89 323.62,194.31 322.32,194.31 321.62,195.01 R1187.1
LANCLK_REQ#_R: length 3.5
  BOTTOM w0.102: R1187.2 v1(319.68,195.21) 319.51,195.21 318.88,195.85 318.88,196.61 318.67,196.82 U31.48
LANWAKE#: length 336.8
  TOP w0.102: v2(275.92,98.04) 275.74,98.04 275.2,97.51 275.2,95.66 272.18,92.63 270.2,92.63 270.04,92.8 270.04,93.64 269.5,94.17 268.92,94.17 268.73,93.98 266.45,93.98 265.96,93.48 255.58,93.48 254.78,94.28 254.78,96.82 255.15,97.2 255.83,97.2 v2(255.85,97.18) ; v2(221.28,55.89) 221.28,54.43 225.18,50.53 v2(225.19,50.53) ; U51.B27 286.97,117.34 v2(286.67,117.04)
  IN2 w0.127: v2(225.19,50.53) 225.19,50.71 225.78,51.3 238.6,51.3 241.49,48.4 241.81,48.4 242.59,49.17 245,49.17 246.05,48.12 252.67,48.12 253.53,48.99 256.15,48.99 257.64,47.5 258.81,47.5 260.63,49.31 262.42,49.31 264.08,47.65 268.31,47.65 268.52,47.87 v2(273.21,47.87) ; v2(305.93,106.89) 306.89,105.92 306.89,104.74 306.21,104.05 304.29,104.05 303.63,104.71 296.84,104.71 296.18,104.05 293.34,104.05 293.14,104.25 290.18,104.25 289.26,105.17 288.2,105.17 287.48,104.45 287.47,104.45 286.79,103.77 285.81,103.77 283.93,101.89 280.48,101.89 280.17,101.59 280.17,101.02 279.38,100.23 277.8,100.23 276.55,98.98 276.55,98.68 v2(275.92,98.04)
  IN3 w0.127: v2(322.36,190.61) 322.36,190.23 322.81,189.79 322.81,188.89 320.4,186.49 320.4,183.81 321.5,182.71 321.5,181.07 320.92,180.49 320.92,177.29 324.2,174.02 324.2,169.67 323.81,169.28 323.81,168.34 324.14,168.01 325.19,168.01 327.86,165.34 327.86,155.88 327.11,155.13 327.11,139.46 325.27,137.62 325.27,134.62 324.72,134.07 320.62,134.07 319.01,132.46 319.01,130.34 316.37,127.7 314.27,127.7 308.3,121.73 308.3,108.33 306.86,106.89 v2(305.93,106.89)
  BOTTOM w0.102: v2(255.85,97.18) 256.43,96.6 256.43,81.53 256.37,81.47 256.37,75.31 258.69,72.99 258.69,63.77 259.18,63.28 259.18,59.04 258.92,58.78 258.92,55.97 259.94,54.95 259.94,47.58 260.09,47.43 260.09,43.94 262.68,41.35 271.04,41.35 v1(273.64,43.95) 273.64,47.43 v2(273.21,47.87) ; v2(221.28,55.89) 221.28,55.59 RH196.2 ; v2(286.67,117.04) 287.09,116.62 287.54,116.62 289.2,114.96 291.52,114.96 291.67,114.82 294.39,114.82 295.15,114.06 295.15,113.67 298,110.82 298,109.85 300.97,106.89 v2(305.93,106.89) ; v2(322.36,190.61) 322.21,190.46 R559.1 321.13,189.97 320.04,189.97 319.77,189.7 R566.1
LANWAKE#_R: length 8.5
  BOTTOM w0.102: U31.2 317.12,194.68 317.71,194.09 320.2,194.09 320.61,193.69 v1(320.61,193.34) 320.61,192.06 320.71,191.96 R558.2 R559.2
LAT_ON_SW#: length 11
  TOP w0.102: v2(284.19,104.53) 284.91,103.82 R870.2 ; v2(288.75,110.1) 288.75,109.89 288.97,109.68 U51.B63
  IN4 w0.102: v2(284.19,104.53) 284.19,104.92 285.01,105.74 286.36,105.74 287.63,107.01 287.63,108.27 288.93,109.58 288.93,110.01 288.84,110.1 v2(288.75,110.1)
  BOTTOM w0.102: v2(288.75,110.1) v1(288.75,109.47)
LCD_CBL_DET#: length 166.7
  TOP w0.102: v2(177.68,168.76) v1(177.68,169.28) ; 205.42,47.51 205.08,47.86 v2(205.08,48.17)
  IN2 w0.089: v2(210.54,65.87) 211.14,65.87 211.73,65.28 211.73,62.57
  IN2 w0.127: v2(205.08,48.17) 205.7,48.17 207.5,49.97 207.5,50.47 209.54,52.51 210.7,52.51 211.49,53.3 211.49,56.76 212.99,58.26 212.99,61.31 211.73,62.57
  IN3 w0.089: v2(210.54,65.87) 210.01,65.87 209.47,65.33 209.12,65.33 208.66,65.8 208.39,65.8 207.81,66.38 207.81,66.77 205.88,68.7 205.88,69.54 206.08,69.75 206.08,70.3 204.31,72.07 203.8,72.07 203.36,72.51 203.36,72.57 201.67,74.26 201.42,74.26 199.84,75.84 199.84,75.87 199.65,76.06 199.65,77.48 198.62,78.51
  IN3 w0.127: 198.62,78.51 193.43,83.71 183.73,83.71 183.52,83.71 175.62,91.6 175.62,91.64 175.62,91.64 175.62,92.28 175.62,92.28 175.62,98.91 173.38,101.16 173.38,112.9 173.05,113.23 173.05,127.72 170.26,130.5 167.8,130.5 167.34,130.96 167.34,137.43 169.67,139.75 169.67,150.15 170.33,150.81 170.33,154.04 169.24,155.13 169.24,157.68 170.05,158.5 170.05,161.14 171.29,162.38 171.29,166.7 172.75,168.16 172.75,168.49 173.29,169.02 174.76,169.02 175.37,168.41 177.34,168.41 v2(177.68,168.76)
  BOTTOM w0.089: v2(210.54,65.87) 210.74,66.07 211.08,66.07
  BOTTOM w0.102: JLVDS1.40 176.76,167.47 177.68,168.39 v2(177.68,168.76)
LCD_EDID_CLK: length 32.9
  TOP w0.089: R113.1 174.02,142.82 174.02,142.18 v2(173.93,142.09) 174.22,141.8 U27.46
  IN1 w0.089: v2(177.2,165.02) 177.03,164.86 173.79,164.86 173.27,164.34 173.27,160.64 173.77,160.14 173.77,148.4 174.53,147.63 174.53,146.45 173.49,145.41 173.49,143.41 174.1,142.8 174.1,142.25 v2(173.93,142.09)
  BOTTOM w0.089: v2(177.2,165.02) 177.07,164.89 176.58,164.89 176.5,164.97 JLVDS1.35
  BOTTOM w0.102: R160.2 177.81,164.93 177.29,164.93 v2(177.2,165.02)
LCD_EDID_DATA: length 32.4
  TOP w0.089: U27.45 174.62,142.02 v2(174.57,142.07) 174.37,142.28 174.37,143.01 R112.1
  IN1 w0.089: v2(177.2,164.44) 177.04,164.6 173.9,164.6 173.53,164.24 173.53,160.74 174.02,160.25 174.02,148.5 174.79,147.74 174.79,146.34 173.74,145.3 173.74,143.51 174.35,142.9 174.35,142.29 v2(174.57,142.07)
  BOTTOM w0.089: v2(177.2,164.44) 177.04,164.6 176.61,164.6 176.49,164.47 JLVDS1.34
  BOTTOM w0.102: v2(177.2,164.44) 177.39,164.63 177.96,164.63 R159.2
LCD_ENVDD_CVT: length 40.9
  TOP w0.102: U27.20 176.22,134.57 176.25,134.54 176.25,134.11 176.89,133.46 176.89,131.52 v2(176.45,131.08) ; v2(172.96,152.13) 172.68,152.13 171.93,152.88 v1(171.93,153.43) U55.1 171.93,155.8 172.42,156.3 172.42,158.13 172.66,158.37 173.03,158.37 173.53,158.86 R115.1
  IN4 w0.102: v2(176.45,131.08) 176.45,131.98 178.93,134.45 178.93,144.17 177.55,145.54 174.34,145.54 172.86,147.03 172.86,150.15 173.34,150.63 173.34,151.75 v2(172.96,152.13)
LCD_SMBCLK: length 10.7
  TOP w0.102: v2(290.73,111.64) 291.16,112.07 291.55,112.07 291.72,111.91 U51.B5 ; v2(298.72,112.66) R418.2
  IN3 w0.127: v2(298.72,112.66) 295.21,112.66 294.6,112.06 291.15,112.06 v2(290.73,111.64)
LCD_SMBDAT: length 2.7
  TOP w0.102: U51.A4 293.34,111.66 v2(293.66,111.34) 294.09,111.77 294.12,111.77 294.71,112.36 294.71,112.45 R420.2
LCD_TST: length 236.3
  TOP w0.102: v1(259.72,56.65) 260.26,56.11 R767.2 261.65,55.57 v2(261.76,55.47) 261.87,55.47 262.46,54.89 U46.A36
  IN3 w0.127: v2(174.2,172.55) 174.89,172.55 175.07,172.73 176.93,172.73 177.74,173.55 179.1,173.55 179.69,172.96 182.15,172.96 182.22,172.9 183.2,172.9 183.29,172.81 184,172.1 187.03,172.1 188.5,173.57 196.03,173.57 196.67,174.21 199.75,174.21 200.09,173.86 218.13,173.86 220.39,176.12 221.51,177.24 224.85,177.24 225.06,177.24 225.27,177.04 225.66,177.04 232.89,177.04 232.9,177.04 235.33,177.04 237.94,179.65 245.99,179.65 246.64,179.01 250.59,179.01 251.21,178.38 258.45,178.38 261.53,175.3 261.53,174.55 262.54,173.54 262.54,150.57 263.47,149.64 263.47,145.55 265.67,143.36 265.67,141.85 266.87,140.64 266.87,138.99 267.41,138.46 267.41,128.64 267.17,128.4 267.17,125.22 267.77,124.62 267.77,105.07 267.08,104.38 267.08,93.05 266.96,92.94 266.96,75.85 266.03,74.92 266.03,72.94 265.36,72.26 265.36,66.07 261.9,62.61 261.9,59.88 262.68,59.09 262.68,58.49 262.87,58.3 262.87,56.22 262.13,55.47 v2(261.76,55.47)
  BOTTOM w0.102: JLVDS1.36 174.57,165.47 173.01,167.03 173.01,168.67 173.36,169.02 175.4,169.02 175.6,169.23 175.6,170.78 175.45,170.93 174.71,170.93 174.38,171.26 174.38,172.38 v2(174.2,172.55)
LCD_VCC_TEST_EN: length 237.1
  TOP w0.102: v2(261.97,52.89) U46.A40 ; v2(176.44,171.39) 177.33,170.5 177.33,170.43 178.58,169.18 v1(178.58,167.27) 178.58,165.91 178.16,165.49 176.51,165.49 176.39,165.37 176.39,160.93 175.61,160.16 D73.2
  IN3 w0.127: v2(176.44,171.39) 176.61,171.39 178.23,173 178.87,173 179.13,172.74 179.13,172.38 178.49,171.74 178.49,171.12 179.1,170.51 180.41,170.51 181.07,171.17 184.81,171.17 185.22,171.58 192.39,171.58 192.97,172.16 194.92,172.16 195.2,172.44 200.58,172.44 200.97,172.83 204.02,172.83 204.11,172.92 214.04,172.92 214.22,173.1 218.45,173.1 221.15,175.81 221.8,176.45 224.35,176.45 224.56,176.45 224.77,176.45 224.95,176.28 225.34,176.28 232.58,176.28 235.83,176.28 236.85,177.29 246.6,177.29 246.83,177.52 253.03,177.52 254.43,176.12 258.6,176.12 261.5,173.22 261.5,171.37 261.78,171.09 261.78,150.25 262.71,149.33 262.71,145.24 264.9,143.04 264.9,141.53 266.11,140.32 266.11,138.68 266.64,138.15 266.64,129.95 265.65,128.96 265.65,121.83 266.33,121.15 266.33,117.94 266.85,117.42 266.85,115.66 266.38,115.2 266.38,110.31 266.82,109.88 266.82,105.41 266.29,104.88 266.29,94.36 266.29,93.55 266.17,93.44 266.17,76.2 264.51,74.53 264.51,66.3 261.14,62.93 261.14,58.29 260.75,57.9 260.75,53.83 261.31,53.26 261.59,53.26 v2(261.97,52.89)
LED_10_GRN#: length 19.1
  TOP w0.102: U32.41 297.17,201.82 297.02,201.68 296.32,201.68 296.15,201.85 v1(296.15,202.45) 296.15,203.71 v2(298.04,205.6)
  IN4 w0.102: v2(298.04,205.6) 299.64,204 306.51,204 307.25,204.74 307.25,205.17 307.12,205.3 v2(307.12,205.93)
  BOTTOM w0.102: v2(307.12,205.93) 307.8,206.61 Q326.3
LED_10_GRN#_Q: length 5.8
  BOTTOM w0.102: Q326.1 309.7,206.59 v1(310.93,207.83) 311.11,208 311.11,209.21 R1653.1
LED_100_ORG#: length 15.2
  TOP w0.102: v2(315.15,206.26) 315.15,206.34 v1(314.79,206.69) 314.66,206.82 312.61,206.82 312.44,206.66 Q325.4 ; U32.18 v2(309.1,201.32)
  IN4 w0.102: v2(315.15,206.26) 315.15,203.44 314.38,202.68 310.46,202.68 v2(309.1,201.32)
LED_100_ORG#_Q: length 15.6
  TOP w0.102: Q325.3 312.44,204.6 312.83,204.99 314.61,204.99 315.39,205.77 317.9,205.77 318.5,206.36 318.5,208.47 v1(317.41,209.56) 315.78,211.19 v2(314.08,211.19)
  BOTTOM w0.102: R1167.1 313.52,210.63 v2(314.08,211.19)
LED_SATA_DIAG_OUT#: length 160.8
  TOP w0.102: v2(274.96,52.84) 274.93,52.84 274.38,53.39 U46.A10 ; D62.1 330.78,162.06 329.99,162.06 329.66,161.73 v2(329.66,161.54)
  BOTTOM w0.102: v2(329.66,161.54) 329.66,161.76 329.95,162.05 332.32,162.05 332.77,161.59 332.77,154.71 v1(331.92,153.85) 327.74,149.68 327.74,142.98 326.3,141.53 326.3,121.75 325.41,120.87 319.11,120.87 315.82,117.58 315.82,105.66 308.79,98.63 288.24,98.63 287.13,97.53 284.31,97.53 279.8,93.01 279.8,67.9 282.07,65.63 282.07,57.68 276.79,52.4 275.4,52.4 v2(274.96,52.84)
LED_WWAN_OUT#: length 7.1
  BOTTOM w0.102: JMINI1.42 345.75,201.77 345.45,201.47 344.65,201.47 343.76,200.58 v1(343.76,199.76) 344.04,199.48 R719.1 345.6,199.48 Q77.3
LG_3V: length 16
  TOP w0.102: v1(148.83,9.41) 148.89,9.35 v4(148.89,8.65)
  IN1 w1.016: 148.19,9.54 145.28,9.54 142.72,6.97 141.31,6.97 139.56,5.22 134.73,5.22
  vias: v4(133.79,5.6) v4(133.79,4.97) v4(149.4,8.27)
LG_5V: length 5.7
  TOP w0.102: v4(152.51,8.9) v1(152.51,9.79)
  IN1 w1.016: 153.27,9.16 156.45,9.16 157.59,8.01
  vias: v4(152,8.46) v4(158.61,8.79) v4(158.61,8.15)
LG_+1.05VSP: length 20
  IN1 w1.016: 241.03,12.2 240.01,13.22 231,13.22 230.11,12.33 230.11,6.11 229.22,5.22
  BOTTOM w0.102: v4(240.71,9.92) v1(241.52,9.92)
  vias: v4(227.69,4.71) v4(228.33,4.71) v4(240.71,10.55)
LGATE1: length 23.2
  TOP w0.102: v4(124.3,153.98) 124.85,153.98 v1(125.13,154.27)
  IN4 w1.016: 146.03,146.7 142.96,146.7 ; 125.2,153.68 127.11,153.68 130.03,150.76 139.81,150.76 141.21,149.36 141.21,147.97
  vias: v4(123.68,154.25) v4(141.59,147.08) v4(141.59,146.32) v4(146.15,148.45) v4(146.15,147.82)
LGATE1_VGA: length 12.9
  TOP w0.102: v4(306.54,161.51) v1(307.16,161.51)
  IN1 w1.016: 299.96,154.83 299.96,156.86 304.53,161.43 304.53,161.56
  IN4 w1.016: 299.83,149.11 299.83,152.79
  vias: v4(299.7,153.68) v4(299.7,148.09) v4(300.34,153.68) v4(300.34,148.09) v4(305.85,161.51)
LGATE2: length 10.5
  TOP w0.102: v1(123.49,151.83) 123.11,152.21 v4(123.11,152.35)
  IN1 w1.016: 132.82,146.7 129.27,146.7
  IN4 w1.016: 124.19,151.52 124.82,150.89 126.86,150.89 128.13,149.62 128.13,148.09
  vias: v4(122.73,152.86) v4(128.38,146.95) v4(128.38,146.32) v4(133.71,147.08) v4(133.71,146.32)
LGATE2_VGA: length 6.6
  TOP w0.102: v4(305.6,163.08) 305.6,163.16 v1(305.09,163.66)
  IN1 w0.762: 299.19,163.72 302.88,163.72 303.39,163.21 304.78,163.21
  vias: v2(298.93,164.85) v2(299.02,165.48) v4(299.58,159.65) v4(300.21,159.65) v4(306.43,163.02)
LGATE3: length 9.4
  TOP w0.102: v4(159.05,155.78) v1(159.05,156.72)
  IN2 w1.016: 154.54,147.97 154.54,149.11 158.25,152.82 158.25,154.46 158.56,154.76
  vias: v4(154.67,146.95) v4(154.67,146.32) v4(158.39,155.8) v4(159.27,147.83) v4(159.3,148.5)
LID_CL#: length 614.3
  TOP w0.102: v2(62.59,207.48) 37.52,207.48 31.11,213.89 22.46,213.89 v2(22.32,213.75) ; U1.3 v2(8.23,218.07) ; R807.1 264.32,40.29 264.32,39.69 v2(264.96,39.05) v1(265.62,39.05)
  IN1 w0.102: v2(62.59,207.48) 68.91,207.48 71.29,205.09 71.29,193.29 73.62,190.97 88.81,190.97 89.26,191.43 98.83,191.43 99.65,190.6 103.96,190.6 105.47,189.09 105.47,188.4 107.26,186.61 113.93,186.61 114.51,187.2 119.96,187.2 120.53,187.77 121.84,187.77 122.73,186.88 129.92,186.88 131.24,188.2 134.9,188.2 138.2,191.5 167.58,191.5 167.9,191.19 167.9,190.83 168.23,190.5 177.12,190.5 177.47,190.86 178.68,190.86 179.64,191.81 209.66,191.81 210.17,191.3 233.68,191.3 234.4,192.02 241.9,192.02 243.32,190.6 244.75,190.6 246.17,192.02 273.6,192.02 274.13,191.5 290.33,191.5 290.71,191.88 293.29,191.88 294.53,193.13 294.53,205.85 297.5,208.81 306.26,208.81 307.85,210.4 315.11,210.4 316.68,211.98 v2(318.93,211.98)
  IN2 w0.127: v2(8.23,218.07) 9.64,218.07 14.97,212.74 20.56,212.74 21.57,213.75 v2(22.32,213.75) ; v2(274.48,40.13) 272.4,40.13 271.64,39.37 271.64,39.34 271.28,38.98 265.03,38.98 v2(264.96,39.05)
  IN3 w0.127: v2(274.48,40.13) 274.48,40.32 284.27,50.11 284.27,61.93 278.75,67.46 278.75,93.99 282.48,97.73 285.71,97.73 287.24,99.25 287.87,99.25 290.56,101.94 299.88,101.94 302.68,104.74 306.77,104.74 313.04,111 313.04,114.95 319.15,121.06 324.51,121.06 326.41,122.96 326.41,137.14 327.62,138.35 327.62,154.75 328.18,155.31 330.07,157.2 330.07,158.18 v2(329.43,158.81) ; v2(309.13,194.26) 312.17,194.26 313.87,192.56 313.87,189.58 314.83,188.62 314.83,185.44 313.83,184.43 313.83,177.61 311.89,175.68 311.89,174.47 314.16,172.21 315.52,172.21 316.42,171.31 316.42,170.87 316.8,170.49 316.8,169.13 316.71,169.04 316.71,166.32 316.85,166.18 316.85,165.93 317.52,165.26 317.52,161.14 317.85,160.81 317.85,155.75 318.3,155.31 v2(318.32,155.31)
  IN4 w0.102: v2(329.43,158.81) 326.92,156.3 325.1,156.3 323.27,154.47 319.16,154.47 v2(318.32,155.31) ; v2(318.93,211.98) 318.07,211.98 317.34,211.25 317.34,210.23 316.86,209.75 316.86,204.04 315.04,202.22 310.68,202.22 310.33,201.88 310.33,200.02 309.49,199.19 309.49,194.63 v2(309.13,194.26)
  BOTTOM w0.102: U58.2 v2(318.93,211.98)
LID_CL_SIO#: length 11.9
  TOP w0.102: v2(265.45,42.32) 265.67,42.1 C716.1 265.63,41.53 R807.2 R805.2 263.63,42.37 T141.1 ; v2(265.22,48.73) 265.19,48.69 U46.B54
  IN1 w0.102: v2(265.45,42.32) 265.35,42.32 265.06,42.61 265.06,44.58 265.78,45.3 265.78,47.17 265.22,47.73 v2(265.22,48.73)
LOM_ACTLED_YEL#: length 18.3
  TOP w0.102: v2(306.15,198.67) 305.62,199.2 U32.15
  IN4 w0.102: v2(306.15,198.67) 306.15,201.39 308.61,203.85 309.05,203.85 310.96,205.75 312.76,205.75 313.34,205.17 313.34,204.28 v2(312.66,203.59)
  BOTTOM w0.102: U31.26 313.52,202.73 v2(312.66,203.59) 312.39,203.59 v1(312.14,203.34)
LOM_SPD10LED_GRN#: length 23.1
  TOP w0.102: v2(296.88,201.19) 297.01,201.32 U32.42
  IN1 w0.102: v2(308.49,204.91) 307.47,204.91 306.21,203.66 298.63,203.66 297.82,202.85 297.82,202.13 v2(296.88,201.19)
  BOTTOM w0.102: U31.25 313.12,202.49 312.82,202.79 312.12,202.79 311.77,203.15 U15.2 311.77,204.91 311.62,205.07 308.64,205.07 v2(308.49,204.91) 308.49,204.08 v1(308.47,204.05)
LOM_SPD100LED_ORG#: length 16.9
  TOP w0.102: U32.16 306.12,199.58 v2(306.81,198.89)
  IN4 w0.102: v2(312.44,205.22) 312.19,204.97 310.55,204.97 309.18,203.59 308.68,203.59 306.38,201.3 306.38,199.32 v2(306.81,198.89)
  BOTTOM w0.102: v2(312.44,205.22) 312.42,205.19 U15.1 312.42,204.14 312.53,204.03 312.87,204.03 313.92,202.97 U31.27 ; v1(306.13,199.26) 306.35,199.26 306.72,198.89 v2(306.81,198.89)
LOOPBACK: length 5.3
  TOP w0.102: R1684.1 323.12,136.94 323.12,135.12 322.74,134.73 R560.2 322.66,133.97 v1(322.82,133.82) 322.61,133.62 U7.13
LPC_LAD0: length 265
  TOP w0.102: v2(299.45,132.69) U39.26 ; v2(284.04,121.31) 284.04,120.35 284.72,119.68 U51.A30 ; U46.A27 v2(266.94,59.27) ; v1(257.11,58.76) 257.06,58.71 v2(256.24,58.71)
  IN1 w0.102: v2(284.04,121.31) 284.04,121.7 284.82,122.48 284.82,124.33 286.2,125.71 286.2,127.47 286.09,127.59 286.09,128.14 287.29,129.34 v2(287.4,129.34)
  IN2 w0.127: v2(256.24,58.71) 256.6,58.71 256.73,58.58 260.6,58.58 261.07,59.05 262.36,59.05 262.94,58.48 264.6,58.48 264.9,58.79 264.9,59.59 265.24,59.92 266.29,59.92 v2(266.94,59.27) 266.94,59.13 267.93,58.14 270.22,58.14 270.88,58.8 270.88,59.23 271.83,60.17 276.02,60.17 276.64,59.55 v2(276.64,59.41) ; v2(300.12,178.02) 300.53,177.61 314.27,177.61 316.45,175.42 v2(316.45,175.18)
  IN3 w0.127: v2(287.4,129.34) 287.75,129.69 291.77,129.69 293.43,131.36 298.22,131.36 299.45,132.59 v2(299.45,132.69) 299.45,132.8 299.68,133.02 304.54,133.02 309.09,137.58 312.36,137.58 316.22,141.44 316.22,142.43 320.37,146.57 320.37,152.76 321.2,153.6 321.2,161.54 320.87,161.87 320.87,167.16 319.82,168.22 319.82,172.55 317.95,174.41 317.95,175.2 317.49,175.67 316.94,175.67 v2(316.45,175.18)
  IN4 w0.102: v2(256.24,58.71) 256.22,58.71 254.99,57.48 254.99,53.07 255.18,52.88 255.18,48.42 254.34,47.59 253.63,47.59 253.47,47.74 253.15,47.74 253.15,47.74 252.77,47.74 246.21,47.74 246.08,47.87 244.31,49.64 243.78,49.64 243.54,49.88 243.54,50.02 242.15,51.41 241.68,51.88 241.49,51.88 240.19,53.18 230.89,53.18 230.76,53.31 229.74,54.33 229.55,54.33 229.55,54.33 222.75,54.33 222.3,54.79 222.3,55.98 216.3,61.98 215.53,61.98 v2(215.41,62.09) ; v2(284.04,121.31) 283.78,121.04 283.46,121.04 282.25,119.84 282.25,118.54 282.68,118.12 282.68,114.15 283.35,113.47 284.58,113.47 284.8,113.25 284.8,112.72 284.55,112.47 283.45,112.47 280.96,109.98 280.54,109.98 277.27,106.72 277.27,105.97 276.41,105.11 276.41,99.34 277.02,98.74 277.02,95.46 274.51,92.95 274.51,92.68 274.09,92.27 274.09,75.47 274.81,74.75 274.81,65.16 276.46,63.51 276.46,61.66 276.13,61.33 276.13,59.98 276.64,59.47 v2(276.64,59.41)
  BOTTOM w0.089: 214.73,64.13 213.84,65.02 UH1.A20
  BOTTOM w0.102: 214.73,64.13 215.16,63.7 215.16,62.9 215.26,62.79 215.26,62.25 v2(215.41,62.09) ; v2(300.12,178.02) 300.26,177.88 JMINI3.16
LPC_LAD1: length 268
  TOP w0.102: v2(284.39,117.15) 284.74,117.5 284.74,117.99 284.47,118.26 U51.B32 ; v1(277.83,60.57) 277.83,59.91 v2(277.73,59.8) ; v2(297.5,132.54) U39.23 ; v2(267.86,59.47) 267.86,59.47 267.86,59.45 267.79,59.45 267.44,59.1 U46.A26
  IN1 w0.102: v2(297.5,132.54) 297.07,132.97 296.68,132.97 295.77,132.05 293.12,132.05 291.98,130.91 286.77,130.91 283.23,127.37 283.23,122.45 282.95,122.17 282.95,120.93 284.65,119.23 284.65,118.12 284.74,118.03 284.74,117.5 v2(284.39,117.15)
  IN2 w0.127: v2(315.87,175.18) 315.22,174.54 310.85,174.54 309.05,176.34 300.55,176.34 v2(299.46,175.25) ; v2(277.73,59.8) 277.1,59.8 276.47,60.43 271.72,60.43 270.63,59.33 270.63,58.91 270.11,58.39 268.45,58.39 268.31,58.53 268.31,59.06 267.9,59.47 v2(267.86,59.47) 267.85,59.47 267.69,59.63 267.69,60.33 267.45,60.58 267.1,60.58 267.07,60.55 264.23,60.55 263.82,60.96 256.43,60.96 v2(256.2,60.73)
  IN3 w0.127: v2(297.5,132.54) 298.35,133.39 303.45,133.39 309.06,139 312.43,139 320.11,146.68 320.11,152.87 320.95,153.71 320.95,161.39 319.93,162.41 319.93,166.89 319.39,167.44 319.39,167.69 319.57,167.87 319.57,172.44 317.24,174.76 316.16,174.76 315.87,175.06 v2(315.87,175.18)
  IN4 w0.102: v2(214.85,62.53) 215.66,62.53 215.84,62.34 216.26,62.34 222.56,56.04 222.56,54.93 222.93,54.56 229.46,54.56 229.84,54.56 230.99,53.41 240.28,53.41 241.58,52.11 241.78,52.11 242.38,51.51 242.38,51.51 243.2,50.69 243.94,50.69 244.82,49.81 244.82,49.46 246.31,47.97 252.86,47.97 252.87,47.97 253.05,47.97 253.57,47.97 253.72,47.82 254.25,47.82 254.95,48.52 254.95,52.78 254.76,52.97 254.76,59.21 256.2,60.65 v2(256.2,60.73) ; v2(284.39,117.15) 284.4,117.15 284.74,116.8 284.74,115.66 286.25,114.15 286.25,112.16 285.73,111.65 285.38,111.65 284.65,110.92 284.65,109.88 283.65,108.88 282.61,108.88 281.95,108.22 279.76,108.22 278.01,106.46 278.01,105.74 277.1,104.82 277.1,99.64 277.71,99.03 277.71,95.16 275.49,92.94 275.49,65.48 277.15,63.82 277.15,61.33 277.5,60.97 277.52,60.97 277.73,60.76 v2(277.73,59.8)
  BOTTOM w0.089: UH1.C20 212.99,65.66 213.3,65.34 213.3,64.86 213.45,64.71 213.82,64.71 214.56,63.97 214.56,63.97
  BOTTOM w0.102: 214.56,63.97 214.93,63.61 214.93,62.6 v2(214.85,62.53) ; JMINI3.14 v2(299.46,175.25)
LPC_LAD2: length 283.2
  TOP w0.102: v2(268.58,55.87) 268.15,56.3 268.15,56.89 268.19,56.93 U46.B26 ; v2(256.24,57.54) 255.76,57.54 v1(255.63,57.67) ; U51.A31 284.22,119.83 283.61,120.43 282.86,120.43 282.58,120.15 281.92,120.15 281.72,120.36 281.06,120.36 280.58,120.84 280.58,121.23 280.5,121.31 280.5,123.76 281.03,124.29 281.03,125.02 282.56,126.54 282.7,126.54 284.14,127.99 284.49,127.99 284.77,128.27 286.3,128.27 v2(286.72,127.85) ; v2(295.55,132.52) U39.20
  IN2 w0.127: v2(298.66,178.05) 299.61,177.1 312.78,177.1 v2(314.69,175.2) ; v2(256.24,57.54) 259.64,57.54 260.92,56.26 263,56.26 263.86,55.4 264.39,55.4 264.43,55.36 264.44,55.36 264.65,55.15 264.65,54.83 264.93,54.55 266.31,54.55 266.47,54.7 267.69,54.7 268.58,55.6 v2(268.58,55.87) 268.61,55.87 269.03,55.45 270.67,55.45 271.23,56.01 272.46,56.01 272.57,55.9 273.84,55.9 274.24,56.31 274.47,56.31 275.24,57.07 276.49,57.07 v2(276.77,56.8)
  IN3 w0.127: v2(314.69,175.2) 314.69,174.82 315.25,174.26 317.03,174.26 319.06,172.23 319.06,168.1 318.85,167.9 318.85,167.2 319.43,166.63 319.43,162.12 320.44,161.11 320.44,153.92 319.6,153.08 319.6,146.89 312.22,139.5 308.72,139.5 303.16,133.95 296.98,133.95 v2(295.55,132.52) 295.55,131.97 295.19,131.61 293.05,131.61 291.42,129.98 287.19,129.98 286.83,129.62 286.83,127.99 286.72,127.89 v2(286.72,127.85)
  IN4 w0.102: v2(276.77,56.8) 277.06,57.09 277.06,59.56 276.81,59.82 276.62,59.82 276.36,60.08 276.36,61.23 276.69,61.56 276.69,63.6 275.03,65.26 275.03,74.85 274.33,75.55 274.33,92.17 274.79,92.64 274.79,92.91 277.25,95.36 277.25,98.84 276.64,99.45 276.64,105.01 277.51,105.88 277.51,106.62 280.53,109.65 280.95,109.65 282.92,111.62 284.41,111.62 284.41,111.62 284.44,111.62 284.68,111.86 284.68,112.17 285.12,112.61 285.12,113.62 284.99,113.75 284.99,114.04 284.55,114.48 283.43,114.48 283.02,114.89 283.02,118.33 282.6,118.74 282.6,119.68 283.32,120.41 283.89,120.41 285,121.51 285,125.23 286.72,126.96 v2(286.72,127.85) ; v2(256.24,57.54) 256.46,57.33 256.46,54.97 255.63,54.14 255.63,48.23 254.53,47.13 252.73,47.13 252.58,47.28 246.02,47.28 244.25,49.06 243.41,49.06 243.04,49.43 243.04,49.87 241.49,51.42 241.3,51.42 240,52.72 230.69,52.72 229.54,53.87 224.46,53.87 223.99,53.4 218.49,53.4 217.43,54.46 217.43,59.03 214.07,62.39 v2(214.07,63.41)
  BOTTOM w0.089: UH1.A18 213.13,64.35 213.6,64.35 214.04,63.91 214.04,63.45
  BOTTOM w0.102: JMINI3.12 v2(298.66,178.05) ; v2(214.07,63.41) 214.04,63.43 214.04,63.45
LPC_LAD3: length 270.6
  TOP w0.102: U46.B25 268.69,56.61 v2(268.58,56.51) ; v2(293.45,132.74) 293.6,132.59 U39.17 ; U51.B33 283.97,118.14 284.32,117.78 v2(284.34,117.78) ; v1(278.01,58.74) 277.67,58.74 v2(277.47,58.94)
  IN1 w0.102: v2(284.34,117.78) 283.78,118.34 282.99,118.34 282.52,118.81 282.52,119.01 280.89,120.63 280.89,123.62 282.13,124.85 282.13,128.19 285.81,131.88 291.21,131.88 292.63,133.3 293.09,133.3 293.45,132.94 v2(293.45,132.74)
  IN2 w0.127: v2(277.47,58.94) 276.88,58.36 271.56,58.36 270.55,57.34 269.42,57.34 v2(268.58,56.51) 268.16,56.08 268.16,55.64 267.95,55.44 264.73,55.44 264.55,55.61 264.54,55.61 264.5,55.65 263.97,55.65 263.09,56.53 261.14,56.53 261.14,56.53 261.01,56.53 259.41,58.13 v2(256.24,58.13) ; v2(314.09,175.2) 313.69,174.79 311.68,174.79 311.37,175.09 311.37,175.72 310.5,176.59 299.24,176.59 v2(297.86,175.21)
  IN3 w0.127: v2(293.45,132.74) 293.6,132.89 293.6,133.03 294.93,134.35 303.08,134.35 308.49,139.76 312.11,139.76 319.35,146.99 319.35,153.19 320.19,154.02 320.19,160.81 319.17,161.82 319.17,166.52 318.54,167.16 318.54,168.06 318.8,168.33 318.8,172.13 316.93,174 315.11,174 314.09,175.02 v2(314.09,175.2)
  IN4 w0.102: v2(284.34,117.78) 284.34,117.77 283.93,117.36 283.93,116.67 284.43,116.17 284.43,115.64 286.03,114.05 286.03,113.18 284.91,112.07 284.91,111.76 284.54,111.39 283.01,111.39 281.05,109.42 280.63,109.42 277.74,106.54 277.74,105.79 276.87,104.92 276.87,99.55 277.48,98.94 277.48,95.25 275.26,93.04 275.26,65.39 276.92,63.73 276.92,61.47 276.59,61.14 276.59,60.36 277.47,59.48 v2(277.47,58.94) ; v2(256.24,58.13) 256.21,58.13 255.21,57.14 255.21,53.16 255.41,52.97 255.41,48.33 254.44,47.36 252.83,47.36 252.68,47.51 246.12,47.51 244.34,49.29 243.5,49.29 243.31,49.48 243.31,49.93 241.59,51.65 241.39,51.65 240.09,52.95 230.8,52.95 229.65,54.1 224.33,54.1 223.86,53.63 218.59,53.63 217.67,54.55 217.67,59.11 214.44,62.35 214.44,62.93 v2(214.48,62.98)
  BOTTOM w0.089: UH1.C18 212.39,65.08 212.72,64.76 213.15,64.76 213.37,64.54 213.67,64.54 214.4,63.81
  BOTTOM w0.102: JMINI3.10 v2(297.86,175.21) ; v2(214.48,62.98) 214.48,63.73 214.4,63.81
LPC_LDRQ0#: length 4.9
  TOP w0.089: T87.1 214.65,66.9 214.21,67.35 213.19,67.35 212.66,66.82 v2(212.41,66.82)
  BOTTOM w0.089: v2(212.41,66.82) 212.95,66.28 UH1.D21
LPC_LDRQ1#: length 91.4
  TOP w0.102: U46.A22 269.44,58.88 269.53,58.97 269.53,58.98 269.78,59.23 269.78,59.36 v2(269.82,59.4) ; v2(256.24,62.39) 256.41,62.22 v1(256.83,62.22)
  IN2 w0.127: v2(269.82,59.4) 269.82,59.67 269.39,60.1 269.39,60.69 268.74,61.34 266.78,61.34 266.75,61.32 264.54,61.32 264.39,61.47 257.53,61.47 256.61,62.39 v2(256.24,62.39)
  IN4 w0.102: v2(212,67.26) 212.54,67.26 213.17,66.63 213.17,62.91 217.18,58.9 217.18,54.39 218.4,53.17 224.08,53.17 224.55,53.64 228.49,53.64 229.65,52.49 239.9,52.49 241.2,51.19 241.4,51.19 242.81,49.78 242.81,48.91 243.68,48.04 244.73,48.04 245.72,47.05 252.49,47.05 252.64,46.9 254.63,46.9 255.86,48.14 255.86,54.05 256.76,54.95 256.76,61.87 v2(256.24,62.39)
  BOTTOM w0.089: UH1.G20 211.77,67.03 v2(212,67.26)
LPC_LFRAME#: length 273
  TOP w0.102: v2(285.15,117.77) 285.06,117.86 285.06,118.11 284.97,118.2 U51.B31 ; U46.A21 v2(269.94,58.81) ; v1(254.88,62.23) 255.02,62.36 v2(255.66,62.36) ; v2(296.85,132.52) U39.22
  IN1 w0.102: v2(296.85,132.52) 296.85,132.51 296.13,131.79 293.23,131.79 292.12,130.68 286.86,130.68 283.46,127.28 283.46,122.35 283.23,122.13 283.23,120.97 285.12,119.08 285.12,117.79 285.15,117.77 v2(285.15,117.77)
  IN2 w0.127: v2(297.72,178.04) 297.79,178.04 298.28,178.54 298.81,178.54 300,177.36 313.13,177.36 v2(315.29,175.2) ; v2(255.66,62.36) 256.26,61.76 256.8,61.76 257.35,61.21 264.29,61.21 264.44,61.06 266.86,61.06 266.89,61.09 268.63,61.09 269.13,60.59 269.13,60 269.4,59.73 269.4,59.11 269.7,58.81 v2(269.94,58.81) 270.03,58.81 270.37,59.15 270.37,60.02 270.43,60.08 270.43,60.32 270.79,60.68 275.73,60.68 275.83,60.78 277.5,60.78 277.95,60.33 278.48,59.8 v2(278.48,59.32)
  IN3 w0.127: v2(315.29,175.2) 315.29,175.04 315.82,174.51 317.14,174.51 319.31,172.34 319.31,168 319.13,167.82 319.13,167.31 319.68,166.76 319.68,162.23 320.7,161.21 320.7,153.81 319.86,152.98 319.86,146.78 312.33,139.25 308.88,139.25 303.32,133.69 297.75,133.69 296.85,132.8 v2(296.85,132.52)
  IN4 w0.102: v2(255.66,62.36) 254.19,60.89 254.19,58.46 254.53,58.12 254.53,52.88 254.72,52.69 254.72,48.61 254.15,48.04 253.81,48.04 253.66,48.2 248.57,48.2 246.35,50.42 244.54,50.42 244.04,50.91 243.29,50.91 242.6,51.6 241.87,52.34 241.68,52.34 240.38,53.64 231.09,53.64 229.94,54.79 229.93,54.79 223.06,54.79 222.82,55.03 222.82,56.39 218.18,61.03 218.18,62.21 216.59,63.79 216.1,63.79 v2(215.79,64.1) ; v2(285.15,117.77) 285.53,117.39 285.97,117.39 286.27,117.09 286.27,116.87 286.67,116.46 286.67,115.39 287.89,114.18 287.89,111.86 287.53,111.51 287.37,111.51 286.9,111.04 286.9,109.85 285.1,108.05 285.1,107.32 283.9,106.13 282.06,106.13 281.04,105.1 278.9,105.1 278.14,104.34 278.14,100.96 279.19,99.9 279.19,98.67 279.68,98.18 279.68,95.65 276.53,92.51 276.53,66.07 278.29,64.31 278.29,62.66 278.71,62.24 278.71,59.77 278.48,59.54 v2(278.48,59.32)
  BOTTOM w0.089: 214.89,64.3 214.76,64.42 214.69,64.42 213.91,65.2 213.91,65.32 UH1.B21
  BOTTOM w0.102: 214.89,64.3 215.08,64.1 v2(215.79,64.1) ; v2(297.72,178.04) 297.39,178.04 297.06,177.71 JMINI3.8
LX_PCIE: length 2.3
  TOP w0.102: PR680.1 193.59,88.62 v1(192.98,88.01)
M_CLK_DDR0: length 61.4
  IN4 w0.089: 155.89,77.36 155.89,78.06 155.35,78.61 155.35,82.27 155.41,82.33 155.87,82.33 156.16,82.04 156.16,81.73 156.03,81.61 155.86,81.61 155.73,81.73 v2(155.73,81.92)
  IN4 w0.102: 155.89,77.36 155.89,69.58 155.48,69.17 155.48,59.41 155.58,59.3 156.1,59.3 156.35,59.05 156.35,58.62 156.1,58.36 155.58,58.36 155.48,58.26 155.48,57.96 155.58,57.86 156.1,57.86 156.35,57.6 156.35,57.17 156.1,56.92 155.58,56.92 155.48,56.81 155.48,56.51 155.58,56.41 156.1,56.41 156.35,56.15 156.35,55.72 156.1,55.47 155.58,55.47 155.48,55.37 155.48,55.06 155.58,54.96 156.1,54.96 156.35,54.71 156.35,54.27 156.1,54.02 155.58,54.02 155.48,53.92 155.48,53.61 155.58,53.51 156.1,53.51 156.35,53.26 156.35,52.83 156.1,52.57 155.58,52.57 155.48,52.47 155.48,52.17 155.58,52.06 156.1,52.06 156.35,51.81 156.35,51.38 156.1,51.12 155.58,51.12 155.48,51.02 155.48,50.72 155.58,50.62 156.1,50.62 156.35,50.36 156.35,49.93 156.1,49.68 155.58,49.68 155.48,49.58 155.48,49.27 155.58,49.17 156.1,49.17 156.35,48.92 156.35,48.48 156.1,48.23 155.58,48.23 155.48,48.13 155.48,47.82 155.58,47.72 156.1,47.72 156.35,47.47 156.35,47.03 156.1,46.78 155.58,46.78 155.48,46.68 155.48,46.37 155.58,46.27 156.1,46.27 156.35,46.02 156.35,45.59 156.1,45.33 155.61,45.33 155.48,45.21 155.48,44.95 155.61,44.83 155.72,44.83 155.98,44.57 155.98,44.14 155.72,43.89 155.58,43.89 155.48,43.78 155.48,42.35 155.6,42.23 155.77,42.23 155.9,42.36 v2(155.9,42.46)
  BOTTOM w0.089: v2(155.73,81.92) JCPU1.V4
  BOTTOM w0.102: v2(155.9,42.46) 155.9,42.37 155.56,42.02 155.34,42.02 155.11,41.8 154.95,41.64 154.95,40.62 155.3,40.27 JDIMM1.101
M_CLK_DDR1: length 60.2
  IN4 w0.089: v2(155.73,80.92) 155.73,80.95 155.84,81.05 156.04,81.05 156.14,80.95 156.14,78.57 156.41,78.3 156.41,77.45 156.41,77.44 156.41,77.38 156.4,77.37 156.4,77.36
  IN4 w0.102: v2(156.51,34.26) 156.51,34.08 156.63,33.95 156.89,33.95 157.02,34.08 157.02,35.3 156.9,35.43 156.29,35.43 156.03,35.68 156.03,36.13 156.29,36.39 157.12,36.39 157.25,36.51 157.25,36.98 157.12,37.11 156.56,37.11 156.35,37.33 156.35,37.91 156.02,38.24 156.02,40.45 156.42,40.86 156.42,42.28 156.73,42.58 156.73,42.83 156.42,43.14 156.42,43.89 156.49,43.96 156.49,45.01 156.86,45.38 156.86,59.67 156.74,59.79 156.24,59.79 155.99,60.04 155.99,60.45 156.22,60.68 156.75,60.68 156.86,60.78 156.86,61.08 156.75,61.19 156.22,61.19 155.99,61.41 155.99,61.96 156.22,62.19 156.75,62.19 156.86,62.29 156.86,62.6 156.75,62.7 156.22,62.7 155.99,62.92 155.99,68.96 156.4,69.37 156.4,77.36
  BOTTOM w0.089: v2(155.73,80.92) JCPU1.V3
  BOTTOM w0.102: JDIMM1.102 155.6,31.99 155.72,32.11 155.72,32.97 155.86,33.11 155.86,33.38 155.56,33.69 155.56,34.01 155.74,34.19 156.44,34.19 v2(156.51,34.26)
M_CLK_DDR2: length 77.6
  IN1 w0.089: 153.78,77.36 153.78,77.46 153.28,77.97 152.76,77.97 152.09,78.64 152.09,82.12 152.45,82.49 152.98,82.49 153.04,82.55 153.04,82.78 152.94,82.88 v2(152.75,82.88)
  IN1 w0.102: 153.78,77.36 153.78,76.58 153.95,76.41 154.17,76.41 154.25,76.33 154.25,75.86 154.19,75.8 153.97,75.8 153.78,75.62 153.78,74.98 154,74.76 154.18,74.76 154.25,74.69 154.25,74.23 154.17,74.15 154.01,74.15 153.78,73.92 153.78,69.15 154.01,68.92 154.41,68.92 154.52,68.82 154.52,68.41 154.41,68.31 154.01,68.31 153.78,68.08 153.78,67.5 154.01,67.27 154.39,67.27 154.52,67.14 154.52,66.79 154.39,66.66 154.01,66.66 153.78,66.43 153.78,65.85 154.01,65.62 154.39,65.62 154.52,65.49 154.52,65.14 154.39,65.01 154.01,65.01 153.78,64.78 153.78,64.19 154.01,63.97 154.39,63.97 154.52,63.84 154.52,63.48 154.39,63.36 154.01,63.36 153.78,63.13 153.78,62.52 154.01,62.29 154.39,62.29 154.52,62.17 154.52,61.81 154.39,61.68 154.03,61.68 153.78,61.43 153.78,60.9 154.03,60.64 154.39,60.64 154.52,60.52 154.52,60.16 154.39,60.03 154.01,60.03 153.78,59.81 153.78,59.18 154.01,58.96 154.31,58.96 154.44,58.83 154.44,58.47 154.31,58.35 154.01,58.35 153.78,58.12 153.78,57.4 154.01,57.17 154.39,57.17 154.52,57.05 154.52,56.69 154.39,56.56 154.03,56.56 153.78,56.31 153.78,55.67 154.03,55.41 154.39,55.41 154.52,55.29 154.52,54.93 154.39,54.81 154.05,54.81 153.79,54.55 153.79,47.87 153.96,47.71 153.96,37.99 154.11,37.83 154.11,27.72 155.12,26.71 155.12,23.5 155.33,23.29 155.62,23.29 155.75,23.17 v2(155.75,23.02)
  BOTTOM w0.089: v2(152.75,82.88) 152.32,82.45 JCPU1.AA4
  BOTTOM w0.102: v2(155.75,23.02) 155.75,23.06 155.5,23.3 155.35,23.3 155.04,23.61 155.04,24.87 155.3,25.13 155.3,26.09 JDIMM2.101
M_CLK_DDR3: length 76.4
  IN1 w0.089: 155.19,77.36 155.19,77.93 154.69,78.43 153.67,78.43 153.33,78.77 153.33,81.25 153.12,81.47 152.64,81.47 152.57,81.53 152.57,81.72 v2(152.76,81.91)
  IN1 w0.102: v2(155.75,20.73) 155.93,20.92 156.19,20.92 156.9,21.62 156.9,22.38 156.47,22.81 156.47,26.99 156.02,27.43 156.02,34.14 155.46,34.71 155.46,37.82 154.9,38.38 154.9,39.87 155.41,40.38 155.41,41.14 155.21,41.33 155.04,41.33 154.91,41.46 154.91,42.03 155.04,42.15 155.23,42.15 155.46,42.38 155.46,42.97 155.23,43.19 155,43.19 154.9,43.3 154.9,43.7 155,43.8 155.23,43.8 155.46,44.03 155.46,44.62 155.23,44.85 155,44.85 154.9,44.95 154.9,45.35 155,45.46 155.23,45.46 155.46,45.68 155.46,46.27 155.23,46.5 155.14,46.5 155.01,46.62 155.01,46.98 155.14,47.11 155.23,47.11 155.46,47.33 155.46,47.93 155.23,48.16 154.83,48.16 154.73,48.26 154.73,48.67 154.83,48.77 155.23,48.77 155.46,49 155.46,49.58 155.23,49.81 154.83,49.81 154.73,49.91 154.73,50.32 154.83,50.42 155.23,50.42 155.46,50.65 155.46,51.23 155.23,51.46 154.83,51.46 154.73,51.56 154.73,51.97 154.83,52.07 155.23,52.07 155.46,52.3 155.46,52.88 155.23,53.11 154.83,53.11 154.73,53.21 154.73,53.62 154.83,53.72 155.23,53.72 155.46,53.95 155.46,72.83 155.19,73.1 155.19,77.36
  BOTTOM w0.089: v2(152.76,81.91) 152.31,81.45 JCPU1.AA3
  BOTTOM w0.102: JDIMM2.102 155.6,18.8 155.79,18.99 155.79,19.28 156.23,19.73 156.23,20.83 156.15,20.92 155.93,20.92 v2(155.75,20.73)
M_CLK_DDR#0: length 61.5
  IN4 w0.089: 155.68,77.36 155.68,77.37 155.68,77.38 155.68,77.44 155.69,77.45 155.69,77.98 155.14,78.52 155.14,82.35 155.32,82.53 155.96,82.53 156.36,82.13 156.36,82.06 156.51,81.92 v2(156.73,81.92)
  IN4 w0.102: 155.68,77.36 155.68,69.67 155.27,69.26 155.27,59.32 155.49,59.09 156.01,59.09 156.13,58.96 156.13,58.71 156.01,58.58 155.49,58.58 155.27,58.35 155.27,57.87 155.49,57.64 156.01,57.64 156.13,57.51 156.13,57.26 156.01,57.13 155.49,57.13 155.27,56.9 155.27,56.42 155.49,56.19 156.01,56.19 156.13,56.06 156.13,55.81 156.01,55.68 155.49,55.68 155.27,55.46 155.27,54.97 155.49,54.74 156.01,54.74 156.13,54.62 156.13,54.36 156.01,54.24 155.49,54.24 155.27,54.01 155.27,53.52 155.49,53.3 156.01,53.3 156.13,53.17 156.13,52.92 156.01,52.79 155.49,52.79 155.27,52.56 155.27,52.08 155.49,51.85 156.01,51.85 156.13,51.72 156.13,51.47 156.01,51.34 155.49,51.34 155.27,51.11 155.27,50.63 155.49,50.4 156.01,50.4 156.13,50.27 156.13,50.02 156.01,49.89 155.49,49.89 155.27,49.66 155.27,49.18 155.49,48.95 156.01,48.95 156.13,48.83 156.13,48.57 156.01,48.44 155.49,48.44 155.27,48.22 155.27,47.73 155.49,47.51 156.01,47.51 156.13,47.38 156.13,47.12 156.01,47 155.49,47 155.27,46.77 155.27,46.29 155.49,46.06 156.01,46.06 156.13,45.93 156.13,45.68 156.01,45.55 155.52,45.55 155.27,45.3 155.27,44.86 155.52,44.61 155.63,44.61 155.76,44.48 155.76,44.23 155.63,44.1 155.49,44.1 155.27,43.87 155.27,42.26 155.52,42.01 155.72,42.01 155.9,41.83 v2(155.9,41.69)
  BOTTOM w0.089: v2(156.73,81.92) JCPU1.U4
  BOTTOM w0.102: v2(155.9,41.69) 155.8,41.8 155.43,41.8 155.18,41.54 155.18,40.72 155.9,39.99 JDIMM1.103
M_CLK_DDR#1: length 60.1
  IN4 w0.089: v2(156.73,81.01) 156.45,81.01 156.35,80.91 156.35,78.65 156.62,78.38 156.62,77.36
  IN4 w0.102: 156.62,77.36 156.62,69.28 156.21,68.87 156.21,63.01 156.31,62.91 156.84,62.91 157.07,62.69 157.07,62.2 156.84,61.97 156.31,61.97 156.21,61.87 156.21,61.5 156.31,61.4 156.84,61.4 157.07,61.17 157.07,60.69 156.84,60.46 156.31,60.46 156.21,60.36 156.21,60.13 156.33,60.01 156.83,60.01 157.07,59.76 157.07,45.29 156.7,44.92 156.7,43.87 156.64,43.8 156.64,43.22 156.94,42.92 156.94,42.49 156.64,42.19 156.64,40.77 156.23,40.36 156.23,38.33 156.56,38 156.56,37.41 156.65,37.33 157.21,37.33 157.47,37.07 157.47,36.42 157.21,36.17 156.38,36.17 156.25,36.04 156.25,35.77 156.38,35.64 156.99,35.64 157.24,35.39 157.24,34 156.98,33.73 156.74,33.73 v2(156.51,33.49)
  BOTTOM w0.089: v2(156.73,81.01) 156.75,81.01 156.3,81.45 JCPU1.U3
  BOTTOM w0.102: JDIMM1.104 156.2,31.92 155.95,32.17 155.95,32.88 156.09,33.02 156.09,33.48 155.79,33.78 155.79,33.92 155.83,33.96 156.13,33.96 156.51,33.58 v2(156.51,33.49)
M_CLK_DDR#2: length 77.6
  IN1 w0.089: v2(153.72,82.93) 153.56,83.08 153.34,83.08 153.25,82.99 153.25,82.46 153.07,82.28 152.53,82.28 152.29,82.04 152.29,78.73 152.85,78.17 153.36,78.17 154,77.53 154,77.36
  IN1 w0.102: 154,77.36 154,76.67 154.04,76.63 154.26,76.63 154.47,76.42 154.47,75.77 154.28,75.58 154.05,75.58 154,75.53 154,75.07 154.09,74.98 154.27,74.98 154.47,74.78 154.47,74.14 154.26,73.93 154.1,73.93 154,73.83 154,69.24 154.1,69.14 154.5,69.14 154.73,68.91 154.73,68.32 154.5,68.09 154.1,68.09 154,67.99 154,67.59 154.1,67.48 154.48,67.48 154.73,67.23 154.73,66.7 154.48,66.44 154.1,66.44 154,66.34 154,65.94 154.1,65.83 154.48,65.83 154.73,65.58 154.73,65.05 154.48,64.79 154.1,64.79 154,64.69 154,64.28 154.1,64.18 154.48,64.18 154.73,63.93 154.73,63.39 154.48,63.14 154.1,63.14 154,63.04 154,62.61 154.1,62.51 154.48,62.51 154.73,62.26 154.73,61.72 154.48,61.47 154.12,61.47 154,61.34 154,60.99 154.12,60.86 154.48,60.86 154.73,60.61 154.73,60.07 154.48,59.82 154.1,59.82 154,59.72 154,59.27 154.1,59.17 154.4,59.17 154.66,58.92 154.66,58.38 154.4,58.13 154.1,58.13 154,58.03 154,57.49 154.1,57.39 154.48,57.39 154.73,57.14 154.73,56.6 154.48,56.35 154.12,56.35 154,56.22 154,55.76 154.12,55.63 154.48,55.63 154.73,55.38 154.73,54.84 154.48,54.59 154.14,54.59 154.01,54.46 154.01,47.96 154.17,47.79 154.17,38.08 154.33,37.92 154.33,27.81 155.34,26.8 155.34,23.59 155.42,23.5 155.61,23.5 155.75,23.64 v2(155.75,23.78)
  BOTTOM w0.089: v2(153.72,82.93) 153.24,82.45 JCPU1.Y4
  BOTTOM w0.102: v2(155.75,23.78) 155.5,23.53 155.44,23.53 155.29,23.69 155.29,24.78 155.45,24.95 155.76,24.95 155.9,25.08 JDIMM2.103
M_CLK_DDR#3: length 76.4
  IN1 w0.089: v2(152.71,80.87) 152.71,81.17 152.8,81.27 153.03,81.27 153.13,81.17 153.13,78.68 153.58,78.23 154.61,78.23 154.99,77.85 154.99,77.45 154.98,77.44 154.98,77.38 154.97,77.37 154.97,77.36
  IN1 w0.102: v2(155.75,21.49) 155.68,21.43 155.68,21.27 155.82,21.13 156.1,21.13 156.68,21.71 156.68,22.29 156.25,22.72 156.25,26.9 155.81,27.34 155.81,34.06 155.24,34.62 155.24,37.73 154.68,38.29 154.68,39.96 155.19,40.47 155.19,41.05 155.12,41.11 154.95,41.11 154.69,41.37 154.69,42.12 154.95,42.37 155.14,42.37 155.24,42.47 155.24,42.88 155.14,42.98 154.91,42.98 154.68,43.21 154.68,43.79 154.91,44.02 155.14,44.02 155.24,44.12 155.24,44.53 155.14,44.63 154.91,44.63 154.68,44.86 154.68,45.44 154.91,45.67 155.14,45.67 155.24,45.77 155.24,46.18 155.14,46.28 155.05,46.28 154.8,46.53 154.8,47.07 155.05,47.32 155.14,47.32 155.24,47.42 155.24,47.84 155.14,47.94 154.74,47.94 154.52,48.17 154.52,48.76 154.74,48.98 155.14,48.98 155.24,49.09 155.24,49.49 155.14,49.59 154.74,49.59 154.52,49.82 154.52,50.41 154.74,50.64 155.14,50.64 155.24,50.74 155.24,51.14 155.14,51.25 154.74,51.25 154.52,51.47 154.52,52.06 154.74,52.29 155.14,52.29 155.24,52.39 155.24,52.79 155.14,52.9 154.74,52.9 154.52,53.12 154.52,53.71 154.74,53.94 155.14,53.94 155.24,54.04 155.24,72.74 154.97,73.01 154.97,77.36
  BOTTOM w0.089: JCPU1.Y3 153.2,81.37 v2(152.71,80.87)
  BOTTOM w0.102: JDIMM2.104 156.2,18.78 156.01,18.96 156.01,19.19 156.46,19.63 156.46,20.93 156.24,21.15 155.75,21.15 155.7,21.2 155.7,21.44 v2(155.75,21.49)
M_ODT0: length 67
  IN4 w0.152: v2(161.73,85.89) 162.06,85.89 162.19,85.77 162.19,77.36
  IN4 w0.165: 162.19,77.36 162.19,63.99 164.13,62.05 164.13,49.92 164.03,49.81 163.43,49.81 163.33,49.71 163.33,48.99 163.43,48.89 163.97,48.89 164.13,48.72 164.13,48.39 163.97,48.23 163.04,48.23 162.94,48.13 162.94,47.67 163.04,47.57 163.97,47.57 164.13,47.4 164.13,47.07 163.97,46.91 163.04,46.91 162.94,46.8 162.94,46.35 163.04,46.25 163.97,46.25 164.13,46.08 164.13,45.19 164.04,45.1 163.8,45.1 163.7,45 163.7,44.4 163.8,44.3 164.04,44.3 164.15,44.2 164.15,43.85 163.68,43.39 163.68,36.67 163.55,36.54 161.48,36.54 161.36,36.42 161.36,34.98 160.97,34.59 160.97,33.68 160.85,33.55 160.52,33.55 160.4,33.68 v2(160.4,33.88)
  BOTTOM w0.089: JCPU1.M8 161.2,86.42 v2(161.73,85.89)
  BOTTOM w0.165: JDIMM1.116 159.8,33.28 v2(160.4,33.88)
M_ODT1: length 64.5
  IN4 w0.152: v2(162.73,84.89) 163.21,84.42 163.21,78.78 162.7,78.27 162.7,77.36
  IN4 w0.165: 162.7,77.36 162.7,64.19 164.64,62.24 164.64,43.65 164.2,43.21 164.2,36.14 164.1,36.04 161.97,36.04 161.87,35.94 161.87,35.55 162,35.42 163.67,35.42 163.79,35.29 163.79,34.94 163.67,34.81 162.25,34.81 162.12,34.68 162.12,34.33 162.25,34.2 162.86,34.2 162.96,34.1 162.96,33.64 162.86,33.54 161.77,33.54 161.67,33.64 v2(161.67,33.88)
  BOTTOM w0.089: JCPU1.L7 162.2,85.42 v2(162.73,84.89)
  BOTTOM w0.165: v2(161.67,33.88) 161,33.21 JDIMM1.120
M_ODT2: length 77.8
  IN1 w0.089: 160.24,77.36 160.24,77.51 159.13,78.62 159.13,81.52 v2(158.73,81.92)
  IN1 w0.165: v2(160.52,21.87) 160.52,22.09 160.65,22.22 161.32,22.22 161.45,22.09 161.45,21.68 161.26,21.49 161.26,20.8 161.39,20.67 162.54,20.67 162.67,20.55 162.67,19.55 162.8,19.42 163.6,19.42 163.73,19.55 163.73,20.5 163.6,20.62 163.56,20.62 163.43,20.75 163.43,21.11 163.56,21.23 163.6,21.23 163.73,21.36 163.73,22.16 163.03,22.85 163.03,26.99 163.76,27.71 163.76,37.52 164.14,37.9 164.14,45.92 162.27,47.79 162.27,75.25 160.24,77.29 160.24,77.36
  BOTTOM w0.089: v2(158.73,81.92) JCPU1.R4
  BOTTOM w0.165: v2(160.52,21.87) 161.03,21.36 161.03,19.41 160.75,19.13 160.1,19.13 159.8,18.82 JDIMM2.116
M_ODT3: length 77.2
  IN1 w0.089: 159.74,77.36 159.74,77.49 159.42,77.82 159.27,77.82 158.32,78.76 158.32,80.91 158.45,81.04 158.62,81.04 v2(158.73,80.92)
  IN1 w0.165: v2(162.04,21.87) 162.37,21.87 162.46,21.78 162.46,21.53 162.53,21.46 162.86,21.46 163.03,21.63 163.03,22.16 162.78,22.4 162.67,22.4 162.54,22.53 162.54,24.51 162.41,24.64 162.23,24.64 162.1,24.76 162.1,25.18 162.23,25.31 162.4,25.31 162.54,25.45 162.54,27.19 163.26,27.91 163.26,38.13 163.43,38.3 163.52,38.3 163.64,38.43 163.64,38.83 163.52,38.96 163.39,38.96 163.26,39.09 163.26,39.49 163.39,39.62 163.52,39.62 163.64,39.75 163.64,40.15 163.52,40.28 163.39,40.28 163.26,40.41 163.26,40.81 163.39,40.94 163.52,40.94 163.64,41.07 163.64,41.47 163.52,41.6 163.39,41.6 163.26,41.73 163.26,42.14 163.39,42.26 163.47,42.26 163.63,42.43 163.63,42.76 163.47,42.92 163.39,42.92 163.26,43.05 163.26,43.46 163.39,43.58 163.52,43.58 163.64,43.71 163.64,44.12 163.52,44.24 163.39,44.24 163.26,44.37 163.26,44.78 163.39,44.9 163.52,44.9 163.64,45.03 163.64,45.44 163.52,45.56 163.43,45.56 163.26,45.73 163.26,46.1 161.77,47.59 161.77,48.63 161.61,48.8 161.34,48.8 161.21,48.93 161.21,49.33 161.34,49.46 161.65,49.46 161.77,49.59 161.77,49.99 161.65,50.12 161.34,50.12 161.21,50.25 161.21,50.65 161.34,50.78 161.65,50.78 161.77,50.91 161.77,51.31 161.65,51.44 161.34,51.44 161.21,51.57 161.21,51.97 161.34,52.1 161.65,52.1 161.77,52.23 161.77,52.63 161.65,52.76 161.34,52.76 161.21,52.89 161.21,53.3 161.34,53.42 161.65,53.42 161.77,53.55 161.77,53.96 161.65,54.08 161.34,54.08 161.21,54.21 161.21,54.62 161.34,54.74 161.65,54.74 161.77,54.87 161.77,55.28 161.65,55.4 161.34,55.4 161.21,55.53 161.21,55.94 161.34,56.06 161.61,56.06 161.77,56.23 161.77,75.05 159.74,77.08 159.74,77.36
  BOTTOM w0.089: v2(158.73,80.92) JCPU1.R3
  BOTTOM w0.165: v2(162.04,21.87) 161.61,21.43 161.61,19.28 161,18.67 JDIMM2.120
MAA0_0: length 30.5
  TOP w0.102: UV5.K4 v2(193.05,122.7)
  IN4 w0.102: 209.88,126.06 209.88,126.83 v2(211.9,128.84)
  IN4 w0.127: 209.88,126.06 209.88,125.27 206.09,121.48 204.59,121.48 204.47,121.35 204.47,120.47 204.34,120.35 204.08,120.35 203.96,120.47 203.96,121.35 203.83,121.48 203.58,121.48 203.45,121.35 203.45,120.47 203.32,120.35 203.06,120.35 202.93,120.47 202.93,120.97 202.8,121.09 202.55,121.09 202.42,120.97 202.42,120.57 202.27,120.42 193.73,120.42 193.05,121.11 v2(193.05,122.7)
  BOTTOM w0.102: UV1.G24 211.85,128.79 v2(211.9,128.84) ; UV5.K4 v2(193.05,122.7)
MAA0_1: length 32
  TOP w0.102: v2(192.65,121.77) UV5.K5
  IN1 w0.102: v2(213.29,128.75) 213.29,128.84 212.57,129.56 211.79,129.56 211.67,129.44 211.31,129.44 211.07,129.68 211.07,129.9 210.93,130.04 210.21,130.04 209.94,130.3 209.2,130.3 209.05,130.45 209.05,130.85 208.83,131.07 207.35,131.07
  IN1 w0.127: v2(192.65,121.77) 193.17,122.29 196.4,122.29 196.64,122.53 196.64,122.53 196.64,122.86 196.64,122.86 196.64,123.33 196.64,123.33 196.64,123.66 196.64,123.66 196.64,124.13 196.64,124.13 196.64,124.46 196.64,124.46 196.64,124.93 196.64,124.93 196.64,125.26 196.64,125.26 196.64,125.73 196.64,125.73 196.64,126.06 196.64,126.06 196.64,129.39 197.44,130.19 199.68,130.19 200.19,130.69 202.23,130.69 202.87,131.33 207.08,131.33 207.35,131.07
  BOTTOM w0.102: UV1.J23 213.45,128.91 v2(213.29,128.75) ; v2(192.65,121.77) UV5.K5
MAA0_2: length 31.9
  TOP w0.102: v2(192.25,117.9) UV5.K11
  IN1 w0.102: 207.12,130.02 207.13,130.04 208.74,130.04 209.04,129.73 209.04,129.31 209.93,128.42 212.14,128.42 v2(212.48,128.77)
  IN1 w0.127: 207.12,130.02 207.1,130.02 206.71,130.42 203.25,130.42 202.61,129.77 200.57,129.77 198.26,127.47 198.26,122.55 196.83,121.12 194.38,121.12 192.45,119.19 192.45,118.1 v2(192.25,117.9)
  BOTTOM w0.102: UV1.H24 212.65,128.6 v2(212.48,128.77) ; v2(192.25,117.9) UV5.K11
