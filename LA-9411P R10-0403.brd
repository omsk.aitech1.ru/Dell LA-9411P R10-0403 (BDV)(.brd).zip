# Allegro board LA-9411P R10-0403.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
DGPU_PWR_EN#: length 185.3
  TOP w0.102: v1(256.94,106.48) 256.69,106.73 v2(256.69,107.25) ; v2(185.15,108.72) 185.14,108.72 184.87,108.46 RV82.2 183.6,108.97 182.55,108.97 182.27,108.69 QV5.3 QV6.2 ; v2(214.04,57.23) 214.18,57.08 RH328.2
  IN2 w0.127: v2(256.69,107.25) 256.07,106.63 251.36,106.63 251.12,106.39 249.46,106.39 248.41,107.44 246.66,107.44 243.99,110.11 239.39,110.11 237.38,108.1 232.36,108.1 228.04,103.78 222.06,103.78 220.31,102.03 219.73,102.03 218.88,101.18 217.9,101.18 216.88,100.16 v2(215.71,100.16)
  IN3 w0.127: v2(214.04,57.23) 215.36,57.23 217.54,55.05 217.54,54.73 219.16,53.11 220.54,53.11 221.17,53.74 229.68,53.74 230.74,52.68 235.73,52.68 237.13,54.08 238.26,54.08 242.91,58.73 242.91,59.59 242.91,59.59 242.91,59.8 242.91,60.22 243.12,60.43 243.12,73.05 244.34,74.27 244.34,80.98 243.84,81.49 243.84,83.31 246.78,86.26 246.78,93.96 256.56,103.74 256.56,107.12 v2(256.69,107.25)
  BOTTOM w0.089: 211.95,61.36 211.23,62.07 211.23,62.36 210.99,62.6 210.99,63.04 UH1.C12
  BOTTOM w0.102: v2(214.04,57.23) 214.42,57.61 214.42,58.59 212.96,60.05 212.96,60.15 212.6,60.51 212.6,60.7 211.95,61.36 ; v2(215.71,100.16) 213.37,102.5 203.45,102.5 198.85,107.1 186.41,107.1 185.15,108.36 v2(185.15,108.72)
DGPU_PWR_EN#_Q: length 226.2
  TOP w0.102: v2(247.71,135.31) 248.29,135.31 v1(248.43,135.17) ; QV11.2 182.29,107.18 181.66,106.54 181.66,105.88 182.29,105.24 QV2.2 181.98,104.93 181.25,105.66 v2(181.25,105.89) 181.15,105.99 180.41,105.99 179.08,107.32 QV5.1 QV6.1 178.71,110.6 177.96,109.85 RV81.1
  IN1 w0.102: v2(247.79,108.05) 247.61,108.23 247.19,108.23 246.71,108.71 246.71,113.99 247.71,115 247.71,119.32 243.77,123.25 243.77,127.71 247.71,131.65 v2(247.71,135.31)
  IN2 w0.127: v2(314.94,150.66) 317.69,153.4 317.69,156.68 v4(318.3,157.29) ; v2(247.63,144.25) 247.63,144.32 248.47,145.16 249.22,145.16 251.3,147.24 253.44,147.24 254.47,146.21 256.54,146.21 259.2,148.88 260.66,148.88 261.74,147.8 276.65,147.8 277.63,148.78 280.2,148.78 v2(281.29,149.87)
  IN3 w0.127: v2(247.79,108.05) 247.79,106.84 245.89,104.95 245.89,103.76 237.65,95.52 222.93,95.52 215.92,102.53 203.13,102.53 201.79,103.86 195.21,103.86 195.03,104.04 188.73,104.04 188.24,103.54 182.1,103.54 181.5,104.14 181.5,105.63 181.25,105.88 v2(181.25,105.89) ; v2(281.29,149.87) 280.78,149.36 280.78,147.08 284.67,143.19 285.99,143.19 286.01,143.17 286.96,143.17 287.24,142.89 293.33,142.89 293.46,142.76 304.99,142.76 305.37,143.14 307.07,143.14 309.49,145.57 310.62,145.57 310.87,145.31 312.73,145.31 314.24,146.83 314.24,149.84 314.25,149.85 314.25,150.12 314.79,150.66 v2(314.94,150.66)
  IN4 w0.102: v2(247.71,135.31) 248.37,135.97 248.37,138.85 248.93,139.41 248.93,143.14 247.82,144.25 v2(247.63,144.25)
  BOTTOM w0.102: v4(318.3,157.29) 318.14,157.44 PR697.1
  BOTTOM w0.254: PQ610.2 318.12,158.11 PR697.1
DGPU_PWROK: length 314.6
  TOP w0.089: v1(214.39,60.97) 214.39,60.75
  TOP w0.102: 214.39,60.75 v2(214.39,59.85) 214.39,58.58 216.09,56.88 RH215.1 ; v2(267.68,46.35) 267.94,46.61 U46.A56
  IN1 w0.102: v2(259.59,110.36) 259.06,110.89 259.06,129.6 258.64,130.02 258.64,143.75 258.24,144.16 258.24,146.53 v2(258.05,146.72)
  IN2 w0.127: v2(258.05,146.72) 258.16,146.84 258.16,146.88 259.2,147.92 260.76,147.92 261.13,147.55 276.76,147.55 277.71,148.5 280.55,148.5 280.78,148.73 280.78,148.73 v2(281.29,149.24) ; v2(316.29,167.02) 316.9,167.02 319.38,164.54 319.38,161.14 322.44,158.08 322.44,156.6 322.08,156.25 321.13,156.25 v2(314.94,150.06) ; v2(232.72,49.07) 233.57,49.92 237.96,49.92 238.23,49.65 239.88,49.65 241.39,48.15 241.92,48.15 242.69,48.92 244.89,48.92 246.01,47.8 256.98,47.8 257.53,47.24 260.91,47.24 261.35,46.8 264.97,46.8 265.23,47.07 266.97,47.07 v2(267.68,46.35) ; v2(256.73,70.27) 257.2,70.74 272.16,70.74 272.47,70.42 v2(273.17,70.42)
  IN3 w0.127: v2(273.17,70.42) 273.17,69.79 273.07,69.69 273.07,62.81 272.79,62.53 272.79,52.73 272.21,52.15 270.96,52.15 270.52,51.7 270.52,50.88 269.75,50.11 268.68,50.11 268.47,49.9 268.47,47.15 v2(267.68,46.35) ; v2(214.39,59.85) 215.45,59.85 217.71,57.59 217.71,57.32 218.23,56.81 218.78,56.81 220.52,55.07 230.18,55.07 231.29,53.96 234.98,53.96 v2(240.04,59.02) ; v2(314.94,150.06) 315.36,150.48 315.36,150.86 315.15,151.08 314.55,151.08 314.3,150.82 314.3,150.52 313.91,150.14 313.91,146.97 312.51,145.57 310.98,145.57 310.72,145.82 308.94,145.82 308.55,145.44 308.55,145 308.37,144.82 308.37,144.81 306.98,143.42 305.29,143.42 304.88,143.01 293.56,143.01 293.44,143.14 287.34,143.14 287.04,143.45 284.77,143.45 281.03,147.18 281.03,148.98 v2(281.29,149.24)
  BOTTOM w0.089: 212.76,62.16 212.28,62.64 212.28,63.34 212.02,63.6 211.7,63.6 211.37,63.93 UH1.C14
  BOTTOM w0.102: 212.76,62.16 213.49,61.43 213.74,61.43 214.16,61.01 214.16,60.7 214.36,60.49 214.36,59.88 v2(214.39,59.85) ; v2(316.29,167.02) PR629.1 ; v2(240.04,59.02) 240.04,58.52 241.13,57.43 241.13,55.88 234.32,49.07 v2(232.72,49.07) ; v2(256.73,70.27) 256.14,70.85 256.14,91 255.41,91.73 255.41,96.17 254.97,96.6 254.97,97.33 255.61,97.96 255.61,107.44 257.55,109.38 258.61,109.38 v2(259.59,110.36)
DH_1.35V: length 6.9
  IN1 w1.016: 201.53,8.65 205.85,12.97
  BOTTOM w0.102: v4(208.01,14.36) v1(208.78,14.36)
  vias: v4(200.9,7.89) v4(200.9,7.25) v4(207.37,14.36)
DIMM1_SA0: length 4.6
  TOP w0.102: v1(186.06,36.47) 185.62,36.92 v2(185.61,36.92) 185.37,36.92 RD6.2
  BOTTOM w0.102: v2(185.61,36.92) 184.95,36.92 184.1,37.77 JDIMM1.197
DIMM1_SA1: length 2.9
  TOP w0.102: v1(186.09,38.11) 185.65,37.68 v2(185.61,37.68) 185.24,37.68 RD7.2
  BOTTOM w0.102: JDIMM1.201 185.3,37.99 v2(185.61,37.68)
DIMM2_SA0: length 4.9
  TOP w0.102: v1(185.7,22.64) RD11.1 184.71,23.1 v2(184.95,23.34)
  BOTTOM w0.102: v2(184.95,23.34) 184.54,23.75 184.54,24.81 184.1,25.25 JDIMM2.197
DIMM2_SA1: length 4.2
  TOP w0.102: v1(186.68,23.76) RD12.1 185.17,23.76 v2(184.95,23.98)
  BOTTOM w0.102: JDIMM2.201 185.3,25.08 185.5,24.88 185.5,24.53 v2(184.95,23.98)
DIS_BAT_PROCHOT#: length 429
  TOP w0.102: v1(85.19,160.41) 85.59,160.82 v2(85.59,161.06) ; v2(270.25,19.76) 270.25,17.56 266.67,13.98 266.67,8.53 265.26,7.12 v2(264.94,7.12) ; U46.B51 263.34,48.64 262.94,48.23 262.01,48.23 v2(261.96,48.29)
  TOP w0.254: v2(52.23,185.69) 51.88,185.69 PR812.1
  IN1 w0.102: v2(85.59,161.06) 85.76,160.9 87.73,160.9 88.24,160.39 89.98,160.39 90.14,160.22 90.14,159.66 91.54,158.27 96.38,158.27 102.54,152.11 102.54,150.34 102.74,150.14 107.42,145.45 107.42,140.73 110.41,137.74 110.41,119.74 109.43,118.76 109.43,102.96 113.41,98.98 113.41,91.92 116.16,89.17 116.16,69.43 116.37,69.23 116.37,61.94 113.43,59 113.43,56.37 112.96,55.91 112.96,37.88 113.85,36.99 113.85,26.23 116.43,23.65 116.43,20.29 119.73,16.99 119.73,14.67 121.01,13.4 122.18,13.4 122.76,13.98 145.07,13.98 145.53,14.44 156.79,14.44 157.42,13.8 160.73,13.8 160.85,13.69 187.61,13.69 192.19,18.26 193.45,18.26 195.13,19.94 204.43,19.94 205.61,21.12 211.41,21.12 212.27,20.26 239.59,20.26 252.9,6.95 264.77,6.95 v2(264.94,7.12) ; v2(261.96,48.29) 261.96,43.41 263.48,41.88 263.48,33.4 266.97,29.92 268.73,29.92 269.63,29.02 269.63,20.38 v2(270.25,19.76)
  IN3 w0.127: v2(85.59,161.06) 85.59,165.1 81.81,168.88 69.08,168.88 68.66,168.47 57.96,168.47 55.16,171.26 55.16,179.4 52.78,181.79 52.78,185.14 v2(52.23,185.69)
DISP_ON: length 9.9
  BOTTOM w0.102: JLVDS1.9 177.26,151.97 177.66,152.36 177.66,152.97 178.04,153.35 178.39,153.35 R1138.1 179.26,154.22 181.15,154.22 v1(181.21,154.28) 181.71,154.28 D69.1 D64.1
DK_AC_OFF: length 5.6
  TOP w0.254: PU800.25 150.75,170.9 150.73,170.91 150.73,172.59 v1(150.26,173.06) 149.31,174.01 PD817.3
DK_AC_OFF_EN: length 3.2
  TOP w0.254: PU800.22 152.25,171.45 152.55,171.75 v1(152.55,172.14) 152.55,172.71 152.25,173.01 152.25,173.41 PR857.1
DK_CSS_GC: length 67.6
  TOP w0.254: PU800.11 155.58,166.03 156.42,165.19 v2(156.42,165.13) ; PR709.2 107.63,165.44 107.16,164.97 v1(107.16,164.73) 107.16,163.96 v2(107.16,163.96)
  BOTTOM w0.254: v2(156.42,165.13) 156.4,165.1 156.4,159.33 155.3,158.24 144.12,158.24 141.18,161.18 130.44,161.18 128.14,163.47 121.73,163.47 121.06,164.15 118.24,164.15 117.94,163.84 117.94,163.67 117.7,163.44 117.22,163.44 116.87,163.78 116.87,163.98 116.75,164.11 116.14,164.11 115.57,163.54 114.85,163.54 114.63,163.31 114.63,161.12 114.46,160.96 113.44,160.96 112.07,162.33 111.09,162.33 108.81,164.61 107.81,164.61 v2(107.16,163.96)
DK_PWRBAR: length 5
  TOP w0.102: v1(147.63,167.98) 147.37,168.25 146.33,168.25 PR832.2
  TOP w0.254: PU800.33 148.05,167.03 147.87,166.85 147.37,166.85 146.19,168.03 PR832.2
DL_1.35V: length 20.2
  IN1 w1.016: 207.63,16.78 199.88,16.78 194.8,11.7 190.48,11.7
  BOTTOM w0.102: v4(208.45,16.17) v1(207.5,16.17)
  vias: v4(189.47,11.95) v4(189.47,11.32) v4(209.09,16.17)
DMI_CRX_PTX_N0: length 46.7
  IN4 w0.089: 173.59,100.47 173.53,100.53 171.38,100.53 171.14,100.29 171.14,98.62 171.03,98.51 170.14,98.51 v2(169.73,98.92)
  IN4 w0.114: v2(197.38,80.46) 197.32,80.52 197.32,80.94 197.39,81.01 197.39,81.52 196.5,82.42 196.5,82.58 195.91,83.17 194.83,83.17 193.44,84.56 188.85,84.56 174.53,98.88 174.53,99.53 173.59,100.47
  BOTTOM w0.089: v2(169.73,98.92) JCPU1.D21 ; 199.75,79.64 199.79,79.59 199.79,79.5 199.93,79.36 200.02,79.36 200.1,79.29 200.1,78.82 200.17,78.74 200.31,78.74 200.38,78.67 200.38,78.55 200.43,78.5 200.55,78.5 200.78,78.27 200.78,78.17 200.88,78.07 200.95,78.07 UH1.BD21
  BOTTOM w0.102: 199.75,79.64 199.05,80.34 198.09,80.34 197.43,81 197.06,81 196.83,80.77 196.83,80.67 197.16,80.34 197.26,80.34 v2(197.38,80.46)
DMI_CRX_PTX_N1: length 46.6
  IN4 w0.089: 173.59,101.23 173.5,101.31 173.49,101.31 173.49,101.32 170.44,101.32 170.33,101.21 170.33,99.61 170.64,99.3 170.87,99.3 170.95,99.38 170.95,99.81 170.84,99.92 v2(170.73,99.92)
  IN4 w0.114: v2(197.83,80) 197.83,79.95 197.98,79.81 198.18,79.81 198.33,79.96 198.33,80.25 198.1,80.47 198.1,82.02 196.52,83.6 195.09,83.6 193.69,85 189.01,85 174.98,99.03 174.98,99.84 173.59,101.23
  BOTTOM w0.089: v2(170.73,99.92) 170.73,99.8 170.39,99.45 JCPU1.C21 ; 199.46,79.34 199.86,78.94 199.86,78.62 200.07,78.41 200.19,78.41 200.25,78.35 200.25,78.23 200.29,78.19 200.43,78.19
  BOTTOM w0.102: 199.46,79.34 199.14,79.65 198.78,79.65 198.57,79.86 198.23,79.86 198.15,79.78 198.05,79.78 v2(197.83,80)
DMI_CRX_PTX_N2: length 41.5
  IN4 w0.089: 173.42,98.12 173.02,98.52 172.55,98.52 172.32,98.75 172.32,99.32 171.99,99.65 171.88,99.65 171.73,99.8 v2(171.73,99.92)
  IN4 w0.114: 173.42,98.12 188.35,83.18 192.91,83.18 195.25,80.85 195.25,80.47 195.06,80.28 195.06,80.11 v2(195.13,80.03)
  BOTTOM w0.089: v2(171.73,99.92) 171.26,99.45 JCPU1.B21 ; UH1.BD17 199.81,76.92 199.7,76.92 199.61,77.01 199.61,77.14 199.35,77.4 199.07,77.69 198.94,77.69 198.89,77.74 198.73,77.74 198.64,77.83 198.64,77.99 198.57,78.05
  BOTTOM w0.102: v2(195.13,80.03) 195,79.9 194.75,79.9 194.62,80.02 194.62,80.11 194.93,80.42 194.93,80.44 195.1,80.61 195.99,80.61 196.48,80.12 196.5,80.12 197.99,78.63 197.99,78.52 198.12,78.4 198.23,78.4 198.33,78.29 198.33,78.18 198.46,78.05 198.57,78.05
DMI_CRX_PTX_N3: length 38.7
  IN4 w0.102: v2(172.73,99.92) 172.72,99.91 172.72,99.54 172.82,99.44 172.94,99.44 173.04,99.53 173.52,99.53 173.59,99.45
  IN4 w0.114: 173.59,99.45 173.83,99.21 173.83,98.63 188.6,83.87 193.15,83.87 198.42,78.6 198.66,78.6 198.8,78.75 v2(198.8,79.03)
  BOTTOM w0.089: 198.89,78.78 198.89,78.4 199.13,78.16 199.5,78.16 199.86,77.8 UH1.BE18 ; JCPU1.A21 172.26,99.45 v2(172.73,99.92)
  BOTTOM w0.102: v2(198.8,79.03) 198.89,78.94 198.89,78.78
DMI_CRX_PTX_P0: length 46.7
  IN4 w0.089: 173.43,100.31 173.41,100.33 171.47,100.33 171.34,100.21 171.34,98.53 171.12,98.31 170.06,98.31 169.93,98.43 169.81,98.43 169.73,98.36 v2(169.73,97.92)
  IN4 w0.114: v2(196.69,81.21) 196.69,81.2 196.91,80.99 197.04,80.99 197.16,81.11 197.16,81.43 196.27,82.32 196.27,82.49 195.81,82.94 194.73,82.94 193.35,84.33 188.76,84.33 174.3,98.78 174.3,99.43 173.43,100.31
  BOTTOM w0.089: v2(169.73,97.92) JCPU1.D20 ; UH1.BB21 201.66,77.53 201.34,77.85 201.34,78.26 201.14,78.46 200.87,78.46 200.29,79.04 200.29,79.37 199.94,79.72 199.94,79.73 199.9,79.78 199.9,79.78
  BOTTOM w0.102: v2(196.69,81.21) 197.52,81.21 198.18,80.55 199.13,80.55 199.9,79.79 199.9,79.78
DMI_CRX_PTX_P1: length 46.6
  IN4 w0.089: 173.59,101.52 170.35,101.52 170.13,101.3 170.13,99.52 v2(170.73,98.92)
  IN4 w0.114: v2(198.4,79.45) 198.41,79.46 198.41,79.71 198.56,79.86 198.56,80.34 198.33,80.57 198.33,82.11 196.61,83.83 195.18,83.83 193.78,85.23 189.1,85.23 175.2,99.13 175.2,99.94 173.62,101.52 173.59,101.52
  BOTTOM w0.089: UH1.BC20 200.93,77.55 200.59,77.89 200.31,77.89 199.66,78.54 199.66,78.85 199.34,79.18 199.33,79.18 199.31,79.2 ; JCPU1.C20 170.26,98.45 v2(170.73,98.92)
  BOTTOM w0.102: 199.31,79.2 199.28,79.23 199.27,79.23 199.07,79.43 198.41,79.43 v2(198.4,79.45)
DMI_CRX_PTX_P2: length 41.5
  IN4 w0.089: v2(171.73,98.92) 171.65,99 171.65,99.32 171.76,99.43 171.92,99.43 172.12,99.23 172.12,98.67 172.47,98.32 172.94,98.32 173.21,98.05 173.21,98.03 173.25,97.98 173.25,97.96 173.26,97.95
  IN4 w0.114: 173.26,97.95 188.26,82.96 192.82,82.96 195.02,80.76 195.02,80.56 194.91,80.45 194.74,80.45 v2(194.56,80.63)
  BOTTOM w0.089: v2(171.73,98.92) 171.26,98.45 JCPU1.B20 ; 198.53,78.39 199.04,77.89 199.16,77.89 199.75,77.29 200.03,77.29 200.2,77.13 200.2,76.78 200.52,76.46 UH1.BB17
  BOTTOM w0.102: 198.53,78.39 196.71,80.21 196.59,80.33 196.56,80.33 196.33,80.57 196.21,80.69 196.08,80.82 195.01,80.82 194.97,80.78 194.95,80.78 194.8,80.63 v2(194.56,80.63)
DMI_CRX_PTX_P3: length 38.8
  IN4 w0.102: 173.43,99.29 173.41,99.31 173.13,99.31 v2(172.73,98.92)
  IN4 w0.114: 173.43,99.29 173.6,99.12 173.6,98.54 188.5,83.64 193.06,83.64 198.33,78.37 198.75,78.37 199.03,78.65 199.18,78.65 v2(199.27,78.56)
  BOTTOM w0.089: v2(172.73,98.92) 172.26,98.45 JCPU1.A20 ; UH1.BC18 200.5,77.09 200.17,77.42 200.17,77.78 199.39,78.56 v2(199.27,78.56)
DMI_CTX_PRX_N0: length 55.6
  IN4 w0.089: v2(169.73,96.92) 169.73,96.82 169.87,96.69 170.07,96.69 170.13,96.75 170.13,97.14 169.96,97.32 169.37,97.32 169.14,97.55 169.14,102.22 169.43,102.5 173.59,102.5
  IN4 w0.102: v2(202.73,76.51) 202.73,76.73 202.89,76.89 202.89,77.2 202.41,77.68 201.89,77.68 200.68,78.89 200.09,78.89 199.54,79.43
  IN4 w0.114: 173.59,102.5 175.88,100.22 175.88,99.42 189.13,86.17 195.26,86.17 195.52,85.9 195.52,85.02 195.74,84.81 196.57,84.81 199.08,82.3 199.08,80.75 199.21,80.62 199.21,79.77 199.54,79.43
  BOTTOM w0.089: v2(169.73,96.92) 169.26,96.45 JCPU1.D18 ; v2(202.73,76.51) 202.87,76.65 UH1.AW22
DMI_CTX_PRX_N1: length 45.3
  IN4 w0.089: 173.59,96.68 172.95,97.33 171.58,97.33 171.33,97.09 171.33,96.65 171.13,96.44 170.85,96.44 170.73,96.33 v2(170.73,95.92) ; 197.58,76.77 197.6,76.77 197.62,76.78 198.81,76.78 199.33,77.3 201.08,77.3 203.34,75.05 203.34,74.9 203.24,74.8 203.03,74.8 v2(202.92,74.91)
  IN4 w0.114: 173.59,96.68 187.98,82.3 189.99,82.3 192.33,79.95 194.1,79.95 197.28,76.77 197.58,76.77
  BOTTOM w0.089: UH1.AR20 203.1,75.09 v2(202.92,74.91) ; v2(170.73,95.92) 170.26,95.45 JCPU1.C17
DMI_CTX_PRX_N2: length 43.2
  IN4 w0.089: v2(203.16,73.32) 202.82,73.32 202.76,73.25 202.36,73.25 200.27,75.35 197.45,75.35 197.07,74.97 195.87,74.97 195.86,74.96 195.79,74.96 195.78,74.94 195.77,74.94 ; 173.59,94.82 173.08,95.33 172.38,95.33 172.14,95.57 172.14,96.13 172.05,96.22 171.87,96.22 171.73,96.09 v2(171.73,95.92)
  IN4 w0.114: 173.59,94.82 187.5,80.91 189.37,80.91 195.33,74.94 195.77,74.94
  BOTTOM w0.089: v2(171.73,95.92) 171.26,95.45 JCPU1.B17 ; UH1.AP17 203.16,73.96 v2(203.16,73.32)
DMI_CTX_PRX_N3: length 39.8
  IN4 w0.089: 173.48,95.87 173.47,95.88 173.47,95.88 173.15,96.21 173.02,96.21 v2(172.73,95.92) ; v2(202,75.84) 201.62,75.84 201.51,75.73 201.26,75.73 200.31,76.68 199.58,76.68 198.96,76.06 197.07,76.06 196.62,76.51
  IN4 w0.114: 173.48,95.87 187.75,81.6 189.67,81.6 194.31,76.96 196.17,76.96 196.62,76.51
  BOTTOM w0.089: v2(172.73,95.92) 172.26,95.45 JCPU1.A17 ; v2(202,75.84) 202.1,75.93 UH1.AV20
DMI_CTX_PRX_P0: length 55.6
  IN4 w0.089: 173.48,102.29 173.47,102.3 169.51,102.3 169.35,102.13 169.35,97.65 169.33,97.64 169.46,97.52 170.05,97.52 170.33,97.24 170.33,96.66 170.15,96.48 169.79,96.48 169.73,96.42 v2(169.73,95.92)
  IN4 w0.102: v2(202.29,76.96) 202.39,76.85 202.55,76.85 202.67,76.98 202.67,77.11 202.32,77.46 201.8,77.46 200.59,78.67 200,78.67 199.46,79.21 199.45,79.21 199.41,79.26 199.4,79.26 199.38,79.27
  IN4 w0.114: 173.48,102.29 175.65,100.12 175.65,99.33 189.04,85.94 195.16,85.94 195.3,85.81 195.3,84.92 195.64,84.58 196.47,84.58 198.85,82.2 198.85,80.65 198.98,80.52 198.98,79.67 199.38,79.27
  BOTTOM w0.089: JCPU1.D17 169.26,95.45 v2(169.73,95.92) ; UH1.AY22 202.45,77.12 v2(202.29,76.96)
DMI_CTX_PRX_P1: length 45.4
  IN4 w0.089: v2(203.38,74.45) 203.38,74.66 203.54,74.82 203.54,75.13 201.16,77.51 199.25,77.51 198.73,76.99 197.61,76.99 197.59,77 197.58,77 ; 173.59,97.01 173.08,97.52 171.5,97.52 171.13,97.15 171.13,96.73 171.05,96.65 170.85,96.65 170.73,96.76 v2(170.73,96.92)
  IN4 w0.114: 197.58,77 197.37,77 194.19,80.18 192.43,80.18 190.08,82.52 188.08,82.52 173.59,97.01
  BOTTOM w0.089: v2(170.73,96.92) 170.26,96.45 JCPU1.C18 ; UH1.AP20 203.6,74.67 v2(203.38,74.45)
DMI_CTX_PRX_P2: length 43.4
  IN4 w0.089: v2(171.73,96.92) 171.64,96.83 171.64,96.55 171.77,96.43 172.14,96.43 172.33,96.23 172.33,95.66 172.47,95.52 173.21,95.52 173.59,95.14 ; 195.77,75.17 196.99,75.17 197.37,75.55 200.35,75.55 202.45,73.46 202.67,73.46 202.69,73.47 v2(202.69,73.77)
  IN4 w0.114: 173.59,95.14 187.59,81.14 189.46,81.14 195.43,75.17 195.77,75.17
  BOTTOM w0.089: v2(171.73,96.92) 171.26,96.45 JCPU1.B18 ; v2(202.69,73.77) 202.75,73.83 UH1.AR17
DMI_CTX_PRX_P3: length 39.8
  IN4 w0.089: v2(201.54,76.3) 201.54,76.05 201.42,75.93 201.34,75.93 200.39,76.89 199.5,76.89 198.88,76.26 197.19,76.26 196.78,76.67 ; v2(172.73,96.92) 172.73,96.7 173.02,96.41 173.23,96.41 173.56,96.08 173.59,96.08
  IN4 w0.114: 196.78,76.67 196.26,77.19 194.4,77.19 189.76,81.83 187.85,81.83 173.59,96.08
  BOTTOM w0.089: v2(201.54,76.3) 201.6,76.35 202.18,76.35 ; JCPU1.A18 172.26,96.45 v2(172.73,96.92)
DMI_IREF: length 3.8
  TOP w0.102: RH98.1 197.25,77.95 v1(196.32,78.88)
  TOP w0.254: v2(198.55,77.39) 197.76,77.39 RH98.1
  BOTTOM w0.254: UH1.BE16 198.94,77.39 v2(198.55,77.39)
DMI_RCOMP: length 5.1
  TOP w0.089: v1(197.21,74.94) 197.21,75.32 197.88,75.99 RH100.2
  TOP w0.254: RH100.2 198.41,75.46 200.7,75.46 v2(200.85,75.61)
  BOTTOM w0.254: v2(200.85,75.61) 201.07,75.82 UH1.AY17
DMIC0: length 176.2
  TOP w0.102: v2(336.2,172.99) 336.61,172.58 336.96,172.58 336.96,172.59 U74.4 ; v2(317.24,171.14) 317.48,171.39 v1(320.61,171.39) 322.08,171.39 322.32,171.15 v2(322.32,171.14) ; v2(189.94,163.4) 189.38,163.4 189.15,163.17 C1207.1 189.54,162.38 D8.3 191.31,162.38 191.52,162.17 v2(191.52,161.77)
  IN1 w0.102: v2(322.32,171.14) 322.32,171.14 322.41,171.23 323.46,171.23 326.1,173.88 328.65,173.88 329,173.52 335.67,173.52 v2(336.2,172.99)
  IN2 w0.127: v2(317.24,171.14) 317.13,171.14 316.61,171.67 316.61,171.68 315.44,172.85 309.2,172.85 308.91,173.14 303.4,173.14 302.78,172.52 301.55,172.52 300.68,173.39 295.56,173.39 293.27,175.68 289.89,175.68 288.02,173.81 288.02,171.52 287.22,170.73 281.05,170.73 277.92,167.6 277.92,166.47 277.17,165.72 275.98,165.72 273.77,167.93 272.44,167.93 272.21,167.7 272.21,166.93 271.58,166.3 257.61,166.3 256.5,165.19 254.34,165.19 251.01,168.52 v2(235.67,168.52)
  IN4 w0.102: v2(235.67,168.52) 235.28,168.12 233.07,168.12 232.71,168.48 199.74,168.48 198.69,169.53 196.26,169.53 195.75,169.02 195.75,167.54 194.72,166.51 194.72,164.62 193.51,163.4 v2(189.94,163.4)
  BOTTOM w0.102: v2(191.52,161.77) 192.72,160.57 193.94,160.57 194.43,161.06 JCAM1.7
DMIC_CLK: length 182.1
  TOP w0.102: v2(298.5,175.2) 297.73,174.43 295.28,174.43 293.44,176.28 v1(290.81,176.28) 290.01,176.28 288.82,175.08 288.82,171.78 287.51,170.47 280.31,170.47 277.33,167.49 277.33,165.61 276.39,164.67 268.61,164.67 266.75,166.53 243.42,166.53 241.74,168.21 v2(241.74,173.96) ; v2(193.51,162.23) 193.35,162.38 D8.2 192.6,161.62 192.32,161.34 190.38,161.34 C1206.1 189.15,160.02 189.91,160.02 v2(189.95,160.06) ; v2(327.74,175.27) 328.42,175.95 330.4,175.95 331.4,174.94 C989.1 332.25,174.94 333.32,173.88 LE3.2
  IN1 w0.102: v2(189.95,160.06) 189.95,161.51 192.29,163.84 192.29,164.88 193.24,165.84 195.56,165.84 200.85,171.12 200.85,173.38 201.62,174.15 218.11,174.15 219.05,175.09 228.64,175.09 229.58,174.15 241.54,174.15 v2(241.74,173.96)
  IN4 w0.102: v2(327.74,175.27) 324.8,175.27 323.71,176.36 321.24,176.36 320.3,175.42 317.88,175.42 317.23,174.78 314.03,174.78 313.32,174.07 303.48,174.07 301.52,176.03 299.33,176.03 v2(298.5,175.2)
  BOTTOM w0.102: JCAM1.5 194.63,163.06 193.8,162.23 v2(193.51,162.23)
DMIC_CLK_L: length 2.8
  TOP w0.102: LE3.1 335.26,173.59 v1(336.44,173.59) U74.2
DOCK_AC_OFF: length 37.6
  TOP w0.102: PD817.1 151.02,176.06 149.96,174.99 v1(149.96,174.36)
  TOP w0.254: PR844.1 PD817.1 151.21,176.85 v2(150.68,177.38)
  IN2 w0.127: v2(169.27,183.15) 168,183.15 165.57,180.71 165.57,180.33 163.98,178.74 157.22,178.74 155.38,176.9 151.16,176.9 v2(150.68,177.38)
  BOTTOM w0.102: JDOCK1.2 167.25,186.95 167.62,186.58 170.54,186.58 171.56,185.56 171.56,183.91 170.92,183.27 169.4,183.27 v2(169.27,183.15)
DOCK_AC_OFF_EC: length 284
  TOP w0.102: v1(154.06,180.68) 154.06,180.67 153.81,180.42 v4(153.81,178.22) ; v2(271.74,45.93) 271.44,46.23 U46.A63
  TOP w0.254: PR857.2 152.26,174.79 153.2,175.73 PR858.1 153.79,176.67 153.79,178.22 v4(153.81,178.22)
  IN3 w0.254: v2(271.74,45.93) 271.74,45.97 270.81,46.9 269.03,46.9 268,45.87 267.48,45.87 266.94,46.41 266.94,46.47 266.19,47.22 261.97,47.22 260.32,48.87 260.32,51.97 259.67,52.62 259.67,58.35 260.06,58.74 260.06,63.38 262.92,66.24 262.92,75.72 264.01,76.81 264.01,92.84 265.2,94.03 265.2,105.85 265.74,106.4 265.74,109.25 265.18,109.8 265.18,120.42 264.47,121.13 264.47,129.72 265.18,130.43 265.18,134.18 265.21,134.2 265.21,136.98 264.93,137.26 264.93,139.98 263.83,141.08 263.83,142.59 261.63,144.79 261.63,148.88 260.7,149.8 260.7,166.14 259.83,167.01 259.83,173.15 258.54,174.45 254.78,174.45 252.54,176.69 247.17,176.69 246.88,176.4 238.4,176.4 237.45,175.45 232.24,175.45 232.24,175.45 224.61,175.45 224.56,175.5 224.3,175.5 224.29,175.5 222.02,175.5 218.79,172.28 214.69,172.28 213.28,170.87 193.37,170.87 193.25,170.98 187.79,170.98 185.84,169.03 181.56,169.03 180.65,169.94 178.87,169.94 177.97,170.84 174.05,170.84 173.16,171.73 170.96,171.73 170.83,171.86 169.84,171.86 168.9,170.92 168.9,169.41 164.83,165.34 163.53,165.34 163.09,164.91 160.01,164.91 156.93,161.84 v2(156.9,161.84)
  IN4 w0.254: v2(156.9,161.84) 157.08,162.01 157.08,164.08 157.21,164.2 157.21,169.71 156.29,170.62 156.29,173.26 153.81,175.75 v4(153.81,178.22)
DOCK_DCIN_IS+: length 107.9
  TOP w0.254: PQ703.6 112.19,163.21 v4(112.87,163.89)
  IN3 w0.127: v2(202.25,187.49) 201.83,187.07 201.15,187.07 198.85,184.77 193.84,184.77 192.56,183.48 190.87,183.48 190.01,184.35 187.61,184.35 186.02,182.77 185.9,182.64 183.05,182.64 182.78,182.37 181.86,182.37 180.82,183.41 178.62,183.41 178.41,183.63 174.3,183.63 173.07,182.4 173.07,181.93 172.83,181.69 172.49,181.69 172.43,181.62 170.56,181.62 170.14,181.2 169.62,181.2 166.86,178.45 163.74,178.45 162.89,177.59 162.89,176.96 162.42,176.49 161.9,176.49 159.89,174.49 157.99,174.49 156.05,172.55 156.05,171.89 155.51,171.34 155.51,170.38 154.64,169.52 154.64,168.4 151.81,165.56 149.41,165.56 149.41,165.56 148.46,165.56 146.25,163.35 141.54,163.35 140.9,163.98 132.81,163.98 131.96,164.83 122.44,164.83 122.22,165.05 114.03,165.05 v4(112.87,163.89)
  BOTTOM w0.102: v2(202.25,187.49) JDOCK1.134
  BOTTOM w0.127: v4(112.87,163.89) 112.87,163.51 v1(112.63,163.27)
DOCK_DCIN_IS-: length 108
  TOP w0.254: v4(114.45,163.86) 114.41,163.86 114.09,163.54 PQ703.4
  IN3 w0.254: v4(114.45,163.86) 114.45,163.59 114.96,163.08 118.85,163.08 119.72,163.94 121.22,163.94 121.56,163.6 126.63,163.6 126.75,163.47 136.81,163.47 137,163.66 140.73,163.66 141.37,163.03 146.38,163.03 148.59,165.24 149.28,165.24 152.97,165.24 154.96,167.23 154.96,169.39 155.82,170.25 155.82,171.21 156.37,171.75 156.37,172.42 157.48,173.53 159.39,173.53 162.03,176.17 162.55,176.17 163.2,176.83 163.2,177.46 163.87,178.13 167.88,178.13 170.99,181.24 172.49,181.24 172.62,181.37 172.96,181.37 173.39,181.8 173.39,182.27 174.43,183.31 178.21,183.31 178.47,183.06 180.68,183.06 181.68,182.05 185.76,182.05 187.74,184.04 189.87,184.04 190.74,183.17 192.69,183.17 193.85,184.33 198.86,184.33 201.29,186.75 202.53,186.75 v2(202.75,186.97)
  BOTTOM w0.127: v1(114.6,164.6) 114.45,164.45 v4(114.45,163.86)
  BOTTOM w0.254: JDOCK1.136 v2(202.75,186.97)
DOCK_DET#: length 443.6
  TOP w0.102: v2(219.32,189.19) 219.03,189.19 218.14,190.08 206.4,190.08 205.64,189.32 R755.1 199.75,189.32 198.48,190.59 197.85,190.59 197.23,189.97 197.23,189.12 196.57,188.46 196.57,187.71 194.29,185.43 194.29,182.81 194.78,182.32 194.78,181.69 196.07,180.39 196.07,179.25 196.5,178.83 v2(196.72,178.83) ; U46.B41 264.01,53.64 264.04,53.62 264.51,53.62 v2(264.96,53.17)
  TOP w0.254: PR886.2 58.8,176.12 v2(59.08,176.4) 58.8,176.68 58.8,177.42 PR887.2 ; PQ817.2 71.21,175.55 70.9,175.87 70.9,177.41 v1(72.73,179.23) 73.13,179.64 73.13,180.77 v2(73.63,181.27) ; PU809.2 v2(36.55,175.72)
  IN1 w0.102: v2(196.72,178.83) 196.79,178.75 196.79,173.74 v2(197,173.53)
  IN3 w0.127: v2(197,173.53) 197.81,172.72 200.48,172.72 200.97,173.22 203.96,173.22 204.03,173.29 213.97,173.29 214.03,173.35 218.34,173.35 220.9,175.91 221.69,176.71 224.25,176.71 224.46,176.71 224.88,176.71 225.06,176.53 225.45,176.53 232.68,176.53 235.72,176.53 236.83,177.63 246.58,177.63 246.72,177.77 253.14,177.77 254.54,176.38 258.7,176.38 261.76,173.32 261.76,171.5 262.03,171.22 262.03,150.36 262.96,149.43 262.96,145.34 265.16,143.14 265.16,141.63 266.37,140.43 266.37,138.78 266.9,138.25 266.9,128.85 266.09,128.04 266.09,121.92 266.66,121.35 266.66,117.97 267.25,117.39 267.25,105.29 266.54,104.59 266.54,94.47 266.54,93.45 266.43,93.33 266.43,76.09 264.77,74.43 264.77,66.2 261.39,62.83 261.39,59.59 262.17,58.81 262.17,58.28 262.27,58.18 262.27,56.81 261.6,56.15 261.48,56.15 261.01,55.68 261.01,54.74 261.58,54.17 263.16,54.17 263.72,53.6 264.53,53.6 v2(264.96,53.17) ; v2(196.72,178.83) 196.48,178.83 196.06,179.25 194.13,179.25 193.67,179.25 192.94,178.52 191.91,178.52 190.47,177.08 187.42,177.08 186.43,176.1 184.41,176.1 184.29,175.97 182.61,175.97 182.07,176.52 180.89,176.52 180.7,176.33 179.45,176.33 178.91,176.86 172.21,176.86 170.59,175.24 168.36,175.24 167.46,174.33 166.75,174.33 164.07,171.65 159.29,171.65 157.68,170.04 157.68,165.27 156.32,163.91 155.63,163.91 154.45,162.72 148.6,162.72 147.97,162.73 146.99,161.75 140.76,161.75 140.19,162.32 138.23,162.32 137.9,161.99 128.04,161.99 126.79,160.73 125.64,160.73 125.36,161.01 125.36,161.35 125.27,161.44 124.18,161.44 123.58,162.04 121.32,162.04 120.91,161.63 116.13,161.63 115.02,160.53 111.76,160.53 110.55,161.74 110.55,165.15 108.97,166.73 102.46,166.73 102.08,167.11 89.98,167.11 88.46,168.63 88.14,168.63 85.26,171.5 85.26,172.24 81.47,176.03 77.95,176.03 74.74,179.25 74.74,180.21 73.68,181.27 v2(73.63,181.27)
  IN4 w0.254: v2(59.08,176.4) 58.12,175.45 46.59,175.45 46.49,175.55 36.71,175.55 v2(36.55,175.72)
  BOTTOM w0.102: D32.2 219.06,188.92 v2(219.32,189.19)
  BOTTOM w0.254: v2(73.63,181.27) 72.69,181.27 70.73,179.31 68.19,179.31 67.67,178.79 61.36,178.79 59.08,176.5 v2(59.08,176.4)
DOCK_DET_R#: length 21
  BOTTOM w0.102: D32.1 v1(216.33,184.57) 214.28,184.57 211.34,187.52 206.98,187.52 206.12,188.38 206.12,189.7 205.84,189.98 204.92,189.98 204.75,189.81 JDOCK1.144 204.75,187.76 204.68,187.69 204.38,187.69 204.25,187.82 JDOCK1.142
DOCK_HP_DET: length 178.5
  TOP w0.102: v2(274.99,51.62) 274.54,52.07 274.23,52.07 274.04,51.89 U46.A7 ; v2(325.18,155.28) 326.12,155.28 328.16,153.24 330.59,153.24 333.51,156.16 333.51,159.36 333.5,159.37 333.5,167.33 v2(333.48,167.35)
  IN1 w0.102: v2(318.3,154.72) 318.37,154.65 318.37,148.46 316.59,146.68 316.59,146.25 312.15,141.81 311.03,141.81 v2(310.6,142.24)
  IN2 w0.127: v2(342.63,164.53) 340.6,166.56 334.65,166.56 333.87,167.35 v2(333.48,167.35)
  IN4 w0.102: v2(274.99,51.62) 275.69,52.32 275.87,52.32 276.22,52.68 276.22,54.66 276.67,55.11 278.78,55.11 281.25,57.58 281.25,65.19 278.87,67.57 278.87,91.51 283.02,95.66 283.02,97.57 283.58,98.13 283.64,98.13 287.04,101.54 288.59,101.54 290,102.95 298.88,102.95 302.38,106.44 303.61,106.44 310.38,113.22 310.38,142.02 v2(310.6,142.24) ; v2(318.3,154.72) 318.88,154.14 324.09,154.14 325.1,155.16 325.1,155.21 v2(325.18,155.28)
  BOTTOM w0.102: 340.91,161.81 341.65,161.81 342.65,162.81 v1(342.65,163.31) 342.65,164.48 342.63,164.5 v2(342.63,164.53) R1081.2
DOCK_LOM_ACTLED_YEL#: length 133.1
  TOP w0.102: U32.19 308.57,201.82 v2(309.08,202.32) ; v2(279.55,190.42) v1(278.96,190.42)
  IN1 w0.102: v2(279.55,190.42) 279.28,190.16 278.64,190.16 278.54,190.26 276.65,190.26 276.2,189.81 269.48,189.81 268.13,191.16 257.72,191.16 256.7,190.14 243.12,190.14 241.73,191.54 234.67,191.54 233.9,190.78 210.04,190.78 209.56,191.26 194.88,191.26 194.04,190.42 v2(194.04,190.26)
  IN3 w0.127: v2(309.08,202.32) 307.75,201 297.8,201 296.27,199.48 296.27,193.13 291.82,188.67 280.07,188.67 279.59,189.15 279.59,190.39 v2(279.55,190.42)
  BOTTOM w0.102: JDOCK1.100 193.75,189.97 v2(194.04,190.26)
DOCK_LOM_SPD10LED_GRN#: length 157.4
  TOP w0.102: v2(296.87,202.12) 296.87,202.16 297.03,202.32 U32.40
  IN3 w0.127: v2(166.87,191.1) 167.09,191.31 167.71,191.31 169.52,189.51 175.43,189.51 176.44,190.51 176.44,191.52 v2(176.27,191.68)
  IN4 w0.102: v2(176.27,191.68) 176.59,192 209.81,192 210.51,191.3 217.52,191.3 217.98,191.76 225.81,191.76 226.22,191.35 233.7,191.35 234.21,191.86 242.1,191.86 243.4,190.55 244.29,190.55 245.77,192.02 273.85,192.02 274.87,191 281.99,191 282.74,191.74 293.26,191.74 295.18,193.66 295.18,200.89 296.11,201.82 296.57,201.82 v2(296.87,202.12)
  BOTTOM w0.102: JDOCK1.3 167.75,182.82 166.89,183.68 166.89,186.92 166.33,187.48 166.33,189.97 166.92,190.56 166.92,191.05 v2(166.87,191.1) ; v2(296.87,202.12) v1(296.1,202.12)
DOCK_LOM_SPD100LED_ORG#: length 157.6
  TOP w0.102: U32.20 308.39,202.32 v2(308.45,202.39)
  IN1 w0.102: v2(167.46,190.89) 168.08,190.27 177.26,190.27 177.62,190.63 178.95,190.63 179.9,191.58 209.57,191.58 210.11,191.03 233.8,191.03 234.56,191.8 241.8,191.8 243.23,190.37 256.43,190.37 257.51,191.45 273.53,191.45 273.95,191.03 279.57,191.03 v2(280.17,190.44)
  IN3 w0.127: v2(280.17,190.44) 280.17,189.75 280.8,189.12 291.91,189.12 296.02,193.23 296.02,199.68 297.65,201.31 307.43,201.31 308.45,202.34 v2(308.45,202.39)
  BOTTOM w0.102: v2(167.46,190.89) 167.46,190.18 167.75,189.89 JDOCK1.4
DOCK_LOM_TRD0+: length 122.7
  TOP w0.089: v2(299.55,205.24) 299.62,205.17 U32.36
  IN2 w0.089: v2(194.7,190.2) 195.05,190.55 195.05,191.27 195.36,191.58 209.52,191.58 210,191.09 211.13,191.09 233.96,191.09 234.46,191.09 235.38,192.01 242.06,192.01 243.44,190.63 244.55,190.63 245.93,192.01 273.78,192.01 274.29,191.5 281.8,191.5 282.29,192 293.34,192 294.89,193.55 294.89,203.18 295.68,203.97 299.24,203.97 299.55,204.28 v2(299.55,205.24)
  BOTTOM w0.089: v2(194.7,190.2) 194.88,190.02 194.88,189.84 194.75,189.71 JDOCK1.104
DOCK_LOM_TRD0-: length 122.7
  TOP w0.089: U32.35 300.12,204.31 300.03,204.4 300.03,205.1 v2(300.16,205.22)
  IN2 w0.089: v2(300.16,205.22) 300.11,205.22 299.78,204.89 299.78,204.18 299.34,203.74 295.77,203.74 295.12,203.09 295.12,193.46 293.43,191.77 282.39,191.77 281.89,191.27 274.2,191.27 273.69,191.78 246.03,191.78 244.64,190.4 243.35,190.4 241.96,191.78 235.48,191.78 234.56,190.86 233.87,190.86 211.04,190.86 209.91,190.86 209.42,191.35 195.45,191.35 195.28,191.18 v2(195.28,190.2)
  BOTTOM w0.089: JDOCK1.106 195.25,189.7 195.17,189.78 195.17,190.09 v2(195.28,190.2)
DOCK_LOM_TRD1+: length 123.4
  TOP w0.089: v2(301.64,204.95) 301.84,204.74 301.84,204.53 301.62,204.3 U32.32
  IN2 w0.089: v2(301.64,204.95) 301.44,205.14 301.3,205.14 301.2,205.04 301.2,201.96 299.28,200.04 297.61,200.04 296.74,199.17 296.74,192.78 293.89,189.93 282.91,189.93 282.43,189.45 260.57,189.45 259.86,190.16 248.59,190.16 247.77,189.34 242.72,189.34 241.91,190.16 235.87,190.16 235.29,189.58 225.3,189.58 224.43,188.71 224.24,188.71 220.53,188.71 219.59,189.65 209.95,189.65 209.88,189.72 206.15,189.72 205.35,188.92 196.93,188.92 196.57,189.29 196.57,189.74 v2(196.21,190.09)
  BOTTOM w0.089: v2(196.21,190.09) 196.41,189.89 196.41,189.83 196.25,189.66 JDOCK1.110
DOCK_LOM_TRD1-: length 123.4
  TOP w0.089: v2(302.14,205.35) 302.14,203.81 U32.31
  IN2 w0.089: v2(302.14,205.35) 302.11,205.37 301.21,205.37 300.97,205.14 300.97,202.06 299.18,200.27 297.51,200.27 296.52,199.27 296.52,192.88 293.8,190.16 282.82,190.16 282.34,189.67 260.67,189.67 259.96,190.39 248.49,190.39 247.68,189.57 242.81,189.57 242,190.39 235.78,190.39 235.2,189.8 225.2,189.8 224.34,188.94 220.63,188.94 219.69,189.88 210.05,189.88 209.97,189.95 206.05,189.95 205.25,189.15 197.03,189.15 196.79,189.39 v2(196.79,190.09)
  BOTTOM w0.089: v2(196.79,190.09) 196.75,190.05 JDOCK1.112
DOCK_LOM_TRD2+: length 124.7
  TOP w0.089: U32.27 304.12,204.36 304.22,204.46 304.22,204.92 v2(304.12,205.01)
  IN2 w0.089: v2(304.12,205.01) 304.26,204.87 304.26,203.62 300.85,200.2 300.85,196.74 299.07,194.96 299.07,191.4 297.52,189.85 295.44,189.85 293.95,188.37 292.91,188.37 292.72,188.56 266.21,188.56 265.93,188.28 260.56,188.28 259.53,189.31 249.25,189.31 248.39,188.44 242.37,188.44 241.49,189.32 236.53,189.32 235.9,188.7 226.21,188.7 225.05,187.54 219.93,187.54 218.78,188.7 217.51,188.7 v2(217.42,188.79)
  BOTTOM w0.089: JDOCK1.122 199.25,189.91 199.3,189.96 199.3,190.93 200.37,192.01 209.97,192.01 210.74,191.24 211.32,191.24 213.86,188.7 217.33,188.7 v2(217.42,188.79)
DOCK_LOM_TRD2-: length 124.7
  TOP w0.089: v2(304.71,204.99) 304.62,204.9 U32.26
  IN2 w0.089: v2(217.42,188.2) 217.69,188.47 218.68,188.47 219.84,187.31 225.15,187.31 226.3,188.47 236,188.47 236.62,189.09 241.4,189.09 242.28,188.21 248.48,188.21 249.35,189.08 259.43,189.08 260.46,188.05 266.02,188.05 266.3,188.33 292.63,188.33 292.82,188.14 294.04,188.14 295.53,189.62 297.61,189.62 299.3,191.31 299.3,194.86 301.07,196.64 301.07,200.11 304.49,203.52 304.49,204.76 v2(304.71,204.99)
  BOTTOM w0.089: v2(217.42,188.2) 217.22,188.4 213.74,188.4 211.2,190.94 210.62,190.94 209.85,191.72 200.49,191.72 199.59,190.81 199.59,190.08 199.75,189.92 JDOCK1.124
DOCK_LOM_TRD3+: length 128.6
  TOP w0.089: U32.23 306.12,204.39 306.21,204.48 306.21,204.92 v2(306.17,204.96)
  IN2 w0.089: v2(306.17,204.96) 306.37,204.76 306.37,204.62 305.81,204.06 305.81,202.19 303.12,199.49 303.12,197.42 302.37,196.67 302.37,193.46 301.32,192.41 300.74,192.41 300.22,191.9 300.22,191.1 296.15,187.03 285.94,187.03 285.02,186.12 280.81,186.12 279.71,187.21 266.92,187.21 266.63,186.92 259.89,186.92 259.56,187.25 258.73,187.25 258.03,187.95 251.3,187.95 250.19,186.84 235.95,186.84 231.2,182.09 228.84,182.09 226.69,184.24 219.87,184.24 216.8,187.31 215.67,187.31 v2(215.59,187.39)
  BOTTOM w0.089: JDOCK1.128 200.75,189.91 200.82,189.98 200.82,190.45 201.36,191 209.39,191 210.27,190.11 211,190.11 213.88,187.24 215.44,187.24 v2(215.59,187.39)
DOCK_LOM_TRD3-: length 128.7
  TOP w0.089: v2(306.79,204.97) 306.62,204.8 U32.22
  IN2 w0.089: v2(306.79,204.97) 306.6,204.77 306.6,204.52 306.04,203.96 306.04,202.09 303.35,199.4 303.35,197.33 302.6,196.58 302.6,193.37 301.41,192.19 300.84,192.19 300.45,191.8 300.45,191.01 296.25,186.8 286.03,186.8 285.12,185.89 280.71,185.89 279.62,186.98 267.02,186.98 266.73,186.69 259.79,186.69 259.46,187.02 258.63,187.02 257.93,187.72 251.39,187.72 250.29,186.61 236.05,186.61 231.3,181.87 231.28,181.87 228.74,181.87 226.6,184.01 219.78,184.01 216.7,187.08 215.9,187.08 215.62,186.8 v2(215.59,186.8)
  BOTTOM w0.089: JDOCK1.130 201.25,189.78 201.11,189.91 201.11,190.33 201.48,190.7 209.27,190.7 210.15,189.82 210.88,189.82 212.74,187.96 213.76,186.94 215.45,186.94 v2(215.59,186.8)
DOCK_MIC_DET: length 210.1
  TOP w0.102: v2(271.28,51.73) 271.69,52.14 U46.B8
  IN1 w0.102: v2(312.52,134.82) 314.21,136.51 314.21,136.55 319.34,141.69 319.34,142.79 324.47,147.92 324.47,150.06 327.17,152.76 329.27,152.76 330.7,154.19 333.73,154.19 v2(333.89,154.36)
  IN2 w0.127: v2(333.89,154.36) 334.64,154.36 335.19,154.9 335.19,164.5 335.75,165.06 338.79,165.06 339.4,164.45 339.4,163.47 339.92,162.95 v2(339.92,161.43) 340.28,161.79 344.66,161.79 345.32,162.45 345.32,162.97 345,163.28 v2(344.78,163.28) ; v2(273.3,130.34) 273.3,130.21 273.58,129.93 274.08,129.93 274.72,130.57 282.66,130.57 282.95,130.86 285.43,130.86 285.77,131.2 286.9,131.2 290.17,134.47 292.21,134.47 292.49,134.19 307.15,134.19 307.87,134.91 312.43,134.91 v2(312.52,134.82)
  BOTTOM w0.102: v2(344.78,163.28) 344.58,163.47 344.58,164.17 344.28,164.48 R1082.2 ; 339.01,161.81 339.54,161.81 v2(339.92,161.43) ; v2(273.3,130.34) 273.15,130.34 272.37,129.57 272.37,127.53 272.09,127.25 272.09,126.8 264.23,118.93 264.23,118.75 264.23,114.06 258.46,108.29 257.84,108.29 257.18,107.63 257.18,106.82 256.89,106.53 256.89,81.24 257.44,80.7 257.44,74.89 259.16,73.16 259.16,64 259.64,63.52 259.64,58.85 259.39,58.61 259.39,56.19 260.7,54.88 260.7,51.52 261.01,51.22 261.85,51.22 263.06,50.01 263.06,48.54 264.7,46.9 264.7,46.47 265.12,46.05 265.54,46.05 265.78,45.81 266.56,45.81 267.27,46.51 267.27,46.85 267.93,47.51 v1(268.64,47.51) 270.66,47.51 270.87,47.73 270.87,51.32 v2(271.28,51.73)
DOCK_POR_RST#: length 172
  TOP w0.102: R881.2 289.62,123.38 290.06,122.94 290.06,122 C737.1 289.61,121.13 289.13,120.66 v2(289.13,120.14) 289.22,120.06 U51.A21 ; v2(205.49,188.05) 205.49,188.85 206.5,189.85 218.04,189.85 219.22,188.67 226.51,188.67 228.09,190.26 240.04,190.26 242.76,187.54 247.58,187.54 248.67,188.63 250.92,188.63 251.86,187.69 251.86,182.18 254.43,179.62 254.43,176.89 254.43,175.75 253.87,175.2 v1(253.87,171.97) 253.87,170.27 253.69,170.09 252.59,170.09 252.34,170.33 252.32,170.33 v2(252.28,170.37)
  IN2 w0.127: v2(255.42,120.23) 256.04,120.85 261.62,120.85 261.96,121.2 271.06,121.2 272.47,122.61 276.35,122.61 276.59,122.85 277.88,122.85 278.06,122.67 279.21,122.67 279.57,123.04 280.24,123.04 281.23,124.03 282.72,124.03 283.03,124.35 285.04,124.35 285.52,123.86 285.61,123.86 285.83,123.64 286.4,123.64 286.64,123.4 286.64,122.98 287.05,122.57 287.43,122.57 289.13,120.87 v2(289.13,120.14)
  IN3 w0.127: v2(252.28,170.37) 252.32,170.33 252.54,170.33 253.37,169.49 253.37,162.98 253.96,162.39 253.96,158.46 255.74,156.68 255.74,136.53 254.63,135.42 254.63,131.22 255.57,130.28 255.57,128.56 255.17,128.16 254.64,128.16 254.35,127.87 254.35,124.55 255.42,123.49 v2(255.42,120.23)
  BOTTOM w0.102: JDOCK1.140 203.75,187.53 204.15,187.13 205.08,187.13 205.49,187.55 v2(205.49,188.05)
DOCK_PSID: length 56.1
  IN4 w0.102: v2(202.33,179.43) 201.09,180.67 195.69,180.67 194.92,179.9 190.6,179.9 189.81,179.11 189.15,179.11 188.74,178.7 188.1,178.7 187.86,178.94 187.86,179.19 186.33,180.72 182.3,180.72 180.83,179.25 179.27,179.25 177.87,180.64 167.79,180.64 167.17,180.02 166.34,180.02 165.77,179.45 161.93,179.45 161.24,180.14 159.03,180.14 v2(158.73,179.84)
  BOTTOM w0.102: v2(202.33,179.43) 202.33,179.45 202.69,179.81 202.69,179.82 202.75,179.88 JDOCK1.135
  BOTTOM w0.254: PU1.1 154.68,176.3 155.2,176.82 155.2,178.15 v1(156.03,178.98) 157.36,178.98 158.22,179.84 v2(158.73,179.84)
DOCK_PWR_BTN#: length 175
  TOP w0.102: R825.2 C733.1 297.11,107.25 v2(296.85,106.99) 297.03,106.99 v1(297.51,106.51)
  IN3 w0.127: v2(203.59,179.46) 203.59,179.21 203.68,179.12 205.09,179.12 205.93,178.28 210.99,178.28 213.46,180.75 217.06,180.75 218.92,182.6 227.77,182.6 228.38,181.98 231.29,181.98 235.02,185.71 245.11,185.71 245.59,186.19 248,186.19 248.22,185.97 252.41,185.97 253.49,184.89 263.59,184.89 269.61,178.87 270.15,178.87 270.34,178.67 270.35,178.67 271.32,177.69 271.32,176.18 271.65,175.85 271.65,174.61 271.06,174.02 271.06,171.98 270.91,171.83 270.91,168.09 270.58,167.76 270.58,149.68 269.95,149.04 269.95,147.57 272.35,145.17 272.47,145.17 274.58,143.05 274.58,135.75 274.7,135.64 274.7,111.13 276.47,109.36 278.02,109.36 281.44,105.93 287.36,105.93 288.85,107.42 290.6,107.42 290.81,107.2 293.76,107.2 294.39,107.84 296.01,107.84 v2(296.85,106.99)
  BOTTOM w0.102: v2(203.59,179.46) 203.75,179.62 JDOCK1.139
DOCK_PWR_SW#: length 11
  TOP w0.102: U51.A63 290.72,107.98 291.06,107.63 v2(291.3,107.63) ; R819.2 295.26,108.93 C734.1 295.33,108.85 R825.1 296.2,109.05 v2(296.74,109.6) 296.99,109.6 v1(297.33,109.94)
  IN2 w0.127: v2(291.3,107.63) 291.3,107.72 292.67,109.09 296.24,109.09 v2(296.74,109.6)
DOCK_SMB_ALERT#: length 407.1
  TOP w0.102: v2(98.32,169.02) 99.39,170.09 99.39,172.79 99.77,173.17 99.77,177.67 100.62,178.52 106.65,178.52 108.39,180.27 PQ7.3 ; v4(165.02,176.12) 164.91,176.24 PR852.2 ; U46.A51 265.44,46.61 v2(265.29,46.46) 264.35,45.52 264.35,44.89 R762.2 ; v2(219.77,171.68) v1(219.77,172.22)
  TOP w0.254: v2(68.52,178.7) 68.34,178.52 PD819.2
  IN3 w0.127: v4(165.02,176.12) 167.32,176.12 167.79,176.59 169.6,176.59 171.71,178.7 172.14,178.7 173.26,179.82 173.91,179.82 174.46,180.37 178.44,180.37 179.01,179.79 180.96,179.79 181.85,180.68 185.57,180.68 188.03,183.15 189.51,183.15 190.36,182.3 193.09,182.3 193.75,182.96 196.08,182.96 197.23,181.81 201.16,181.81 v2(201.82,182.47) ; v2(265.29,46.46) 263.7,46.46 262.87,45.63 262.2,45.63 259.42,48.41 259.42,51.36 258.85,51.93 258.85,53.27 258.19,53.93 258.19,55.6 258.85,56.26 258.85,58.69 259.04,58.89 259.04,63.52 261.32,65.81 261.32,67.48 262.1,68.26 262.1,76.06 263.18,77.15 263.18,96.18 264.21,97.21 264.21,119.79 263.46,120.54 263.46,130.04 263.25,130.24 263.25,142.35 261.06,144.55 261.06,148.64 260.13,149.57 260.13,165.8 259.2,166.73 259.2,172.89 258.36,173.72 253.88,173.72 253.04,174.56 248.13,174.56 247.04,175.65 238.57,175.65 237.72,174.8 224.36,174.8 224.29,174.87 222.46,174.87 219.77,172.17 v2(219.77,171.68)
  IN4 w0.102: v2(201.82,182.47) 203.96,182.47 205.52,180.91 205.52,179.62 v2(205.37,179.46)
  BOTTOM w0.102: v2(219.77,171.68) 219.7,171.75 219.16,171.75 218.53,172.38 212.3,172.38 205.52,179.16 205.51,179.16 205.37,179.3 v2(205.37,179.46) ; v4(165.02,176.12) 166.01,175.13 166.01,165.95 165.44,165.38 162.18,165.38 160.69,163.89 158.82,163.89 157.03,165.68 155.94,165.68 155.39,165.14 155.39,159.37 154.95,158.93 144.4,158.93 141.47,161.86 130.72,161.86 128.42,164.16 122.03,164.16 121.34,164.85 117.72,164.85 117.53,164.66 116.47,164.66 115.93,165.19 115.93,168.81 115.73,169.01 110.69,169.01 105.67,163.99 99.42,163.99 98.32,165.1 v2(98.32,169.02) 96.76,170.59 83.9,170.59 83.01,171.48 77.99,171.48 70.76,178.7 v2(68.52,178.7) ; JDOCK1.133 202.25,181.97 201.82,182.4 v2(201.82,182.47)
DOCK_SMB_ALERT#_C2: length 2.7
  TOP w0.203: PU808.18 162.8,176.47
  TOP w0.254: 162.8,176.47 v1(163.18,176.85) 163.99,177.66 PR852.1
DOCK_SMB_CLK: length 181.9
  TOP w0.102: v2(298.99,111.05) 298.76,111.05 R841.2 ; v2(291.36,111.64) 291.59,111.41 U51.B4
  IN1 w0.102: v2(281.29,172.92) 281.12,172.76 281.12,172.76 280.51,172.15 280.23,172.15 279.98,171.9 276.68,171.9 276.23,171.45 276.23,169.37 276.46,169.15 276.46,168.53 275.1,167.18 275.1,154.6 275.53,154.17 275.53,146.41 277.73,144.21 277.73,137.7 278,137.43 278,133.43 278.82,132.6 278.82,130.57 279.37,130.02 279.37,115.57 280.08,114.86 280.25,114.86 280.33,114.95 281.53,114.95 282.34,114.14 282.34,113.89 282.92,113.31 284.42,113.31 285.1,112.64 289.75,112.64 290.28,112.11 290.28,111.48 290.56,111.2 290.93,111.2 v2(291.36,111.64)
  IN2 w0.127: v2(200.57,179.1) 200.57,178.9 201.32,178.16 211.36,178.16 212.86,179.65 225.09,179.65 226.31,178.44 234.2,178.44 237.08,181.32 247.56,181.32 248.37,180.5 251.59,180.5 252.67,181.59 252.67,181.57 252.94,181.84 259.34,181.84 260.92,183.41 263.09,183.41 266.93,179.57 277.26,179.57 281.06,175.76 281.06,173.97 281.48,173.55 281.48,173.11 v2(281.29,172.92)
  IN3 w0.127: v2(291.36,111.64) 291.49,111.76 294.78,111.76 295.32,112.31 297.73,112.31 v2(298.99,111.05)
  BOTTOM w0.102: JDOCK1.127 200.75,179.76 200.75,179.75 200.75,179.27 v2(200.57,179.1)
DOCK_SMB_DAT: length 176.6
  TOP w0.102: U51.A3 293.2,111.16 293.48,110.88 293.85,110.88 v2(294.31,111.34) 294.74,111.77 R838.2
  IN1 w0.102: v2(281.29,172.34) 280.87,171.92 280.32,171.92 280.07,171.67 276.78,171.67 276.46,171.36 276.46,169.47 276.68,169.25 276.68,168.43 275.33,167.08 275.33,154.69 275.76,154.26 275.76,146.5 277.96,144.3 277.96,137.8 278.23,137.53 278.23,133.52 279.05,132.7 279.05,130.66 279.6,130.12 279.6,115.66 280.09,115.18 281.62,115.18 282.56,114.24 282.56,113.99 283.02,113.54 284.52,113.54 285.19,112.86 289.85,112.86 290.65,112.06 291.89,112.06 293.04,110.92 294.1,110.92 294.31,111.12 v2(294.31,111.34)
  IN2 w0.127: v2(201.15,179.1) 201.15,178.68 201.42,178.41 211.26,178.41 212.75,179.91 225.2,179.91 226.41,178.69 234.09,178.69 236.97,181.57 247.71,181.57 248.52,180.76 251.48,180.76 252.41,181.69 252.81,182.09 259.24,182.09 260.81,183.67 263.19,183.67 267.04,179.82 277.36,179.82 281.31,175.87 281.31,174.08 281.73,173.66 281.73,172.65 281.43,172.35 281.3,172.35 v2(281.29,172.34)
  BOTTOM w0.102: JDOCK1.129 201.25,179.76 200.97,179.48 200.97,179.27 v2(201.15,179.1)
DOCKED: length 198.6
  TOP w0.102: v2(262.03,53.72) 262.04,53.72 262.2,53.89 U46.A38 ; v1(320.37,168.99) 320.38,168.99 320.76,168.61 v2(321.28,168.61) ; U32.13 304.62,199.17 v2(305.21,198.58)
  IN1 w0.102: v2(262.03,53.72) 262.15,53.61 265.18,53.61 266.54,54.97 269.54,54.97 269.93,55.36 269.93,56.9 270.57,57.53 271.12,57.53 274.95,61.36 274.95,63.54 276.17,64.76 276.17,92.15 286.5,102.48 305.64,102.48 309.28,106.11 309.28,127.43 310.09,128.24 310.09,136.98 320.25,147.14 320.25,153.65 320.87,154.27 320.87,160.06 321.15,160.34 321.15,168.48 v2(321.28,168.61)
  IN3 w0.127: v2(321.28,168.61) 321.65,168.97 321.65,170.99 321.41,171.23 321.41,173.94 319.58,175.77 319.58,182.49 319.13,182.93 319.13,187.6 316.16,190.58 316.16,192.9 312.56,196.49 310.36,196.49 309.03,197.82 306.41,197.82 305.65,198.58 v2(305.21,198.58)
DP_HDMI_HPD: length 11.2
  TOP w0.102: U46.B4 272.54,50.14 272.27,50.41 271.88,50.41 v2(271.44,49.97) ; R1154.2 279.28,49.92 v2(278.84,50.37) 278.71,50.24 T130.1
  IN2 w0.127: v2(271.44,49.97) 271.89,50.42 273.31,50.42 273.86,49.87 276.11,49.87 276.82,50.58 278.62,50.58 v2(278.84,50.37)
DPC_CA_DET: length 63.7
  IN1 w0.102: v4(167.75,187.08) 168.03,186.8 169.52,186.8 169.53,186.82 173.87,186.82 174.48,186.21 177.25,186.21 177.63,185.83 177.63,184.82 179.8,182.65 188.57,182.65 188.87,182.35 188.87,181.57 189.67,180.77 190.23,180.77 193.97,177.03 193.97,176.03 194.72,175.28 v2(194.72,174.24) 194.46,173.98 194.46,171.83 v2(194.25,171.62)
  IN2 w0.127: v2(203.22,176.86) 203.22,176.77 202.88,176.43 200.47,176.43 200.31,176.58 198.59,176.58 197.16,175.16 195.64,175.16 v2(194.72,174.24)
  BOTTOM w0.102: R492.2 194.42,176.47 195.02,176.47 195.26,176.22 195.26,175.3 194.72,174.76 v2(194.72,174.24) 194.25,173.77 193.8,173.77 193.15,173.11 U20.4 ; JDOCK1.6 168.25,187.58 v4(167.75,187.08) ; v2(203.22,176.86) 203.94,176.14 v1(203.94,175.72) 203.94,175.53 203.61,175.2 U21.2 201.94,175.2 201.71,174.97 201.71,174.43 201.99,174.15 201.99,173.6 202.2,173.38 Q5.2 ; U20.1 193.87,171.16 194.25,171.55 v2(194.25,171.62)
DPC_CA_DET#: length 9.6
  BOTTOM w0.102: U20.10 199.25,173.76 199.51,173.49 199.78,173.49 v1(199.83,173.55) 199.83,174.37 200.01,174.55 U21.4 201.27,174.55 201.66,174.15 201.66,172.86 201.53,172.73 Q5.1 200.44,172.73 R415.2 199.27,172.12 198.96,171.81 U20.13
DPC_CPU_LANE_N0: length 90.6
  TOP w0.102: C680.1 168.87,187.49 168.87,186.97 169.58,186.27 170.64,186.27 172.2,184.7 v4(172.2,183.9) 172.2,182.28 v2(172.39,182.1)
  IN1 w0.089: v2(156.56,112.89) 156.52,112.89 156.36,113.06 156.36,114.31 156.71,114.67 156.71,115.3 156.74,115.32 156.74,115.43
  IN1 w0.114: 156.74,115.43 156.74,116.69 157.37,117.32 157.37,117.44 167.62,127.69 167.62,141.52 167.72,141.63 167.72,143.22 167.6,143.35 167.6,146.86 167.74,147 167.74,148.88 167.62,149 167.62,174.33 167.73,174.44 168.25,174.44 168.51,174.7 168.51,175.21 168.25,175.47 167.73,175.47 167.62,175.58 167.62,175.93 167.73,176.04 168.52,176.04 168.78,176.3 168.78,176.81 168.52,177.07 167.95,177.07 167.87,177.15 167.87,177.83 170.2,180.17 170.2,180.52 169.49,181.23 169.49,181.39 169.73,181.63 169.89,181.63 170.6,180.92 170.95,180.92 171.24,181.2 171.78,181.2 172.13,181.56 172.13,181.84 v2(172.39,182.1)
  BOTTOM w0.089: v2(156.56,112.89) 157,112.45 JCPU1.T34
DPC_CPU_LANE_N0_C: length 1.4
  TOP w0.102: RE18.2 168.96,189.67 168.87,189.59 168.87,189.22 C680.2
DPC_CPU_LANE_N1: length 90.7
  TOP w0.102: C684.1 170.9,187.49 170.9,187.2 v4(172.5,185.61) 173.4,184.71 173.4,183.9 174.3,183 174.3,182.23 v2(174.46,182.07)
  IN1 w0.089: v2(155.73,113.92) 155.48,113.92 155.41,113.99 155.41,114.21 155.51,114.31 155.73,114.31 155.94,114.52 155.94,114.92 155.6,115.26 155.6,115.46
  IN1 w0.114: 155.6,115.46 155.6,115.79 155.67,115.86 155.78,115.86 156,116.08 156,117.02 156.62,117.64 156.62,117.84 157.71,118.93 157.71,119.28 157.56,119.43 157.56,119.59 157.81,119.83 157.97,119.83 158.12,119.68 158.47,119.68 166.89,128.11 166.89,141.32 166.65,141.57 166.65,147.76 166.89,148.01 166.89,176.5 167.09,176.7 167.09,178.12 167.43,178.47 167.43,180.46 169.48,182.51 169.54,182.51 169.65,182.61 172.66,182.61 172.96,182.32 172.96,181.69 173.46,181.19 173.81,181.19 174.1,181.48 174.1,181.72 v2(174.46,182.07)
  BOTTOM w0.089: v2(155.73,113.92) JCPU1.U35
DPC_CPU_LANE_N1_C: length 1.4
  TOP w0.102: C684.2 170.93,189.18 170.93,189.61 171,189.67 RE20.2
DPC_CPU_LANE_N2: length 102.9
  TOP w0.102: C686.1 173.26,187.9 172.98,187.62 172.98,187.1 173.49,186.6 173.49,185.74 174.19,185.03 174.51,184.71 174.51,184 175.01,183.5 v4(175.4,183.5) 175.85,183.5 176.28,183.06 176.28,182.26 v2(176.49,182.06)
  IN1 w0.089: v2(155.73,110.92) 155.91,111.1 155.91,111.32 156.05,111.46 156.05,112.33 156.24,112.51 156.74,112.51 157.2,112.96 157.2,113.05 156.95,113.29 156.95,113.56 157.13,113.74 157.13,114.31 157.34,114.52 157.42,114.52 157.44,114.53 157.5,114.53 157.52,114.54 157.53,114.54
  IN1 w0.114: v2(176.49,182.06) 176.49,182.61 176.25,182.85 175.64,182.85 175.2,182.42 175.2,181.41 174.21,180.42 171.5,180.42 171.18,180.09 171.18,177.68 171.06,177.56 169.94,177.56 169.69,177.32 169.69,176.78 169.94,176.54 171.8,176.54 171.93,176.41 171.93,176.09 171.8,175.96 169.94,175.96 169.69,175.72 169.69,175.18 169.94,174.94 171.43,174.94 171.56,174.81 171.56,174.34 171.43,174.21 169.45,174.21 168.46,173.22 168.46,172.54 168.5,172.5 168.5,154.65 168.21,154.36 168.21,152.88 168.5,152.58 168.5,148.56 168.77,148.3 168.77,128.12 158.26,117.61 158.26,117.44 157.58,116.76 157.58,116.4 157.88,116.1 157.88,115.94 157.81,115.87 157.44,115.87 157.23,115.67 157.23,115.14 157.41,114.96 157.81,114.96 157.89,114.88 157.89,114.67 157.77,114.54 157.53,114.54
  BOTTOM w0.089: v2(155.73,110.92) 155.73,110.56 155.84,110.45 JCPU1.U32
