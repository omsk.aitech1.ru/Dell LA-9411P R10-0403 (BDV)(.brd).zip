# Allegro board LA-9411P R10-0403.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
PCH_DDPB_CTRLCLK: length 345.1
  TOP w0.089: 218.07,80.37 218.04,80.34 v2(218.04,80.3)
  TOP w0.102: RH255.2 218.24,80.54 218.07,80.37 ; v2(27.19,198.06) 27.27,198.14 U19.38
  IN2 w0.089: v2(215.59,74.89) 215.26,75.22 215.26,76.14 215.64,76.51 215.64,77.68 217.2,79.25 218.07,79.25 218.3,79.48 218.3,80.05 v2(218.04,80.3) 218.04,80.34 218.07,80.37
  IN2 w0.127: 218.07,80.37 218.07,80.73 218.32,80.97 218.32,86.14 223.73,91.55 223.73,101.33 224.87,102.48 v2(224.87,102.67) ; v2(27.19,198.06) 27.64,198.51 30.84,198.51 33.13,196.23 44.81,196.23 50.22,190.82 50.22,183.58 55.75,178.05 62.5,178.05 62.71,178.05 69.3,171.46 74.79,171.46 74.96,171.28 81.1,171.28 81.1,171.28 81.21,171.28 81.42,171.29 87.1,165.6 87.1,165.09 89.81,162.38 90.75,162.38 91.42,161.71 98.69,161.71 98.98,162 100.36,162 101.7,160.67 104.9,160.67 105.48,160.08 113.97,160.08 114.31,160.43 126.54,160.43 128.63,162.52 135.53,162.52 136.75,161.3 146.84,161.3 147.15,161.3 147.73,160.73 148.59,160.73 149.15,161.28 152.79,161.28 154.8,163.3 160.12,163.3 160.87,162.55 163.46,162.55 168.52,167.61 170.02,167.61 172.53,170.12 175.29,170.12 175.73,169.68 176.52,169.68 176.89,170.05 180.91,170.05 v2(181.17,170.32)
  IN4 w0.102: v2(224.87,102.67) 224.71,102.5 224.71,102.35 223.62,101.26 216.3,101.26 215.03,102.53 204.55,102.53 198.48,108.6 195.83,108.6 194.94,109.49 193.75,109.49 192.12,111.11 179.74,111.11 175.33,115.52 175.33,123.47 176.89,125.03 180.55,125.03 181.3,124.28 182.39,124.28 182.77,124.66 182.77,148.2 181.8,149.17 180.35,149.17 179.78,149.75 179.78,154.08 180.36,154.66 181.89,154.66 186.88,159.65 186.88,164.4 186.19,165.09 186.19,168.03 185.91,168.31 184.74,168.31 184.11,168.95 182.02,168.95 181.17,169.8 v2(181.17,170.32)
  BOTTOM w0.089: v2(215.59,74.89) 215.39,75.09 UH1.R40
PCH_DDPB_CTRLDATA: length 344
  TOP w0.089: 218.89,79.55 217.86,79.55 v2(217.66,79.76)
  TOP w0.102: RH256.2 219.29,79.78 219.07,79.55 218.89,79.55 ; U19.39 27.67,198.22 v2(27.82,198.07)
  IN2 w0.089: v2(215.14,74.46) 215.14,74.58 215.03,74.69 215.03,76.29 215.38,76.64 215.38,78.07 217.06,79.76 v2(217.66,79.76) 217.66,80.02 217.64,80.05 217.64,80.81
  IN2 w0.127: v2(27.82,198.07) 28.01,198.26 30.74,198.26 33.06,195.94 44.75,195.94 49.97,190.71 49.97,183.47 55.64,177.8 62.61,177.8 69.2,171.21 74.68,171.21 74.86,171.03 75.07,171.03 75.07,171.03 81.21,171.03 81.31,171.03 86.85,165.49 86.85,164.99 89.71,162.13 90.64,162.13 91.32,161.45 98.88,161.45 99.06,161.63 100.25,161.63 101.6,160.29 104.5,160.29 105.02,159.77 114.02,159.77 114.35,160.1 126.59,160.1 128.67,162.18 135.36,162.18 136.5,161.05 146.94,161.05 146.94,161.05 147.05,161.05 147.62,160.48 148.7,160.48 149.25,161.03 152.89,161.03 154.78,162.92 156.57,162.92 156.57,162.92 159.91,162.92 160.56,162.27 163.55,162.27 168.61,167.33 170.1,167.33 172.63,169.86 175.19,169.86 175.62,169.43 176.62,169.43 176.99,169.8 181.46,169.8 v2(181.67,170.01) ; v2(224.28,102.67) 223.45,101.84 223.45,91.73 217.98,86.26 217.98,81.25 217.64,80.91 217.64,80.81
  IN4 w0.102: v2(224.28,102.67) 224.28,102.34 223.49,101.55 216.43,101.55 215.21,102.77 204.75,102.77 198.65,108.86 195.94,108.86 195.09,109.72 193.91,109.72 192.24,111.39 183.38,111.39 181.99,112.79 178.39,112.79 175.62,115.56 175.62,123.34 177.07,124.79 180.28,124.79 181.07,124 182.53,124 183,124.47 183,148.31 181.89,149.43 180.45,149.43 180.07,149.81 180.07,154.01 180.48,154.42 181.99,154.42 187.12,159.55 187.12,164.6 186.44,165.28 186.44,168.16 186.06,168.54 184.93,168.54 184.22,169.25 182.43,169.25 v2(181.67,170.01)
  BOTTOM w0.089: UH1.R39 214.97,74.63 v2(215.14,74.46)
PCH_DDPC_CTRLCLK: length 165.2
  TOP w0.102: v2(195.66,176.06) v1(195.66,175.42)
  IN1 w0.102: v2(195.66,176.06) 195.3,175.69 195.3,173.79 195.45,173.64 v2(195.45,171.73) 195.45,171.61 194.57,170.74 193.99,170.74 193.8,170.55 192.97,170.55 v2(191.65,169.23)
  IN2 w0.089: v2(214.22,73.54) 214.22,73.93 214.22,74.38 213.53,75.07 213.53,77.16 215.13,78.77 215.13,79.86 216.23,80.95 216.23,82.22
  IN2 w0.127: v2(221.93,102.62) 221.93,102.12 221.57,101.76 221.57,92.99 216.23,87.64 216.23,82.22
  IN4 w0.102: v2(221.93,102.62) 222.19,102.35 222.19,102.13 222.19,102.12 222.09,102.02 216.71,102.02 215.35,103.38 205.34,103.38 199.26,109.46 196.22,109.46 195.46,110.22 194.15,110.22 192.51,111.86 183.8,111.86 181.99,113.68 178.88,113.68 176.23,116.32 176.23,123 177.4,124.17 179.55,124.17 180.78,122.94 182.47,122.94 183.54,124 183.54,148.7 182.67,149.57 182.67,153.75 187.85,158.93 187.85,166.47 189.9,168.52 190.94,168.52 v2(191.65,169.23)
  BOTTOM w0.089: UH1.R35 214.05,73.71 v2(214.22,73.54)
  BOTTOM w0.102: U20.12 196.18,172.46 v2(195.45,171.73) ; R1539.2 195.69,176.09 v2(195.66,176.06)
PCH_DDPC_CTRLDATA: length 166.5
  TOP w0.102: v2(195.72,174.24) v1(195.72,173.65)
  IN1 w0.102: v2(196.25,176.06) 195.72,175.53 v2(195.72,174.24) 195.72,172.78 195.96,172.54 195.96,171.64 194.79,170.47 194.06,170.47 193.86,170.27 193.05,170.27 192.79,170.01 v2(192.79,169.63)
  IN2 w0.089: v2(214.68,74) 214.68,74.27 214.17,74.79 213.75,75.21 213.75,77.08 215.46,78.79 215.46,79.67 216.64,80.84 216.64,81.81
  IN2 w0.127: 216.64,81.81 216.64,87.62 221.83,92.81 221.83,101.64 v2(222.69,102.5)
  IN4 w0.102: v2(192.79,169.63) 191.42,169.63 190.53,168.74 189.78,168.74 187.55,166.51 187.55,159.03 182.43,153.91 182.43,149.45 183.28,148.6 183.28,124.16 182.3,123.18 180.91,123.18 179.68,124.41 177.3,124.41 176,123.11 176,116.09 178.67,113.42 181.82,113.42 183.62,111.62 192.43,111.62 194.08,109.97 195.32,109.97 196.07,109.22 199.14,109.22 205.32,103.05 215.3,103.05 216.57,101.78 222.23,101.78 222.49,102.03 222.49,102.3 v2(222.69,102.5)
  BOTTOM w0.089: v2(214.68,74) 214.55,74.13 UH1.R36
  BOTTOM w0.102: R1530.2 196.71,176.52 v2(196.25,176.06) ; U20.9 195.89,174.41 v2(195.72,174.24)
PCH_DDPD_CTRLCLK: length 154.5
  TOP w0.102: R1066.2 188.03,167.41 187.59,166.97 187.59,165.91 188.34,165.16 188.34,164.45 188.69,164.1 v2(188.69,164.12)
  IN1 w0.102: v2(180.17,173.38) 181.78,171.77 183.9,171.77 185.83,169.84 187.02,169.84 188.69,168.16 v2(188.69,164.12)
  IN2 w0.089: v2(216.26,74.14) 216.2,74.21 216.2,74.82 216.76,75.37 216.76,77.86 217.37,78.47 218.31,78.47 219.14,79.3
  IN2 w0.127: v2(226.39,102.56) 226.39,102.21 224.28,100.1 224.28,91.33 221.73,88.78 221.73,85.74 221.09,85.1 219.91,85.1 219.15,84.34 219.15,79.31 219.14,79.3
  IN4 w0.102: v2(188.69,164.12) 188.69,161.9 189.17,161.42 189.17,158.9 183.22,152.95 183.22,149.85 184.07,149 184.07,115.39 185.85,113.61 192.32,113.61 194.65,111.28 200.27,111.28 205.95,105.6 217.53,105.6 219.25,103.89 225.66,103.89 226.23,103.31 226.23,102.72 v2(226.39,102.56)
  BOTTOM w0.089: UH1.N40 216.08,74.33 v2(216.26,74.14)
  BOTTOM w0.102: v2(180.17,173.38) 180.49,173.38 180.62,173.51 U23.12
PCH_DDPD_CTRLDATA: length 151.3
  TOP w0.102: v1(225.92,101.87) 225.79,101.99 v2(225.79,102.58) ; R1062.2 188.03,166.13 v2(188.26,165.9)
  IN1 w0.102: v2(180.45,171.46) 180.49,171.42 183.87,171.42 185.78,169.51 187,169.51 188.26,168.25 v2(188.26,165.9)
  IN2 w0.089: 218.75,79.69 218.75,79.43 218.27,78.94 217.42,78.94 216.47,77.99 216.47,75.37 215.98,74.89 215.98,74.5 215.37,73.89 v2(215.37,73.3)
  IN2 w0.127: 218.75,79.69 218.75,80.59 218.74,80.61 218.74,84.59 219.63,85.48 220.96,85.48 221.41,85.93 221.41,88.85 224.02,91.47 224.02,100.76 225.79,102.53 v2(225.79,102.58)
  IN4 w0.102: v2(188.26,165.9) 188.26,161.89 188.88,161.26 188.88,159.22 182.91,153.25 182.91,149.74 183.79,148.87 183.79,115.26 185.71,113.35 192.26,113.35 194.57,111.04 200.16,111.04 205.85,105.35 217.32,105.35 219.05,103.62 225.55,103.62 225.94,103.23 225.94,102.73 v2(225.79,102.58)
  BOTTOM w0.089: v2(215.37,73.3) 215.37,73.72 UH1.N38
  BOTTOM w0.102: U23.9 180.55,171.56 v2(180.45,171.46)
PCH_DPWROK: length 126
  TOP w0.089: v2(208.37,65.35) 208.34,65.35 207.89,64.91 v1(207.88,64.91)
  TOP w0.102: v2(273.68,62.32) 273.68,62.28 273.41,62.01 R802.1
  IN1 w0.089: 204.73,60.44 204.73,60.59 205.64,61.5 205.64,63 206,63.36 208,65.35 v2(208.37,65.35)
  IN1 w0.102: v2(225.79,52.46) 225.73,52.46 225.38,52.81 221.96,52.81 216.91,47.75 210.01,47.75 209.39,47.13 206.38,47.13 205.71,47.8 205.71,48.15 203.7,50.16 203.7,50.88 203.02,51.56 203.02,52.3 203.48,52.76 203.48,56.07 203.67,56.26 v2(203.67,56.55) 203.99,56.55 205.42,57.98 205.42,58.93 204.73,59.62 204.73,60.44
  IN2 w0.127: v2(228.72,70.47) 230.05,69.14 233.57,69.14 234.72,70.29 248.86,70.29 249.93,69.23 252.34,69.23 252.66,69.54 257.08,69.54 258.02,70.48 271.42,70.48 271.98,69.93 272.74,69.93 273.46,69.2 v2(273.69,69.2)
  BOTTOM w0.089: v2(208.37,65.35) 208.43,65.41 UH1.L13
  BOTTOM w0.102: v2(273.69,69.2) 273.72,69.2 274.47,68.45 274.47,63.09 273.69,62.32 v2(273.68,62.32) ; v2(225.79,52.46) 225.79,53.07 229.12,56.4 229.12,70.08 v2(228.72,70.47) ; RH120.2 202.72,55.9 203.37,56.55 v2(203.67,56.55) 203.81,56.55 205,55.37 205.35,55.37 RH79.1
PCH_GPIO3: length 23.4
  TOP w0.102: v1(207.82,49.48) 207.01,49.48 v2(206.69,49.8) 206.37,49.48 205.72,49.48 205.27,49.02 205.27,48.58 205.5,48.35 205.5,48.15 RPH6.3
  IN2 w0.089: 212.17,61.58 211.01,62.73 211.01,63.73 211.01,64.02 210.9,64.14 210.9,65.31 v2(211.02,65.44)
  IN2 w0.127: v2(206.69,49.8) 206.69,50.02 210.12,53.45 210.12,54.57 211.11,55.56 211.11,58.86 211.93,59.69 211.93,60.06 212.17,60.3 212.17,61.57 212.17,61.58
  BOTTOM w0.089: 211.5,65.65 211.24,65.65 v2(211.02,65.44)
PCH_GPIO06: length 6.7
  TOP w0.102: RH257.2 213.93,58.35 v1(213.93,58.88) v2(213.93,60.3)
  BOTTOM w0.089: UH1.A14 212.06,63.11 212.06,62.54 212.6,62
  BOTTOM w0.102: 212.6,62 213.4,61.2 213.64,61.2 213.93,60.91 v2(213.93,60.3)
PCH_GPIO07: length 12.2
  TOP w0.102: v2(212.94,56.22) 212.98,56.18 212.98,55.29 RH203.1
  IN1 w0.089: v2(210.33,64.74) 210.07,64.48 210.07,59.85 210.26,59.66
  IN1 w0.102: 210.26,59.66 210.26,59.66 212.7,57.22 212.7,56.46 v2(212.94,56.22)
  BOTTOM w0.089: v2(210.33,64.74) 210.39,64.8 UH1.G15
  BOTTOM w0.102: v1(213.34,55.68) 212.98,56.04 212.98,56.18 v2(212.94,56.22)
PCH_GPIO22: length 207.2
  TOP w0.089: 193.38,71.79 193.48,71.89 195.05,71.89 195.94,71.01 197.21,71.01 197.72,71.51 197.72,72.15 v2(197.13,72.74)
  TOP w0.102: 193.38,71.79 193.33,71.74 v1(191.75,71.74) 191.19,71.74 189.95,70.5 189.95,70.41 RH198.1 189.14,70.11 189.14,70.2 RH248.1 ; v2(302.15,126.49) 300.39,126.49 299.45,127.43 R1670.1 ; v2(250.16,105.59) 250.16,105.65 252.08,107.57 253.14,107.57 254.33,108.75 264.27,108.75 265.15,109.63 267.37,109.63 267.4,109.65 v2(273.52,109.65)
  IN1 w0.089: v2(197.13,72.74) 197.13,72.69 198.03,71.79 199.67,71.79 200.35,71.11 200.63,71.11 201.8,72.28 201.8,72.81 202.28,73.29 202.28,74.76 199.97,77.08 199.97,78.85 199.47,79.36
  IN1 w0.102: 199.47,79.36 198.69,80.14 198.69,85.03 201.62,87.96 201.62,89.1 207.54,95.02 207.73,95.02 211.69,98.98 212.03,98.98 213.8,100.74 219.31,100.74 220.05,100 229.55,100 229.83,99.73 235.29,99.73 236.25,98.77 241.85,98.77 248.66,105.59 v2(250.16,105.59)
  IN3 w0.127: v2(273.52,109.65) 273.6,109.57 273.6,106 277.57,102.03 278.66,102.03 279.43,101.26 279.62,101.26 279.78,101.1 279.78,98.7 280.24,98.23 285.5,98.23 287.04,99.77 287.61,99.77 288.07,100.23 288.07,101.46 288.54,101.93 289.69,101.93 289.96,102.2 299.78,102.2 303.4,105.82 307.13,105.82 308.55,107.23 308.55,121.63 313.41,126.49 v2(315.11,126.49)
  BOTTOM w0.089: UH1.BB4 196.91,72.51 v2(197.13,72.74)
  BOTTOM w0.102: v2(315.11,126.49) v2(302.15,126.49)
PCH_GPIO24: length 25
  TOP w0.102: v2(195.72,50.95) 195.81,50.86 v1(196.51,50.86) 197.39,50.86 197.68,51.16 RH213.1
  IN2 w0.089: 202.64,63.35 202.64,64.19 204.93,66.48 v2(204.93,66.99)
  IN2 w0.127: 202.64,63.35 201.18,61.89 200.9,61.89 199.69,60.68 199.69,58.72 196.97,56.01 196.3,56.01 194.28,53.99 194.28,52.4 195.72,50.96 v2(195.72,50.95)
  BOTTOM w0.089: v2(204.93,66.99) 204.84,67.08 UH1.Y10
PCH_GPIO33: length 5.2
  TOP w0.089: 214.33,63.74 214.28,63.8 v2(213.62,63.8)
  TOP w0.102: v1(215.9,61.86) 215.9,62.94 RH40.2 214.89,63.19 214.33,63.74
  BOTTOM w0.089: UH1.B17 212.53,64.49 213.22,63.8 v2(213.62,63.8)
PCH_GPIO34: length 28.6
  TOP w0.102: v2(188.08,58.45) 188.08,58.52 v1(187.56,59.04)
  IN3 w0.089: v2(199.42,70.64) 199.42,70.23 198.64,69.45 198.64,68.49 197.77,67.62 197.55,67.62
  IN3 w0.127: 197.55,67.62 194.82,64.88 193.6,64.88 192.58,63.87 191.12,63.87 187.96,60.7 187.96,58.57 v2(188.08,58.45)
  BOTTOM w0.089: v2(199.42,70.64) 199.42,70.62 199.68,70.37 UH1.AN6
  BOTTOM w0.102: v2(188.08,58.45) 187.63,58.9 185.7,58.9 185.15,59.45 185.15,64.13 RH258.1
PCH_GPIO35: length 12.8
  TOP w0.102: RH205.1 189.67,63.2 189.67,63.43 190.47,64.23 RH25.1 191.78,64.91 v2(191.91,65.04) 191.91,64.45 v1(191.7,64.25)
  IN3 w0.127: v2(191.91,65.04) 193.66,66.79 v2(193.66,66.89)
  BOTTOM w0.089: UH1.AP1 197.97,68.88 197.27,68.88 197.21,68.81 197.06,68.81 196.71,68.47 196.7,68.47
  BOTTOM w0.102: 196.7,68.47 196.51,68.27 196.03,68.27 195.39,67.64 194.93,67.64 194.18,66.89 v2(193.66,66.89)
PCH_GPIO36: length 11.9
  BOTTOM w0.089: 196.34,68.83 196.47,68.83 196.81,69.17 196.96,69.17 197.06,69.27 197.64,69.27 197.87,69.5 197.87,69.93 UH1.AT3
  BOTTOM w0.102: RH228.1 191.95,68.1 192.83,68.1 v1(192.97,67.96) 194.04,67.96 194.29,68.21 194.31,68.21 195.32,68.21 195.84,68.73 196.25,68.73 196.34,68.83 ; RH228.1 RH230.1 ; RH228.1 190.44,67.7 189.59,66.84 RH12.1
PCH_GPIO37: length 13.1
  BOTTOM w0.089: UH1.AK1 199.19,67.79 198.77,67.79 198.11,67.13 198.04,67.13
  BOTTOM w0.102: RH14.1 191.7,59.38 RH229.2 192.46,60.47 192.91,60.92 192.91,61.2 193.43,61.73 RH231.1 194.2,62.14 196.17,64.11 v1(196.17,64.5) 196.17,65.97 197.33,67.13 198.04,67.13
PCH_GPIO49: length 8.9
  TOP w0.102: RH227.1 195.76,66.69 v2(196,66.69) 196,66.07 v1(195.86,65.93) 195.61,65.68 195.61,65.22 196,64.83 RH19.1 195.41,63.88 RH225.1
  BOTTOM w0.089: UH1.AK3 199.86,68.53 199.52,68.2 199.13,68.2 198.92,67.99 198.72,67.99 198.09,67.36 197.81,67.36
  BOTTOM w0.102: v2(196,66.69) 196.56,66.69 197.23,67.36 197.81,67.36
PCH_GPIO55: length 17.2
  TOP w0.102: v1(188.91,61.09) 189.03,60.96 RH76.1 191.15,60.96 191.41,61.23 191.41,61.32 191.43,61.24 v2(191.43,61.3)
  IN3 w0.127: v2(200.16,70.02) 199.31,69.16 199.31,68.03 198.42,67.14 198.42,66.9 197.54,66.02 197.54,64.94 196.9,64.3 196.01,64.3 195.12,63.41 194.19,63.41 194.03,63.25 194.02,63.25 192.8,62.03 192.17,62.03 192.06,61.91 192.06,61.91 191.81,61.67 191.81,61.66 191.44,61.3 v2(191.43,61.3)
  BOTTOM w0.089: 200.37,69.54 200.37,69.8 v2(200.16,70.02)
PCH_GPIO69: length 14.2
  TOP w0.102: v2(213.85,53.75) v1(213.85,52.97)
  IN4 w0.102: v2(213.85,53.75) 213.85,56.11 214.7,56.95 214.7,58.92 213.46,60.16 v2(213.46,60.77)
  BOTTOM w0.089: UH1.D13 210.65,63.86 210.87,63.64 211.41,63.64 211.59,63.46 211.59,63.13 211.68,63.04 211.85,62.87 211.85,62.43 212.43,61.84
  BOTTOM w0.102: RH254.1 213.2,53.75 v2(213.85,53.75) ; v2(213.46,60.77) 213.46,60.81 212.43,61.84
PCH_GPIO70: length 3.4
  TOP w0.089: v2(209.21,64.51) 209.72,64.51 210.03,64.2 v1(210.03,63.54) 210.03,62.94 RH207.1
  BOTTOM w0.089: v2(209.21,64.51) 209.52,64.51 UH1.G13
PCH_GPIO71: length 3.8
  TOP w0.089: RH208.1 210.73,63.5 210.73,63.77 209.87,64.63 v2(209.87,65.2) 209.45,65.2 v1(209.28,65.04)
  BOTTOM w0.089: v2(209.87,65.2) 209.97,65.3 UH1.H15
PCH_INTVRMEN: length 16
  TOP w0.102: v2(210.54,53.01) 211,53.01 RH5.2 RH18.1 211.89,52.01 v1(212.71,51.19)
  IN1 w0.089: 209.6,59.01 209.19,59.42 208.81,59.8 208.81,61.96 208.55,62.22 208.55,62.95 208.54,62.96 208.54,63.78 208.55,63.78 v2(208.55,63.79)
  IN1 w0.102: v2(210.54,53.01) 210.09,53.46 210.09,54.26 211.07,55.25 211.07,57.54 209.6,59.01
  BOTTOM w0.089: v2(208.55,63.79) 208.76,64 UH1.G10
PCH_JTAG_RST: length 135.5
  TOP w0.102: RH32.2 269.93,77.61 v2(269,78.54) v3(268.23,78.54)
  IN2 w0.127: v2(257.95,77.86) 258.77,78.69 268.85,78.69 v2(269,78.54)
  IN4 w0.089: v2(203.36,66.82) 203.56,66.61 203.56,65.93 203.81,65.68 203.81,65.49 203.69,65.38 203.69,62.46 203.48,62.26 202.92,62.26
  IN4 w0.102: 202.92,62.26 202.41,62.26 201.89,61.73 201.89,60.72 201.61,60.44 200.85,60.44 200.16,59.75 200.16,57.76 199.17,56.77 198.47,56.77 197.76,56.06 197.76,55.21 197.99,54.98 197.99,54.42 199.41,53 199.69,53 201.6,51.08 206.02,51.08 207.74,49.36 212.61,49.36 214.51,51.27 225.87,51.27 226.27,50.86 239.06,50.86 240.56,49.37 240.56,45.54 243.53,42.57 243.94,42.57 245.2,41.31 252.99,41.31 254.81,43.13 255.79,43.13 257.23,44.57 257.23,53.34 258.17,54.28 258.17,55.33 258.17,60.77 258.92,61.52 258.92,62.15 258.17,62.9 258.17,71.53 257.67,72.04 257.67,77.58 v2(257.95,77.86)
  BOTTOM w0.089: UH1.AB6 203.09,66.82 v2(203.36,66.82)
PCH_JTAG_RST_R: length 4.3
  TOP w0.102: v1(271.08,76.58) RH32.1 271.57,77.61 v2(272.31,78.35)
  BOTTOM w0.102: JXDP2.54 272.29,78.33 v2(272.31,78.35)
PCH_JTAG_TCK: length 132.6
  TOP w0.102: v2(266.96,73.47) 267.17,73.67 267.7,73.67 269.22,75.2 272.56,75.2 274.77,77.41 v2(274.77,77.97) ; v2(191.55,54.28) 190.9,54.28 v3(190.58,54.6)
  IN1 w0.102: v2(191.55,54.28) 191.8,54.28 193.81,52.27 194.39,52.27 194.62,52.03 194.62,51.43 202.81,43.24 216.77,43.24 222.15,48.62 230.53,48.62 232.23,50.32 235.64,50.32 245.02,59.69 246.21,59.69 247.36,60.84 254.58,60.84 255.69,61.95 256.58,61.95 256.94,62.31 256.94,63.11 258.55,64.72 258.55,65.36 266.66,73.47 v2(266.96,73.47)
  IN2 w0.089: 199.66,63.23 200.83,64.4 v2(200.99,64.4)
  IN2 w0.127: v2(191.55,54.28) 191.55,56.33 192.75,57.53 193.89,57.53 195.5,59.14 196.58,59.14 197.77,60.34 197.77,61.34 199.66,63.23
  BOTTOM w0.089: UH1.AB3 202.51,65.95 202.51,65.5 202.31,65.3 202.28,65.3 202.28,65.3 202.04,65.3 202.04,65.3 201.98,65.3 201.8,65.12 201.47,64.8 201.38,64.8 v2(200.99,64.4) 200.97,64.38 200.97,64.37
  BOTTOM w0.102: v2(274.77,77.97) 274.77,77.95 275.4,77.33 JXDP2.57 ; 200.97,64.37 200.43,63.83 200.43,62.46 199.84,61.87 199.84,61.06 197.75,58.97 196.96,58.97 RH47.1
PCH_JTAG_TDI: length 181.4
  TOP w0.102: v3(196.55,43.68) 196.55,43.7 v2(197.49,44.64)
  IN1 w0.089: v2(199.02,64.54) 198.87,64.54 198.55,64.86 198.03,64.86
  IN1 w0.102: v2(256.94,34.38) 256.19,34.38 255.63,34.94 255.63,36.59 257.28,38.24 257.28,42.81 256.29,43.8 255,43.8 254.39,44.41 254.39,46.31 257.31,49.23 257.31,51.85 259.32,53.86 259.32,55.51 260.76,56.96 260.76,59.25 263.25,61.73 265.67,61.73 267.06,63.13 267.06,64.91 271.38,69.23 271.38,69.76 272.75,71.13 272.75,71.24 273.02,71.51 v2(273.02,71.73) ; v2(197.49,44.64) 197.07,45.06 197.07,46.22 192.15,51.14 186.5,56.79 186.5,61.04 186.19,61.35 184.95,62.59 184.95,65.68 184.86,65.76 184.86,66.73 188.21,70.08 189.76,70.08 190.25,70.57 191.13,70.57 191.82,69.89 191.82,67.6 193.57,65.85 195.06,65.85 196.51,64.4 197.19,64.4 197.65,64.86 198.03,64.86
  IN2 w0.127: v2(197.49,44.64) 204.33,44.64 210.45,38.52 222.78,38.52 223.57,39.31 232.38,39.31 234.45,37.24 241.87,37.24 245.55,33.55 247.48,33.55 247.72,33.79 255.42,33.79 256,34.38 v2(256.94,34.38)
  BOTTOM w0.089: 199.28,65.61 199.61,65.94 199.62,65.94 200.12,66.43 200.82,66.43 201.06,66.67 UH1.AE2
  BOTTOM w0.102: 199.28,65.61 199.02,65.34 v2(199.02,64.54) 199.02,63.96 197.64,62.58 RH55.1 196,62.58 195.36,61.94 195.3,61.94 194.83,61.47 RH50.2 ; v2(273.02,71.73) 273.02,72.39 272.52,72.88 272.52,76.65 272.55,76.68 272.55,77.33 272.06,77.83 JXDP2.56
PCH_JTAG_TDO: length 222.9
  TOP w0.102: v2(210.04,41.45) v3(209.16,41.45) ; RH56.1 RH52.2 269.53,78.63 v2(269.03,79.12)
  IN1 w0.102: v2(273.67,71.4) 273.76,71.4 274.3,70.85 274.3,68.08 273.92,67.7 272.65,67.7 268.71,63.77 268.71,62.24 267.24,60.77 263.65,60.77 263,60.11 263,57.42 262.1,56.51 260.64,56.51 259.55,55.42 259.55,53.77 257.56,51.78 257.56,49.16 254.62,46.22 254.62,44.54 255.1,44.06 256.42,44.06 257.92,42.56 257.92,37.96 256.32,36.36 v2(256.26,36.36)
  IN2 w0.127: v2(210.04,41.45) 210.46,41.87 211.7,41.87 214.49,39.09 222.51,39.09 223.3,39.88 232.1,39.88 232.52,39.88 234.65,37.76 242.55,37.76 245.47,34.84 254.74,34.84 v2(256.26,36.36) ; v2(257.03,80.53) 257.32,80.24 264.32,80.24 265.48,79.08 268.99,79.08 v2(269.03,79.12)
  IN3 w0.127: v2(256.26,36.36) 256.26,37.48 256.51,37.73 256.51,39.38 257.07,39.94 257.07,41.78 255.78,43.07 254.38,43.07 253.84,43.61 253.84,47.63 253.41,48.06 253.41,48.71 254.06,49.36 254.06,50.12 253.13,51.04 253.13,56.78 253.06,56.85 253.06,62.53 252.75,62.84 252.75,64.94 257.65,69.85 257.65,71.39 256.79,72.25 256.79,78.04 256.78,78.05 256.78,80.28 v2(257.03,80.53)
  BOTTOM w0.089: 199.56,63.32 199.73,63.49 199.73,64.54 199.93,64.74 v2(199.93,65.42) 200.67,65.42 201.07,65.82 201.21,65.82 201.32,65.93 201.32,66.48 UH1.AD3
  BOTTOM w0.102: v2(210.04,41.45) 210.04,41.5 210.21,41.67 210.21,44.62 208.91,45.92 208.91,46.93 208.45,47.38 208.45,47.71 208.45,48.07 208.2,48.32 207.84,48.32 207.7,48.18 206.33,48.18 205.68,47.54 203.47,47.54 202.75,48.26 196.77,48.26 192.18,52.84 192.18,56.15 193.2,57.16 193.67,57.16 194.24,57.73 194.24,58.48 194.75,58.99 195.99,58.99 196.63,59.63 197.08,59.63 197.46,60.01 197.46,60.12 197.98,60.64 197.98,61.71 199.56,63.3 199.56,63.32 ; v2(273.67,71.4) 274.23,71.96 274.23,72.91 272.78,74.36 272.78,78.63 272.58,78.83 JXDP2.52
PCH_JTAG_TMS: length 129.5
  TOP w0.102: v3(191.24,52.41) 191.58,52.74 v2(191.58,53.3)
  IN1 w0.102: v2(191.58,53.3) 191.6,53.3 202.52,42.38 217.08,42.38 222.07,47.37 231.78,47.37 232.52,48.11 233.03,48.11 234.43,49.51 235.98,49.51 245.35,58.88 246.54,58.88 247.69,60.03 254.92,60.03 256.03,61.13 256.91,61.13 257.75,61.98 257.75,62.75 262.59,67.59 262.59,67.75 267.77,72.93 267.77,73.81 266.81,74.77 266.81,77 267.71,77.9 v2(268.99,77.9)
  IN2 w0.089: v2(199.47,64.98) 199.47,63.85 199.25,63.63
  IN2 w0.127: v2(191.58,53.3) 191.04,53.84 191.04,56.54 192.91,58.41 192.91,58.72 193.34,59.16 193.66,59.16 194.23,59.73 195.93,59.73 196.48,60.27 196.49,60.27 196.73,60.52 196.73,60.53 197.1,60.9 197.1,61.48 199.25,63.63
  BOTTOM w0.089: 199.57,65.6 200.23,66.26 200.92,66.26 UH1.AD1
  BOTTOM w0.102: v2(268.99,77.9) 269.57,77.33 JXDP2.58 ; 195.5,60.42 195.5,60.71 196.7,61.91 RH54.1 197.49,62.05 197.7,62.05 199.47,63.82 199.47,64.98 v2(199.47,64.98) 199.47,65.5 199.57,65.6
PCH_PCIE_IREF: length 3.5
  BOTTOM w0.089: UH1.BE30 202.82,81.55 202.82,81.79 202.37,82.24 202.35,82.24
  BOTTOM w0.102: 202,82.52 202.26,82.25 202.34,82.25 202.35,82.24
  BOTTOM w0.305: RH188.2 201.14,83.38 v1(201.81,82.71) 202,82.53 202,82.52
PCH_PCIE_RCOMP: length 3.3
  TOP w0.089: v1(203.03,81.75) 203.63,81.15 RH192.2
  TOP w0.381: v2(202.51,81.04) 202.59,81.11 202.66,81.11 202.71,81.17 203.47,81.17 RH192.2
  BOTTOM w0.254: UH1.BD29 203.32,80.44 202.73,81.04 v2(202.51,81.04)
PCH_PCIE_WAKE#: length 169.3
  TOP w0.102: v2(266.83,110.81) v1(266.12,110.81) ; U51.A44 281.62,112.16 281.55,112.1 281.07,112.1 v2(280.63,111.66) ; RH92.2 202.01,57.24 RH78.2 201.46,58.03 201.85,58.03 202.14,58.31 v2(202.14,58.91)
  IN2 w0.127: v2(280.63,111.66) 280.47,111.66 280.18,111.37 279.83,111.37 279.46,111.73 276.68,111.73 276.41,111.47 275.85,111.47 275.64,111.68 275.08,111.68 274.61,112.15 269.88,112.15 269.41,111.68 267.7,111.68 v2(266.83,110.81)
  IN4 w0.102: v2(266.83,110.81) 266.61,110.59 266.61,104.37 265.2,102.96 265.2,101.13 264.6,100.53 264.6,99.79 261.73,96.92 261.73,96.55 257.12,91.94 257.12,87.69 256.54,87.1 256.54,72.42 257.72,71.24 257.72,54.56 256.78,53.62 256.78,44.76 255.6,43.59 254.62,43.59 252.8,41.77 246.55,41.77 244.13,44.2 242.96,44.2 241.9,45.26 241.9,49.4 241.02,50.28 240.82,50.28 239.55,51.55 226.78,51.55 226.37,51.96 211.84,51.96 211.23,51.35 209.02,51.35 208.29,52.08 204.88,52.08 203.42,53.54 201.42,53.54 200.39,54.57 200.39,55.05 199.65,55.79 199.65,56.5 199.91,56.76 200.59,56.76 202.12,58.28 202.12,58.89 v2(202.14,58.91)
  BOTTOM w0.089: 204.43,60.74 204.43,61.07 204.29,61.21 204.29,61.52 204.71,61.94 204.71,62.27 204.89,62.45 205.21,62.45 205.54,62.78 UH1.K3
  BOTTOM w0.102: 204.43,60.74 204.43,60.19 203.15,58.91 v2(202.14,58.91)
PCH_PLTRST#: length 172.5
  TOP w0.102: UH3.2 185.92,67.56 185.92,67.74 RH109.2 ; 186.34,68.58 RH113.2 RH109.2 ; 186.34,68.58 RH114.2 186.97,70.1 186.29,70.78 186.29,72.16 186.62,72.49 187.92,72.49 189.58,74.15 v1(189.58,74.76) 189.58,75.86 190.6,76.87 v2(190.6,77.14) ; 186.34,68.58 186.34,68.57 186.84,68.07 UH3.1 ; RH110.2 184.46,66.69 RH111.2 ; RH109.2 RH111.2 ; RH111.2 185.29,67.12 185.29,66.23 v2(185.5,66.02)
  IN1 w0.089: 199.93,64.83 201.66,66.56 201.83,66.56 201.95,66.44 201.95,66.27 201.6,65.93 201.6,65.78 201.71,65.68 201.86,65.68 202.22,66.04 202.35,66.04 202.73,65.66 202.88,65.66 202.98,65.77 202.98,65.91 202.52,66.37 202.52,66.54 202.64,66.66 202.81,66.66 203.31,66.16 203.49,66.16 205.03,67.69 205.17,67.69 v2(205.45,67.41)
  IN1 w0.102: 187.55,66.46 187.11,66.02 v2(185.5,66.02) 185.93,66.46 187.55,66.46 ; 187.55,66.46 188.05,66.96 189.75,66.96 190.11,67.31 191,67.31 196.13,62.18 197.49,62.18 199.06,63.75 199.06,63.95 199.93,64.83 ; v2(119.36,64.4) 119.3,64.46 119.3,64.96 119.19,65.07 v2(119.19,98.18)
  BOTTOM w0.089: UH1.Y11 205.26,67.6 v2(205.45,67.41)
  BOTTOM w0.102: UC2.2 122.49,101.49 v2(119.19,98.18) ; v2(119.36,64.4) 120.91,64.4 125.13,60.19 171.76,60.19 183.35,71.77 183.35,72.49 187.16,76.3 187.16,76.51 187.39,76.75 187.61,76.75 188.15,77.29 190.44,77.29 v2(190.6,77.14) ; QH2.2 185.5,66.38 v2(185.5,66.02)
PCH_PLTRST#_BUF: length 5.3
  BOTTOM w0.102: v1(128.11,104.19) 128.18,104.13 RC64.1 RC67.1 RC60.2 127.92,100.98 127.52,101.38 127.52,101.94 127.32,102.14 UC2.4
PCH_PLTRST#_EC: length 548.6
  TOP w0.102: U41.6 271.4,32.27 271.17,32.04 268.17,32.04 267.97,32.25 267.1,32.25 v2(266.8,31.94) ; v2(276.83,166.59) 276.58,166.84 276.58,167.43 280.17,171.02 287.36,171.02 288.34,172 288.34,175.62 289.66,176.94 291.23,176.94 293.29,179.01 294.33,179.01 295.42,180.1 295.42,183.24 296.67,184.48 303.06,184.48 v2(304.53,183.01) 304.53,179.5 305.86,178.17 v2(305.86,178.05) 305.67,177.87 v1(305.67,173.68) v4(305.67,171.93) ; U51.B30 285.47,118.12 285.56,118.03 285.56,117.23 285.8,116.99 v2(285.8,116.98) ; UH3.4 187.49,65.07 187.49,64.93 187.1,64.54 v2(187.1,63.55) ; R704.2 337.93,201.14 339.14,199.94 344.61,199.94 v2(345.23,200.56) ; v2(270.38,55.93) 269.96,56.35 269.96,56.71 270.19,56.93 U46.B22 ; U39.16 292.95,130.19 v2(292.88,130.11) ; v2(301.52,124.97) 314.35,124.97 314.5,124.82 316.28,124.82 317.06,124.03 318.4,124.03 319.25,123.18 Q85.2
  IN1 w0.102: v2(345.23,200.56) 345.23,197.94 342.9,195.61 340.38,195.61 336.79,192.01 336.79,188.38 336.03,187.62 336.03,182.07 330.05,176.09 326.62,176.09 325.99,175.45 324.1,175.45 322.36,173.72 321.26,173.72 319.93,172.39 318.99,172.39 318.66,172.72 306.36,172.72 305.67,172.03 v4(305.67,171.93) ; v2(276.83,166.59) 277.02,166.4 277.02,155.22 277.33,154.91 277.33,146.96 280.06,144.23 280.06,139.89 279.47,139.31 v2(279.46,139.31) ; v2(301.52,124.97) 301.52,129.51 300.53,130.5 293.27,130.5 v2(292.88,130.11) 292.71,130.28 287.59,130.28 285.68,128.37 285.68,127.42 285.8,127.3 285.8,126.29 283.87,124.36 283.87,122.19 283.64,121.96 283.64,121.14 285.56,119.22 285.56,117.23 285.8,116.99 v2(285.8,116.98)
  IN2 w0.127: v2(275.13,138.37) 278.23,138.37 279.03,139.17 279.33,139.17 v2(279.46,139.31) ; v2(262.11,175.08) 262.43,175.4 266.49,175.4 266.96,174.93 267.62,174.93 268.5,174.05 273.72,174.05 274.06,173.71 274.4,173.71 274.4,173.71 275.3,173.71 276.93,172.08 276.93,166.69 v2(276.83,166.59)
  IN4 w0.102: v2(270.38,55.93) 270.23,55.78 270.23,50.26 270.82,49.66 270.82,47.29 269.74,46.22 269.74,44.39 268.13,42.77 268.13,37.31 267.99,37.17 267.99,33.59 267.78,33.37 267.08,33.37 266.98,33.27 266.98,33.07 267.08,32.96 268.05,32.96 268.17,32.84 268.17,32.63 268.08,32.54 267.39,32.54 v2(266.8,31.94) 266.59,31.94 266.32,31.67 266.32,29.89 255.25,18.82 232.52,18.82 231.12,20.22 222.54,20.22 221.47,19.15 215.13,19.15 200.52,33.77 200.52,35.15 196.17,39.49 196.17,40.12 193.94,42.35 193.94,43.72 186.75,50.9 186.75,59.25 186.99,59.49 186.99,63.45 v2(187.1,63.55) ; v2(277.85,62.57) 277.83,62.59 277.83,64.15 276.13,65.86 276.13,92.68 278.79,95.34 278.79,99.73 277.73,100.79 277.73,104.51 278.74,105.51 280.87,105.51 281.89,106.53 282.68,106.53 283.41,107.27 283.41,107.92 283.73,108.24 284.44,108.24 286.04,109.84 286.04,111 286.89,111.85 286.89,114.48 286.23,115.14 286.23,116.32 285.8,116.75 v2(285.8,116.98)
  BOTTOM w0.102: v2(304.53,183.01) 304.48,183.01 303.87,183.61 303.87,184.79 JMINI3.17 ; v2(275.13,138.37) 276.72,136.79 276.72,132.65 277,132.37 277,132.34 277.25,132.09 277.25,129.36 275.59,127.7 275.59,125.27 273.17,122.86 273.17,117.72 272.7,117.25 272.7,107.77 275.34,105.12 275.34,97.23 275.6,96.98 276.18,96.98 277.77,95.39 277.77,74.83 277.4,74.47 277.4,63.06 277.85,62.61 v2(277.85,62.57) 277.5,62.23 277.5,60.88 278.15,60.23 278.15,59.57 278.07,59.49 278.07,58.74 277.35,58.01 274.07,58.01 273.35,57.29 270.96,57.29 270.8,57.12 270.8,56.35 v2(270.38,55.93) ; v2(262.11,175.08) 262.24,175.08 262.49,175.34 R703.1 ; JMINI3.22 v2(305.86,178.05)
PCH_PWRBTN#_XDP: length 6.3
  TOP w0.102: RH28.2 276.44,80.94 v1(274.43,80.94) 274.04,80.94 273.68,81.29 v2(273.67,81.29)
  BOTTOM w0.102: v2(273.67,81.29) 273.68,81.3 276.31,81.3 JXDP2.41
PCH_PWROK: length 13.6
  TOP w0.102: v3(211.16,55.11) 211.16,54.47 211.65,53.98 211.65,53.96 211.44,53.96 v2(211.02,53.54)
  IN1 w0.089: 209.93,59.33 209.65,59.61 209.65,62.66 v2(208.95,63.36)
  IN1 w0.102: v2(211.02,53.54) 211.3,53.82 211.3,57.96 209.93,59.33
  BOTTOM w0.089: UH1.F10 209.17,63.58 v2(208.95,63.36)
PCH_RI#: length 8.1
  TOP w0.102: 200.2,59.39 200.37,59.56 200.66,59.56 201.14,60.05 v2(201.73,60.05)
  BOTTOM w0.089: 203.2,61.98 203.96,62.74 203.96,62.9 204.19,63.13 204.19,63.42 204.39,63.62 204.78,63.62 UH1.N4
  BOTTOM w0.102: v2(201.73,60.05) 201.74,60.03 202.9,60.03 203.13,60.26 203.13,61.17 203.08,61.22 203.08,61.86 203.2,61.98
PCH_RSMRST#: length 141.8
  TOP w0.102: v2(284.27,112.02) 283.83,111.58 283.43,111.58 283.1,111.91 U51.B47 ; v2(280.01,111.79) 278.05,111.79 R892.2 ; v2(242.93,47.89) v1(242.93,48.65)
  IN2 w0.127: v2(284.27,112.02) 284.27,111.9 283.95,111.58 282.81,111.58 282.28,112.12 280.34,112.12 v2(280.01,111.79) 279.8,111.99 276.57,111.99 276.31,111.72 275.96,111.72 275.65,112.03 275.38,112.03 275,112.41 269.78,112.41 269.32,111.95 266.29,111.95 265.92,111.58 259.16,111.58 v2(257.65,110.07) ; v2(214.04,49.19) 214.04,49.1 214.23,48.91 214.87,48.91 215.5,48.27 225.13,48.27 228.54,44.86 230.68,44.86 232.27,46.44 232.27,47.51 234.42,49.67 237.85,49.67 238.12,49.4 239.77,49.4 241.28,47.89 v2(242.93,47.89)
  IN3 w0.127: v2(242.93,47.89) 243.06,48.02 243.06,50.81 244.46,52.21 244.46,53.45 246.39,55.38 246.39,57.07 246.83,57.52 246.83,72.05 247.81,73.02 247.81,93.91 257.37,103.47 257.37,104.56 258.35,105.54 258.35,109.38 257.66,110.07 v2(257.65,110.07)
  BOTTOM w0.102: v2(214.04,49.19) 214.04,49.54 213.62,49.97 U9.1 213.37,50.18 212.5,50.18 211.83,49.5 211.83,48.96 212.52,48.27 R1623.1
PCH_RSMRST#_Q: length 116.6
  TOP w0.102: RH26.1 275.82,82.44 275.36,82.89 274.25,82.89 273.88,82.52 v2(273.67,82.52) ; v2(203.91,57.37) 204.08,57.19 v1(204.08,56.89)
  IN1 w0.102: v2(210.85,46.74) 210.82,46.77 210.79,46.77 210.66,46.9 205.77,46.9 203.47,49.2 203.47,50.51 202.74,51.24 202.74,51.89 201.9,52.73 201.9,53.37 202.17,53.63 202.52,53.63 202.95,54.06 202.95,56.79 203.53,57.37 v2(203.91,57.37)
  IN2 w0.127: v2(232.13,69.56) 232.13,70.07 234.84,72.78 255.79,72.78 256.76,73.75 260.98,73.75 263.09,75.86 267.9,75.86 268.37,75.39 270.65,75.39 271.46,76.19 271.46,80.85 271.64,81.04 272.56,81.04 272.83,81.31 272.83,82.3 273.06,82.52 v2(273.67,82.52)
  BOTTOM w0.102: v2(232.13,69.56) 232.13,68.89 230.06,66.81 230.06,56.32 227.68,53.95 227.68,52.02 226.57,50.91 226.57,50.61 225.88,49.92 219.32,49.92 216.28,46.88 214.51,46.88 R1624.1 213.29,46.28 211.3,46.28 210.85,46.72 v2(210.85,46.74) 210.85,47.18 R1636.2 211.25,47.59 R1623.2 R1655.2 ; v2(203.91,57.37) 204,57.37 RH105.1
PCH_RSMRST#_R: length 6.7
  BOTTOM w0.089: UH1.J2 205.66,62.07 205.29,61.71 205.29,61.07 204.89,60.67 204.89,60.28
  BOTTOM w0.102: 204.89,60.28 204.89,58.96 205.2,58.65 v1(205.2,57.8) 205.2,57.46 RH105.2 RH79.2
PCH_RTCRST#: length 175.4
  TOP w0.089: v2(210.81,61.06) 210.81,60.49 210.95,60.35
  TOP w0.102: v2(229.88,52.92) 230.15,52.92 230.73,52.34 239.5,52.34 242.35,55.18 243.06,55.18 245.27,57.39 245.27,58.08 246.87,59.68 246.87,59.69 250.25,63.07 v3(251.16,63.07) 251.46,63.07 251.96,63.07 252.18,63.28 252.18,63.28 253.07,64.17 256.3,64.17 256.55,63.92 261.6,63.92 261.84,64.16 262.46,64.16 263.94,65.63 266.34,65.63 267.12,64.86 268.85,64.86 268.92,64.79 271.34,64.79 272.69,66.14 277.84,66.14 280.11,68.4 280.11,93.31 283.8,97 v2(288.35,97) ; RH44.2 209.98,57.1 CH7.2 210.59,58.04 CMOS1.2 211.47,58.36 211.99,58.36 212.56,58.93 212.56,59.05 211.49,60.12 211.18,60.12 210.95,60.35 ; JAPS1.9 313.44,114.94 313.53,114.85 v2(313.55,114.85)
  IN1 w0.089: 210.95,60.36 210.81,60.5 v2(210.81,61.06)
  IN1 w0.102: 210.95,60.36 211.08,60.22 211.64,60.22 211.9,59.97 211.9,59.87 214.13,57.63 214.99,57.63 217.39,55.24 217.39,54.93 218.8,53.52 228.29,53.52 228.94,52.87 229.83,52.87 v2(229.88,52.92)
  IN4 w0.102: v2(288.35,97) 288.34,97.02 288.34,97.21 289.3,98.17 306.48,98.17 314.79,106.48 314.79,114.05 314.07,114.77 313.62,114.77 v2(313.55,114.85)
  BOTTOM w0.089: v2(210.81,61.06) 210.81,61.35 210.28,61.88 210.02,61.88 209.83,62.07 209.83,62.47 UH1.D9
PCH_RTCX1: length 6.3
  TOP w0.089: v2(208.34,61.19) 208.29,61.13 v1(208.29,59.96) 208.29,58.42 207.63,57.76 207.63,57.54
  TOP w0.102: 207.63,57.54 207.42,57.34 207.42,57.34 RH39.1 207.63,56.86 207.72,56.86 208.23,56.34
  BOTTOM w0.089: UH1.B5 208.76,61.19 v2(208.34,61.19)
PCH_RTCX1_R: length 2.8
  TOP w0.102: RH38.1 208.24,55.06 CH4.2 207.57,54.98 206.8,54.22 YH1.1
PCH_RTCX2: length 7.1
  TOP w0.089: 206.99,58.18 v1(207.45,58.64) 207.45,60.28 v2(207.87,60.7)
  TOP w0.102: YH1.2 205.11,55.87 205.9,55.87 CH5.2 206.64,56.6 RH39.2 206.77,57.99 206.79,57.99 206.99,58.18
  BOTTOM w0.089: UH1.B4 208.34,60.7 v2(207.87,60.7)
PCH_SATA_MOD_EN#: length 173.6
  TOP w0.102: U51.B36 283.04,117.41 283.49,117.85 v2(283.52,117.85) ; v2(254.06,114.7) v1(255,114.7)
  IN1 w0.102: v2(186.37,79.88) 186.8,80.31 186.8,86.72 183.37,90.14 183.37,99.77 183.31,99.83 v2(183.31,100.24)
  IN2 w0.127: v2(254.06,114.7) 254.06,114.7 258.69,114.7 258.94,114.95 274.03,114.95 274.21,115.13 279.3,115.13 279.71,115.54 279.71,116.22 279.95,116.46 281.59,116.46 282.55,115.51 283.72,115.51 284.02,115.81 284.02,116.6 283.97,116.65 283.97,117.44 283.55,117.85 v2(283.52,117.85)
  IN3 w0.127: v2(180.98,62.06) 180.83,62.22 180.83,71.18 185.35,75.7 185.35,78.87 v2(186.37,79.88) ; v2(183.31,100.24) 183.31,101.88 183.98,102.55 188.15,102.55 189.04,103.44 194.75,103.44 195.25,102.95 197.47,102.95 197.63,102.79 202.15,102.79 203.08,101.85 215.87,101.85 223.06,94.67 237.52,94.67 246.4,103.55 246.4,104.71 250.35,108.66 250.35,112.84 252.8,115.29 253.46,115.29 254.06,114.69 254.06,114.7 v2(254.06,114.7)
  BOTTOM w0.102: v2(180.98,62.06) 180.98,63.72 184.92,67.66 QH2.3
PCH_SMB_ALERT#: length 19.9
  IN2 w0.089: 204.54,60.64 204.59,60.69 204.61,60.69 205.19,61.28 205.19,63.12 v2(206.12,64.05)
  IN2 w0.127: 204.54,60.64 201.66,57.76 200.88,57.76 199.77,56.65 199.77,54.18 198.58,52.98 196.17,52.98 v2(195.83,53.33)
  BOTTOM w0.089: UH1.N7 206.07,64.11 v2(206.12,64.05)
  BOTTOM w0.102: RH166.2 195.39,53.76 v2(195.83,53.33) 195.83,53.31 v1(195.23,52.72)
PCH_SPI_CLK: length 82
  IN4 w0.089: v2(202.23,70.7) 200.23,70.7 199.56,70.04 199.56,69.7 199.23,69.37 197.61,69.37 197.34,69.1 196.07,69.1
  IN4 w0.102: v2(188.83,41.8) 188.83,41.59 188.7,41.47 188.25,41.47 188.12,41.59 188.12,42.67 187.99,42.8 187.59,42.8 187.46,42.67 187.46,41.99 187.33,41.86 186.72,41.86 186.6,41.99 186.6,44.72 181.39,49.93 181.39,68.4 184.53,71.54 190.7,71.54 193.6,68.65 195.62,68.65 196.07,69.1
  BOTTOM w0.089: v2(202.23,70.7) 202.4,70.54 UH1.AJ11
  BOTTOM w0.102: v2(188.83,41.8) 188.83,41.84 189.23,42.24 189.23,43.07 190.49,44.32 192.71,44.32 192.93,44.09 196.35,44.09 197.45,45.19 198.71,45.19 198.9,45.39 201.12,45.39 201.53,44.97 v1(203.48,44.97) 204.87,44.97 RH181.2 206.1,42.79 206.1,41.44 206.18,41.36 JSPI1.8
PCH_SPI_CS0#: length 76.7
  IN4 w0.102: v2(190.35,42.27) 190.32,42.27 189.47,43.11 189.47,44 182.84,50.63 182.84,66.08 183.62,66.86 183.62,67.01 183.49,67.13 183.49,67.3 183.61,67.42 183.78,67.42 183.9,67.29 184.05,67.29 184.19,67.44 184.19,67.58 183.55,68.22 183.55,68.39 183.67,68.5 183.84,68.5 184.47,67.88 184.63,67.88 184.75,68 184.75,68.17 184.13,68.79 184.13,68.96 185.29,70.12 188.61,70.12 193.47,65.26 194.25,65.26 194.53,64.97 195.29,64.97 196.23,65.91 197.04,65.91 197.21,65.74 197.6,65.36 198.22,65.36 199.79,66.92 199.79,68.26 v2(200.85,69.32)
  BOTTOM w0.089: UH1.AJ7 201.36,69.39 200.92,69.39 v2(200.85,69.32)
  BOTTOM w0.102: JSPI1.10 205.18,41.5 205.08,41.6 205.08,42.78 RH182.2 204.21,44.62 v1(201.95,44.62) 201.19,44.62 200.77,45.03 199.17,45.03 198.97,44.84 198.27,44.84 197.17,43.74 192.12,43.74 190.64,42.27 v2(190.35,42.27)
PCH_SPI_CS1#: length 77.7
  IN4 w0.089: 196.57,68.6 196.76,68.79 197.31,68.79
  IN4 w0.102: v2(201.33,69.84) 200.79,69.84 200.48,69.53 199.67,69.53 199.31,69.17 197.69,69.17 197.31,68.79 ; v2(187.43,44.34) 187.43,44.39 181.75,50.08 181.75,68.25 184.68,71.19 190.56,71.19 193.47,68.27 196.24,68.27 196.57,68.6
  BOTTOM w0.089: UH1.AL7 201.21,69.96 v2(201.33,69.84)
  BOTTOM w0.102: v2(187.43,44.34) 187.62,44.52 189.18,44.52 190.05,45.39 194.69,45.39 195.72,46.42 198.33,46.42 198.66,46.75 201.97,46.75 202.68,46.04 207.71,46.04 v1(208.59,45.16) 209.63,44.13 RH177.2 209.17,42.81 209.17,42.03 209.18,42.02 JSPI1.2
PCH_SPI_DIN: length 75.8
  IN4 w0.089: 198.16,66.88 198.52,66.88 198.82,66.58 198.82,66.57 v2(198.81,66.57)
  IN4 w0.102: 198.16,66.88 197.74,67.3 197.03,67.3 196.77,67.55 196.22,67.55 195.96,67.3 195.18,67.3 194.01,66.13 193.1,66.13 188.76,70.47 185.14,70.47 183.59,68.92 183.01,68.35 183.01,68.18 183.36,67.83 183.36,67.67 183.24,67.55 183.07,67.55 182.75,67.87 182.63,67.87 182.51,67.75 182.51,67.53 183.07,66.97 183.07,66.82 182.93,66.68 182.79,66.68 182.68,66.78 182.58,66.78 182.48,66.69 182.48,50.48 188.51,44.45 188.51,43.51 v2(188.83,43.19)
  BOTTOM w0.089: UH1.AH3 200.5,67.95 200.17,67.62 200.17,67.2 199.98,67.02 199.79,67.02 199.35,66.58 198.82,66.58 198.82,66.57 v2(198.81,66.57)
  BOTTOM w0.102: v2(188.83,43.19) 188.86,43.19 190.34,44.68 196.38,44.68 197.25,45.55 198.46,45.55 198.67,45.76 201.25,45.76 201.68,45.33 v1(205.3,45.33) 205.53,45.33 RH179.2 207.14,42.81 207.14,42.03 207.18,41.99 JSPI1.6
PCH_SPI_DO: length 76.6
  IN4 w0.089: 197.52,67.65 198.3,67.65 198.95,67 v2(199.21,67)
  IN4 w0.102: 197.52,67.65 197.18,67.65 196.92,67.91 196.07,67.91 195.82,67.65 195.03,67.65 193.86,66.49 193.25,66.49 188.9,70.83 184.99,70.83 182.13,67.96 182.13,50.25 187.94,44.43 187.94,43.43 v2(188.77,42.61)
  BOTTOM w0.089: v2(199.21,67) 199.42,67 199.74,67.32 UH1.AH1
  BOTTOM w0.102: JSPI1.4 208.15,40.42 208.15,42.81 RH178.2 208.61,43.28 v1(207.01,44.88) 206.21,45.69 202.53,45.69 201.83,46.39 198.8,46.39 198.36,45.95 197.11,45.95 196.2,45.03 190.19,45.03 189.24,44.08 189.15,44.08 188.43,43.36 188.43,42.95 v2(188.77,42.61)
PCH_SPI_DO2: length 76.9
  IN4 w0.102: v2(197.07,65.24) 196.53,65.24 195.77,64.48 194.52,64.48 194.1,64.9 193.62,64.9 193.62,64.9 193.32,64.9 188.46,69.76 187.61,69.76 187.39,69.55 187.24,69.55 187.03,69.76 186.86,69.76 186.74,69.64 186.74,69.48 186.96,69.26 186.96,69.12 186.74,68.9 186.5,68.9 185.63,69.76 185.45,69.76 185.3,69.61 185.3,69.43 186.2,68.53 186.2,68.36 186.07,68.23 185.89,68.23 184.99,69.14 184.81,69.14 184.64,68.97 184.64,68.79 185.23,68.2 185.23,67.97 183.19,65.94 183.19,50.78 189.85,44.12 189.85,43.37 v2(190.35,42.87)
  BOTTOM w0.089: UH1.AJ4 200.19,68.22 199.8,68.22 199.6,68.02 199.6,67.73 199.45,67.59 198.82,67.59 198.4,67.17 198.4,66.96 198.3,66.87
  BOTTOM w0.102: v2(190.35,42.87) 190.36,42.87 190.36,42.85 189.94,42.43 189.94,42.09 190.17,41.86 190.74,41.86 192.01,43.13 193.35,43.13 194.25,42.23 196.16,42.23 198.41,44.48 199.12,44.48 199.31,44.68 v1(200.27,44.68) 200.63,44.68 201.04,44.26 203.55,44.26 RH183.2 204.19,43.27 204.06,43.14 204.06,41.33 204.18,41.21 JSPI1.12 ; v2(197.07,65.24) 197.07,66.38 197.47,66.78 198.21,66.78 198.3,66.87
PCH_SPI_DO3: length 76.8
  IN4 w0.102: v2(190.32,43.51) 190.33,43.51 190.33,43.51 190.33,44.14 183.56,50.91 183.56,65.8 184.14,66.38 184.29,66.38 184.81,65.87 184.97,65.87 185.09,65.99 185.09,66.15 184.57,66.67 184.57,66.82 184.72,66.96 184.86,66.96 185.39,66.43 185.56,66.43 185.68,66.55 185.68,66.71 185.18,67.22 185.18,67.4 185.3,67.53 185.48,67.53 186.59,66.42 186.77,66.42 186.96,66.6 186.96,66.78 186.13,67.61 186.13,67.79 186.45,68.11 186.63,68.11 187.14,67.59 187.32,67.59 187.55,67.82 187.55,68 187.07,68.48 187.07,68.72 187.75,69.41 188.31,69.41 192.97,64.75 193.18,64.54 193.77,64.54 193.96,64.54 194.38,64.13 195.96,64.13 196.64,64.81 v2(196.68,64.81)
  BOTTOM w0.089: UH1.AJ2 199.91,67.79 199.53,67.41 198.89,67.41 198.59,67.11 198.59,66.88 198.45,66.74
  BOTTOM w0.102: v2(190.32,43.51) 190.33,43.5 190.33,43.5 189.59,42.75 189.59,41.78 189.86,41.5 190.89,41.5 192.12,42.74 192.92,42.74 193.78,41.87 196.31,41.87 198.56,44.13 v1(198.86,44.13) 199.27,44.13 199.46,44.32 200.48,44.32 200.89,43.91 202.89,43.91 RH184.2 203.01,42.74 203.01,42.02 203.18,41.85 JSPI1.14 ; 198.45,66.74 198.13,66.42 197.84,66.42 197.48,66.07 197.48,64.99 197.3,64.81 v2(196.68,64.81)
PCH_TD_IREF: length 11.2
  BOTTOM w0.102: UH1.AY43 209.24,83.6 209.24,84.11 209.41,84.28 209.41,84.56 209.17,84.8 209.17,86.03 207.76,87.45 207.69,87.45 205.83,89.32 205.54,89.32 205.22,89.63 RH176.1 204.56,90.16 203.96,90.77 v1(203.3,90.77)
PCH_THRMTRIP#_R: length 6
  TOP w0.102: CH17.1 RH206.2 193.24,69.46 v2(194.24,69.46)
  BOTTOM w0.089: UH1.AV1 196.9,70.28 196.22,70.28 195.96,70.01 195.96,69.82 195.65,69.52
  BOTTOM w0.102: 195.65,69.52 195.22,69.09 194.61,69.09 v2(194.24,69.46) 194.24,69.45 194.03,69.24 194.03,69 v1(194.01,68.99)
PCH_TP25: length 6.9
  TOP w0.089: 206.61,58.57 207.25,59.22 207.25,59.6 206.69,60.16 206.69,60.67 v1(206.51,60.85) 206.51,61.43 207.48,62.39 207.78,62.39 v2(208.18,62.79)
  TOP w0.102: RH53.2 206.56,58.52 206.61,58.57
  BOTTOM w0.089: UH1.F8 208.65,62.8 208.21,62.8 208.2,62.8 208.19,62.8 v2(208.18,62.79)
PCI_5048: length 2.4
  TOP w0.089: RH158.1 219.65,72.62 v2(219.65,72.47) 219.65,72.35 v1(219.35,72.05)
  BOTTOM w0.089: v2(219.65,72.47) 219.65,72.47 219.72,72.54 UH1.D44
PCI_DOCK: length 4.3
  TOP w0.089: 220.02,72.23 220.57,72.78 RH162.1 221.34,72.78 v1(222.16,71.97)
  TOP w0.102: v2(219.29,71.51) 220.02,72.23
  BOTTOM w0.089: v2(219.29,71.51) 219.29,71.61 UH1.B42
PCI_LOOPBACKOUT: length 4.3
  BOTTOM w0.089: UH1.A40 219.58,70.56 220.01,70.56 220.1,70.65 221.24,70.65
  BOTTOM w0.102: 221.24,70.65 221.95,70.65 RH164.1
PCI_MEC: length 2.5
  TOP w0.089: RH160.1 219.82,73.6 v2(219.17,72.94) 219.17,73.07 v1(218.84,73.39)
  BOTTOM w0.089: v2(219.17,72.94) 219.28,73.05 UH1.E44
PCI_PIRQA#: length 4.1
  TOP w0.089: RPH4.1 213.54,66.94 213.19,66.94 212.62,66.38 212.26,66.38 v1(211.88,66.75) 211.56,67.07 211.56,67.63 v2(211.49,67.7)
  BOTTOM w0.089: v2(211.49,67.7) 211.35,67.56 UH1.H20
PCI_PIRQB#: length 5.3
  TOP w0.089: RPH4.2 213.24,66.54 213.04,66.54 212.68,66.18 211.94,66.18 211.32,66.8 211.32,67.26 211.12,67.46 v2(210.44,67.46) 210.44,67.92 v1(210.56,68.05)
  BOTTOM w0.089: UH1.L20 210.5,67.53 v2(210.44,67.46)
PCI_PIRQC#: length 5.3
  TOP w0.089: v2(210.1,66.36) 210.6,66.36 211.16,65.8 211.74,65.8 212.61,64.93 212.91,64.93 213.39,65.42 213.39,65.67 RPH4.3
  BOTTOM w0.089: v2(210.1,66.36) 210.23,66.49 UH1.K17
PCI_PIRQD#: length 5.2
  TOP w0.089: RPH4.4 212.76,65.6 212.35,66 211.34,66 209.59,67.75 v2(209.59,68.32)
  BOTTOM w0.089: v2(209.59,68.32) 209.95,68.32 UH1.M20
PCI_TPM_TCM: length 8.2
  BOTTOM w0.089: UH1.C40 219,71.12 219.49,71.12 219.74,70.87 221.01,70.87 221.52,71.38 221.97,71.38
  BOTTOM w0.102: 221.97,71.38 223.04,70.31 RH155.2 223.81,69.55 224.33,69.04 224.84,69.04 v1(225.01,68.86)
PCIE#_SATA: length 8.1
  TOP w0.102: R747.1 317.37,127.14 v2(316.89,127.62) 317.36,128.09 R749.1 ; U7.17 319.94,131.22 v2(319.78,131.38)
  IN3 w0.127: v2(319.78,131.38) 319.78,130.75 316.89,127.86 v2(316.89,127.62)
  BOTTOM w0.102: v2(316.89,127.62) v1(316.89,126.95)
PCIE_B+: length 2.6
  BOTTOM w0.102: PC680.1 v1(197.51,97.42)
  BOTTOM w0.508: v2(196.13,98.63) PC680.1
PCIE_PRX_EMBTX_N4: length 113.3
  IN4 w0.102: 218.72,76.85 218.17,77.39 216.4,77.39 213.13,80.67 211.51,80.67 211,81.18 210.47,81.18 208.92,79.63 208.36,79.63 208.17,79.82 v2(207.2,79.82)
  IN4 w0.114: v2(243.21,53.52) 243.03,53.7 243.03,54.21 241.73,55.51 241.73,60.68 241.48,60.93 240.85,60.93 240.72,61.06 240.72,61.37 240.85,61.5 241.48,61.5 241.73,61.75 241.73,62.28 241.48,62.53 240.81,62.53 240.69,62.66 240.69,62.97 240.81,63.1 241.48,63.1 241.73,63.35 241.73,63.88 241.48,64.13 241.18,64.13 241.06,64.24 241.06,64.59 241.18,64.7 241.48,64.7 241.73,64.95 241.73,66.76 241.25,67.24 240.89,67.24 240.51,66.86 240.35,66.86 240.11,67.1 240.11,67.26 240.49,67.64 240.49,67.99 240.11,68.37 239.76,68.37 239.38,67.99 239.22,67.99 238.98,68.23 238.98,68.39 239.36,68.78 239.36,69.13 238.98,69.5 238.63,69.5 238.25,69.12 238.09,69.12 237.84,69.36 237.84,69.52 238.23,69.91 238.23,70.26 237.58,70.9 236.13,70.9 235.87,70.64 235.87,68.9 235.75,68.77 235.33,68.77 235.2,68.9 235.2,70.24 234.96,70.48 234.2,70.48 233.94,70.22 233.94,68.75 233.81,68.62 231.41,68.62 231.3,68.73 231.3,70.24 231.05,70.48 230.52,70.48 230.27,70.24 230.27,68.73 230.15,68.62 229.62,68.62 229.5,68.74 229.5,69.23 229.18,69.54 227.98,69.54 227.87,69.66 227.87,70.86 227.61,71.12 227.1,71.12 226.84,70.86 226.84,69.66 226.71,69.53 223.81,69.53 223.68,69.66 223.68,70.38 223.81,70.51 225.48,70.51 225.74,70.77 225.74,71.28 225.48,71.54 223.85,71.54 223.73,71.65 223.73,72 223.85,72.11 225.58,72.11 225.84,72.37 225.84,72.88 225.58,73.14 223.85,73.14 223.73,73.25 223.73,74.22 221.53,76.42 219.14,76.42 218.72,76.85
  BOTTOM w0.089: UH1.AT33 206.91,79.55 207.22,79.86 207.22,79.84 v2(207.2,79.82)
  BOTTOM w0.102: v2(243.21,53.52) 242.9,53.2 242.9,52.78 242.6,52.48 241.3,52.48 241.05,52.23 241.05,47.35 240.09,46.39 240.09,41.44 238.73,40.07 238.73,34.42 237.63,33.32 237.43,33.32 236.84,32.73 236.63,32.73 235.84,31.95 235.84,31.58 236.03,31.39 236.41,31.39 JSATA2.19
PCIE_PRX_EMBTX_P4: length 113.3
  IN4 w0.102: 218.55,76.69 218.54,76.7 218.54,76.71 218.49,76.76 218.49,76.76 218.08,77.18 216.32,77.18 213.04,80.45 211.42,80.45 210.91,80.96 210.56,80.96 209.01,79.41 208.27,79.41 208.08,79.6 207.73,79.6 207.63,79.5 207.63,79.41 v2(207.62,79.4)
  IN4 w0.114: v2(242.39,53.52) 242.62,53.29 242.74,53.29 242.8,53.35 242.8,54.11 241.5,55.42 241.5,60.59 241.38,60.7 240.76,60.7 240.5,60.96 240.5,61.47 240.76,61.73 241.38,61.73 241.5,61.84 241.5,62.19 241.38,62.3 240.72,62.3 240.46,62.56 240.46,63.07 240.72,63.33 241.38,63.33 241.5,63.44 241.5,63.79 241.38,63.9 241.08,63.9 240.83,64.15 240.83,64.68 241.08,64.93 241.38,64.93 241.5,65.05 241.5,66.66 241.15,67.01 240.99,67.01 240.61,66.63 240.26,66.63 239.88,67 239.88,67.36 240.26,67.74 240.26,67.9 240.02,68.14 239.86,68.14 239.48,67.76 239.12,67.76 238.75,68.14 238.75,68.49 239.13,68.87 239.13,69.03 238.89,69.27 238.73,69.27 238.34,68.89 237.99,68.89 237.62,69.27 237.62,69.62 238,70 238,70.16 237.49,70.68 236.23,70.68 236.1,70.55 236.1,68.8 235.84,68.54 235.24,68.54 234.98,68.8 234.98,70.14 234.86,70.26 234.3,70.26 234.17,70.13 234.17,68.66 233.9,68.39 231.32,68.39 231.07,68.64 231.07,70.14 230.95,70.26 230.61,70.26 230.5,70.14 230.5,68.64 230.25,68.39 229.53,68.39 229.27,68.65 229.27,69.13 229.09,69.31 227.89,69.31 227.64,69.56 227.64,70.76 227.51,70.89 227.2,70.89 227.07,70.76 227.07,69.56 226.81,69.3 223.71,69.3 223.45,69.56 223.45,70.48 223.71,70.74 225.38,70.74 225.51,70.86 225.51,71.18 225.38,71.31 223.75,71.31 223.5,71.56 223.5,72.09 223.75,72.34 225.48,72.34 225.61,72.46 225.61,72.78 225.48,72.91 223.75,72.91 223.5,73.16 223.5,74.13 221.44,76.19 219.05,76.19 218.55,76.69
  BOTTOM w0.089: UH1.AR33 207.33,79.32 207.41,79.4 v2(207.62,79.4)
  BOTTOM w0.102: v2(242.39,53.52) 242.69,53.22 242.69,52.87 242.51,52.69 241.21,52.69 240.84,52.32 240.84,47.44 239.88,46.48 239.88,41.53 238.51,40.16 238.51,34.51 237.54,33.54 237.34,33.54 236.75,32.94 236.54,32.94 235.63,32.04 235.63,31.49 235.76,31.36 235.76,31.14 JSATA2.18
PCIE_PRX_EXPTX_N7: length 156.6
  TOP w0.102: JEXP1.15 288.99,31.06 288.76,31.28 287.56,31.28 v2(287.38,31.1)
  IN4 w0.089: 210.81,82.45 210.8,82.44 210.78,82.44 210.73,82.4 210.63,82.4 210.55,82.4 210.55,82.4 210.47,82.4 209.92,82.4 209.53,82.01 208.85,82.01 208.68,81.84 208.68,81.69 208.77,81.6 v2(208.92,81.6)
  IN4 w0.114: 210.81,82.45 210.94,82.59 213.74,82.59 217.31,79.02 221.04,79.02 223.72,76.34 224.14,76.34 224.69,75.79 224.78,75.79 228.83,71.74 234.94,71.74 235.7,72.5 239.75,72.5 243.34,68.91 243.34,55.68 244.53,54.49 244.53,53.16 244.8,52.9 245.43,52.9 245.69,53.16 245.69,54.2 245.82,54.33 246.87,54.33 247.05,54.51 247.58,54.51 247.86,54.79 247.86,55.32 248.09,55.55 249.06,55.55 249.31,55.8 249.31,57.05 249.42,57.16 249.76,57.16 249.88,57.05 249.88,55.72 250.13,55.46 250.54,55.46 250.87,55.79 251.08,55.79 251.41,55.46 251.71,55.46 v2(251.89,55.28)
  BOTTOM w0.089: v2(208.92,81.6) 208.82,81.5 208.82,81.38 208.95,81.25 209.32,81.25 UH1.AT40
  BOTTOM w0.102: v2(251.89,55.28) 252.08,55.48 252.28,55.48 252.91,54.86 252.91,54.71 252.57,54.38 252.57,54.06 252.91,53.72 253.23,53.72 253.56,54.06 253.71,54.06 253.92,53.84 253.92,53.7 253.59,53.36 253.59,53.05 253.93,52.71 254.25,52.71 254.58,53.04 254.72,53.04 255.07,52.69 255.07,52.45 254.24,51.62 254.24,51.27 254.83,50.68 255.39,50.68 255.75,50.32 255.75,47 256.27,46.48 256.27,43.78 256.83,43.21 256.83,38.79 256.03,37.99 256.03,37.18 255.39,36.54 255.39,35.37 254.92,34.89 254.92,29.92 258.78,26.05 259.27,26.05 259.61,26.39 259.76,26.39 259.97,26.17 259.97,26.03 259.63,25.69 259.63,25.37 260.05,24.96 260.4,24.96 260.52,25.07 260.98,25.07 261.26,24.8 280.28,24.8 284.06,28.58 284.06,29.71 284.17,29.81 285.53,29.81 285.78,30.06 285.78,30.49 285.53,30.74 284.16,30.74 284.03,30.87 284.03,34.92 284.16,35.05 284.91,35.05 285.04,34.92 285.04,31.7 285.26,31.48 287.01,31.48 v2(287.38,31.1)
PCIE_PRX_EXPTX_P7: length 156.7
  TOP w0.102: JEXP1.17 288.82,31.56 288.76,31.5 287.57,31.5 v2(287.38,31.69)
  IN4 w0.089: v2(208.34,81.53) 208.48,81.67 208.48,81.93 208.76,82.21 209.45,82.21 209.83,82.6 210.55,82.6 210.56,82.6 210.63,82.6 210.64,82.61
  IN4 w0.114: 210.64,82.61 210.85,82.82 213.84,82.82 217.41,79.25 221.13,79.25 223.81,76.57 224.24,76.57 224.79,76.02 224.87,76.02 228.93,71.97 234.84,71.97 235.61,72.73 239.84,72.73 243.57,69.01 243.57,55.78 244.76,54.58 244.76,53.25 244.89,53.12 245.33,53.12 245.46,53.25 245.46,54.29 245.73,54.56 246.78,54.56 246.95,54.74 247.49,54.74 247.63,54.88 247.63,55.42 248,55.78 248.96,55.78 249.08,55.89 249.08,57.14 249.32,57.39 249.86,57.39 250.11,57.14 250.11,55.81 250.23,55.69 250.45,55.69 250.78,56.02 251.18,56.02 251.51,55.69 251.71,55.69 v2(251.89,55.87)
  BOTTOM w0.089: v2(208.34,81.53) 208.34,81.51 208.91,80.93 UH1.AT39
  BOTTOM w0.102: v2(251.89,55.87) 252.06,55.69 252.37,55.69 253.12,54.94 253.12,54.63 252.78,54.29 252.78,54.15 253,53.93 253.14,53.93 253.48,54.27 253.79,54.27 254.13,53.93 254.13,53.61 253.8,53.28 253.8,53.13 254.02,52.92 254.16,52.92 254.49,53.25 254.81,53.25 255.28,52.78 255.28,52.36 254.45,51.53 254.45,51.35 254.91,50.89 255.48,50.89 255.96,50.41 255.96,47.09 256.48,46.57 256.48,43.86 257.04,43.3 257.04,38.7 256.24,37.9 256.24,37.09 255.6,36.45 255.6,35.28 255.13,34.8 255.13,30 258.87,26.26 259.19,26.26 259.52,26.6 259.84,26.6 260.18,26.26 260.18,25.94 259.84,25.6 259.84,25.46 260.13,25.17 260.32,25.17 260.44,25.29 261.07,25.29 261.35,25.01 280.19,25.01 283.85,28.67 283.85,29.8 284.08,30.02 285.45,30.02 285.57,30.15 285.57,30.4 285.45,30.53 284.07,30.53 283.82,30.78 283.82,35.01 284.07,35.26 285,35.26 285.25,35.01 285.25,31.79 285.35,31.69 v2(287.38,31.69)
