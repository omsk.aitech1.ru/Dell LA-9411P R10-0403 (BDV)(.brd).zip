# Allegro board LA-9411P R10-0403.brd (continued)
## Footprints (pads in the part's own frame, mm; a bottom-side part is the same pattern mirrored in y, then rotated) (continued)
CYNTE_PCMC063T-2R2MN_2P
  rect 1.854x3.505 smd: 1(0,0) 2(5.55,0)
DH82LPMS-QCG1-B0_FCBGA_695P
  round 0.483 smd: A2(0.624,0) A44(18.101,0) B1(0,-0.624) B45(18.625,-0.524) BD1(0,-18.101) BD45(18.625,-18.101) BE2(0.524,-18.625) BE44(18.101,-18.625)
  round 0.356 smd: A4(1.217,0) A5(1.81,0) A41(16.915,0) A43(17.508,0) B2(0.603,-0.603) B44(18.022,-0.603) BA1(0,-16.915) BA45(18.625,-16.915) BC1(0,-17.508) BC45(18.625,-17.508) BD2(0.603,-18.022) BD44(18.022,-18.022) BE3(1.117,-18.625) BE5(1.71,-18.625) BE41(16.915,-18.625) BE43(17.508,-18.625) C45(18.625,-1.117) D1(0,-1.217) E1(0,-1.81) E45(18.625,-1.71)
  round 0.33 smd: A6(2.483,0) A40(16.242,0) AY1(0,-16.242) AY45(18.625,-16.242) B4(1.315,-0.586) B42(17.233,-0.637) BA2(0.551,-16.664) BB2(0.563,-17.31) BB44(17.988,-17.233) BD4(1.391,-17.988) BD41(16.664,-18.074) BD42(17.31,-18.061) BE6(2.383,-18.625) BE40(16.242,-18.625) D2(0.637,-1.391) D44(18.061,-1.315) E44(18.074,-1.96) F1(0,-2.483) F45(18.625,-2.383)
  round 0.305 smd: A8(3.216,0) A10(4.029,0) A12(4.842,0) A14(5.655,0) A16(6.468,0) A18(7.28,0) A20(8.093,0) A22(8.906,0) A24(9.719,0) A26(10.532,0) A28(11.344,0) A30(12.157,0) A32(12.97,0) A34(13.783,0) A36(14.596,0) A38(15.408,0) AA2(0.452,-8.478) AA4(1.336,-8.5) AA14(5.515,-8.827) AA16(6.328,-8.827) AA18(7.141,-8.827) AA20(7.954,-8.827) AA22(8.766,-8.827) AA24(9.579,-8.827) AA26(10.392,-8.827) AA28(11.205,-8.827) AA30(12.018,-8.827) AA32(12.83,-8.827) AA42(17.289,-8.5) AA44(18.173,-8.521) AB1(0,-8.906) AB3(0.904,-8.906) AB6(1.934,-9.008) AB7(2.531,-9.008) AB8(3.128,-9.008) AB10(3.724,-9.008) AB11(4.321,-9.008) AB12(4.918,-9.008) AB34(13.707,-9.008) AB35(14.304,-9.008) AB36(14.9,-9.008) AB38(15.497,-9.008) AB39(16.094,-9.008) AB40(16.691,-9.008) AB43(17.721,-8.906) AB45(18.625,-8.906) AC2(0.472,-9.312) AC44(18.152,-9.312) AD1(0,-9.719) AD3(0.904,-9.719) AD6(1.934,-9.617) AD7(2.531,-9.617) AD8(3.128,-9.617) AD10(3.724,-9.617) AD11(4.321,-9.617) AD12(4.918,-9.617) AD14(5.515,-9.488) AD16(6.328,-9.488) AD18(7.141,-9.488) AD20(7.954,-9.488) AD22(8.766,-9.488) AD24(9.579,-9.488) AD26(10.392,-9.488) AD28(11.205,-9.488) AD30(12.018,-9.488) AD32(12.83,-9.488) AD34(13.707,-9.617) AD35(14.304,-9.617) AD36(14.9,-9.617) AD38(15.497,-9.617) AD39(16.094,-9.617) AD40(16.691,-9.617) AD43(17.721,-9.719) AD45(18.625,-9.719) AE2(0.452,-10.103) AE4(1.336,-10.125) AE14(5.515,-10.148) AE16(6.328,-10.148) AE18(7.141,-10.148) AE20(7.954,-10.148) AE22(8.766,-10.148) AE24(9.579,-10.148) AE26(10.392,-10.148) AE28(11.205,-10.148) AE30(12.018,-10.148) AE32(12.83,-10.148) AE42(17.289,-10.125) AE44(18.173,-10.147) AF1(0,-10.532) AF3(0.904,-10.532) AF6(1.934,-10.595) AF7(2.531,-10.595) AF8(3.128,-10.595) AF10(3.724,-10.595) AF11(4.321,-10.595) AF12(4.918,-10.595) AF34(13.707,-10.595) AF35(14.304,-10.595) AF36(14.9,-10.595) AF38(15.497,-10.595) AF39(16.094,-10.595) AF40(16.691,-10.595) AF43(17.721,-10.532) AF45(18.625,-10.532) AG2(0.472,-10.938) AG14(5.515,-10.808) AG16(6.328,-10.808) AG18(7.141,-10.808) AG20(7.954,-10.808) AG22(8.766,-10.808) AG24(9.579,-10.808) AG26(10.392,-10.808) AG28(11.205,-10.808) AG30(12.018,-10.808) AG32(12.83,-10.808) AG44(18.152,-10.938) AH1(0,-11.344) AH3(0.904,-11.344) AH43(17.721,-11.344) AH45(18.625,-11.344) AJ2(0.452,-11.729) AJ4(1.336,-11.751) AJ6(1.934,-11.573) AJ7(2.531,-11.573) AJ8(3.128,-11.573) AJ10(3.724,-11.573) AJ11(4.321,-11.573) AJ12(4.918,-11.573) AJ14(5.515,-11.469) AJ16(6.328,-11.469) AJ18(7.141,-11.469) AJ20(7.954,-11.469) AJ22(8.766,-11.469) AJ24(9.579,-11.469) AJ26(10.392,-11.469) AJ28(11.205,-11.469) AJ30(12.018,-11.469) AJ32(12.83,-11.469) AJ34(13.707,-11.573) AJ35(14.304,-11.573) AJ36(14.9,-11.573) AJ38(15.497,-11.573) AJ39(16.094,-11.573) AJ40(16.691,-11.573) AJ42(17.289,-11.751) AJ44(18.173,-11.773) AK1(0,-12.157) AK3(0.904,-12.157) AK14(5.515,-12.129) AK16(6.328,-12.129) AK18(7.141,-12.129) AK20(7.954,-12.129) AK22(8.766,-12.129) AK24(9.579,-12.129) AK26(10.392,-12.129) AK28(11.205,-12.129) AK30(12.018,-12.129) AK32(12.83,-12.129) AK43(17.721,-12.157) AK45(18.625,-12.157) AL2(0.472,-12.564) AL6(1.934,-12.551) AL7(2.531,-12.551) AL8(3.128,-12.551) AL10(3.724,-12.551) AL11(4.321,-12.551) AL12(4.918,-12.551) AL34(13.707,-12.551) AL35(14.304,-12.551) AL36(14.9,-12.551) AL38(15.497,-12.551) AL39(16.094,-12.551) AL40(16.691,-12.551) AL44(18.152,-12.564) AM1(0,-12.97) AM3(0.904,-12.97) AM14(5.515,-12.79) AM16(6.328,-12.79) AM18(7.141,-12.79) AM20(7.954,-12.79) AM22(8.766,-12.79) AM24(9.579,-12.79) AM26(10.392,-12.79) AM28(11.205,-12.79) AM30(12.018,-12.79) AM32(12.83,-12.79) AM43(17.721,-12.97) AM45(18.625,-12.97) AN2(0.452,-13.355) AN4(1.336,-13.376) AN6(1.934,-13.529) AN7(2.531,-13.529) AN8(3.128,-13.529) AN10(3.724,-13.529) AN11(4.321,-13.529) AN34(13.656,-13.529) AN35(14.304,-13.529) AN36(14.9,-13.529) AN38(15.497,-13.529) AN39(16.094,-13.529) AN40(16.691,-13.529) AN42(17.289,-13.376) AN44(18.173,-13.398) AP1(0,-13.783) AP3(0.904,-13.783) AP13(5.096,-13.656) AP15(6.074,-13.707) AP17(7.052,-13.707) AP20(8.03,-13.707) AP22(9.008,-13.707) AP24(9.617,-13.707) AP26(10.595,-13.707) AP29(11.573,-13.707) AP31(12.551,-13.707) AP43(17.721,-13.783) AP45(18.625,-13.783) AR2(0.472,-14.189) AR13(5.096,-14.304) AR15(6.074,-14.304) AR17(7.052,-14.304) AR20(8.03,-14.304) AR22(9.008,-14.304) AR24(9.617,-14.304) AR26(10.595,-14.304) AR29(11.573,-14.304) AR31(12.551,-14.304) AR33(13.529,-14.304) AR44(18.152,-14.189) AT1(0,-14.596) AT3(0.904,-14.596) AT6(1.934,-14.507) AT7(2.531,-14.507) AT8(3.128,-14.507) AT10(4.118,-14.9) AT13(5.096,-14.9) AT15(6.074,-14.9) AT17(7.052,-14.9) AT20(8.03,-14.9) AT22(9.008,-14.9) AT24(9.617,-14.9) AT26(10.595,-14.9) AT29(11.573,-14.9) AT31(12.551,-14.9) AT33(13.529,-14.9) AT36(14.9,-14.507) AT38(15.497,-14.507) AT39(16.094,-14.507) AT40(16.691,-14.507) AT43(17.721,-14.596) AT45(18.625,-14.596) AU2(0.452,-14.98) AU4(1.336,-15.002) AU42(17.289,-15.002) AU44(18.173,-15.024) AV1(0,-15.408) AV3(0.904,-15.408) AV6(1.934,-15.485) AV7(2.531,-15.485) AV10(4.118,-15.497) AV13(5.096,-15.497) AV15(6.074,-15.497) AV17(7.052,-15.497) AV20(8.03,-15.497) AV22(9.008,-15.497) AV24(9.617,-15.497) AV26(10.595,-15.497) AV29(11.573,-15.497) AV31(12.551,-15.497) AV33(13.529,-15.497) AV36(14.507,-15.497) AV40(16.691,-15.485) AV43(17.721,-15.408) AV45(18.625,-15.408) AW2(0.472,-15.815) AW8(3.14,-16.094) AW10(4.118,-16.094) AW13(5.096,-16.094) AW15(6.074,-16.094) AW17(7.052,-16.094) AW20(8.03,-16.094) AW22(9.008,-16.094) AW24(9.617,-16.094) AW26(10.595,-16.094) AW29(11.573,-16.094) AW31(12.551,-16.094) AW33(13.529,-16.094) AW36(14.507,-16.094) AW38(15.485,-16.094) AW40(17.123,-16.221) AW44(18.152,-15.815) AY3(0.978,-16.221) AY5(1.743,-16.051) AY7(2.404,-17.123) AY8(3.14,-16.691) AY10(4.118,-16.691) AY13(5.096,-16.691) AY15(6.074,-16.691) AY17(7.052,-16.691) AY20(8.03,-16.691) AY22(9.008,-16.691) AY24(9.617,-16.691) AY26(10.595,-16.691) AY29(11.573,-16.691) AY31(12.551,-16.691) AY33(13.529,-16.691) AY36(14.507,-16.691) AY38(15.485,-16.691) AY43(17.721,-16.221) B5(1.96,-0.586) B7(2.739,-0.552) B9(3.645,-0.452) B11(4.436,-0.472) B13(5.27,-0.452) B15(6.061,-0.472) B17(6.896,-0.452) B19(7.687,-0.472) B21(8.521,-0.452) B23(9.312,-0.472) B25(10.147,-0.452) B27(10.938,-0.472) B29(11.773,-0.452) B31(12.564,-0.472) B33(13.398,-0.452) B35(14.189,-0.472) B37(15.024,-0.452) B39(15.815,-0.472) BA40(16.051,-16.882) BB4(1.391,-17.302) BB9(3.623,-17.289) BB13(5.248,-17.289) BB17(6.874,-17.289) BB21(8.5,-17.289) BB25(10.125,-17.289) BB29(11.751,-17.289) BB33(13.376,-17.289) BB37(15.002,-17.289) BB42(17.302,-17.233) BC6(2.404,-17.721) BC8(3.216,-17.721) BC10(4.029,-17.721) BC12(4.842,-17.721) BC14(5.655,-17.721) BC16(6.468,-17.721) BC18(7.28,-17.721) BC20(8.093,-17.721) BC22(8.906,-17.721) BC24(9.719,-17.721) BC26(10.532,-17.721) BC28(11.344,-17.721) BC30(12.157,-17.721) BC32(12.97,-17.721) BC34(13.783,-17.721) BC36(14.596,-17.721) BC38(15.408,-17.721) BC40(16.221,-17.647) BD7(2.81,-18.152) BD9(3.601,-18.173) BD11(4.436,-18.152) BD13(5.227,-18.173) BD15(6.061,-18.152) BD17(6.852,-18.173) BD19(7.687,-18.152) BD21(8.478,-18.173) BD23(9.312,-18.152) BD25(10.103,-18.173) BD27(10.938,-18.152) BD29(11.729,-18.173) BD31(12.564,-18.152) BD33(13.355,-18.173) BD35(14.189,-18.152) BD37(14.98,-18.173) BD39(15.815,-18.152) BE8(3.216,-18.625) BE10(4.029,-18.625) BE12(4.842,-18.625) BE14(5.655,-18.625) BE16(6.468,-18.625) BE18(7.28,-18.625) BE20(8.093,-18.625) BE22(8.906,-18.625) BE24(9.719,-18.625) BE26(10.532,-18.625) BE28(11.344,-18.625) BE30(12.157,-18.625) BE32(12.97,-18.625) BE34(13.783,-18.625) BE36(14.596,-18.625) BE38(15.408,-18.625) C6(2.37,-1.017) C8(3.216,-0.904) C10(4.029,-0.904) C12(4.842,-0.904) C14(5.655,-0.904) C16(6.468,-0.904) C18(7.28,-0.904) C20(8.093,-0.904) C22(8.906,-0.904) C24(9.719,-0.904) C26(10.532,-0.904) C28(11.344,-0.904) C30(12.157,-0.904) C32(12.97,-0.904) C34(13.783,-0.904) C36(14.596,-0.904) C38(15.408,-0.904) C40(16.221,-0.904) D4(1.323,-1.391) D9(3.623,-1.336) D13(5.248,-1.336) D17(6.874,-1.336) D21(8.5,-1.336) D25(10.125,-1.336) D29(11.751,-1.336) D33(13.376,-1.336) D37(15.002,-1.336) D42(17.233,-1.323) E6(2.574,-1.743) F3(0.978,-2.359) F8(3.14,-1.934) F10(4.118,-1.934) F13(5.096,-1.934) F15(6.074,-1.934) F17(7.052,-1.934) F20(8.03,-1.934) F22(9.008,-1.934) F24(9.617,-1.934) F26(10.595,-1.934) F29(11.573,-1.934) F31(12.551,-1.934) F33(13.529,-1.934) F36(14.507,-1.934) F38(15.485,-1.934) F39(16.221,-1.502) F41(16.882,-2.574) F43(17.647,-2.404) G2(0.532,-2.752) G5(1.562,-2.48) G8(3.14,-2.531) G10(4.118,-2.531) G13(5.096,-2.531) G15(6.074,-2.531) G17(7.052,-2.531) G20(8.03,-2.531) G22(9.008,-2.531) G24(9.617,-2.531) G26(10.595,-2.531) G29(11.573,-2.531) G31(12.551,-2.531) G33(13.529,-2.531) G36(14.507,-2.531) G38(15.485,-2.531) G44(18.152,-2.81) H1(0,-3.216) H3(0.904,-3.216) H6(1.934,-3.14) H7(2.531,-3.14) H10(4.118,-3.128) H13(5.096,-3.128) H15(6.074,-3.128) H17(7.052,-3.128) H20(8.03,-3.128) H22(9.008,-3.128) H24(9.617,-3.128) H26(10.595,-3.128) H29(11.573,-3.128) H31(12.551,-3.128) H33(13.529,-3.128) H36(14.507,-3.128) H39(16.094,-3.14) H40(16.691,-3.14) H43(17.721,-3.216) H45(18.625,-3.216) J2(0.452,-3.601) J4(1.336,-3.623) J42(17.289,-3.623) J44(18.173,-3.645) K1(0,-4.029) K3(0.904,-4.029) K6(1.934,-4.118) K7(2.531,-4.118) K8(3.128,-4.118) K10(3.724,-4.118) K13(5.096,-3.724) K15(6.074,-3.724) K17(7.052,-3.724) K20(8.03,-3.724) K22(9.008,-3.724) K24(9.617,-3.724) K26(10.595,-3.724) K29(11.573,-3.724) K31(12.551,-3.724) K33(13.529,-3.724) K36(14.507,-3.724) K38(15.497,-4.118) K39(16.094,-4.118) K40(16.691,-4.118) K43(17.721,-4.029) K45(18.625,-4.029) L2(0.472,-4.436) L13(5.096,-4.321) L15(6.074,-4.321) L17(7.052,-4.321) L20(8.03,-4.321) L22(9.008,-4.321) L24(9.617,-4.321) L26(10.595,-4.321) L29(11.573,-4.321) L31(12.551,-4.321) L33(13.529,-4.321) L44(18.152,-4.436) M1(0,-4.842) M3(0.904,-4.842) M15(6.074,-4.918) M17(7.052,-4.918) M20(8.03,-4.918) M22(9.008,-4.918) M24(9.617,-4.918) M26(10.595,-4.918) M29(11.573,-4.918) M31(12.551,-4.918) M33(13.529,-4.969) M43(17.721,-4.842) M45(18.625,-4.842) N2(0.452,-5.227) N4(1.336,-5.248) N6(1.934,-5.096) N7(2.531,-5.096) N8(3.128,-5.096) N10(3.724,-5.096) N11(4.321,-5.096) N12(4.969,-5.096) N35(14.304,-5.096) N36(14.9,-5.096) N38(15.497,-5.096) N39(16.094,-5.096) N40(16.691,-5.096) N42(17.289,-5.248) N44(18.173,-5.27) P1(0,-5.655) P3(0.904,-5.655) P14(5.515,-5.525) P16(6.328,-5.525) P18(7.141,-5.525) P20(7.954,-5.525) P22(8.766,-5.525) P24(9.579,-5.525) P26(10.392,-5.525) P28(11.205,-5.525) P30(12.018,-5.525) P32(12.83,-5.525) P43(17.721,-5.655) P45(18.625,-5.655) R2(0.472,-6.061) R6(1.934,-6.074) R7(2.531,-6.074) R8(3.128,-6.074) R10(3.724,-6.074) R11(4.321,-6.074) R12(4.918,-6.074) R14(5.515,-6.186) R16(6.328,-6.186) R18(7.141,-6.186) R20(7.954,-6.186) R22(8.766,-6.186) R24(9.579,-6.186) R26(10.392,-6.186) R28(11.205,-6.186) R30(12.018,-6.186) R32(12.83,-6.186) R34(13.707,-6.074) R35(14.304,-6.074) R36(14.9,-6.074) R38(15.497,-6.074) R39(16.094,-6.074) R40(16.691,-6.074) R44(18.152,-6.061) T1(0,-6.468) T3(0.904,-6.468) T43(17.721,-6.468) T45(18.625,-6.468) U2(0.452,-6.852) U4(1.336,-6.874) U6(1.934,-7.052) U7(2.531,-7.052) U8(3.128,-7.052) U10(3.724,-7.052) U11(4.321,-7.052) U12(4.918,-7.052) U14(5.515,-6.846) U16(6.328,-6.846) U18(7.141,-6.846) U20(7.954,-6.846) U22(8.766,-6.846) U24(9.579,-6.846) U26(10.392,-6.846) U28(11.205,-6.846) U30(12.018,-6.846) U32(12.83,-6.846) U34(13.707,-7.052) U35(14.304,-7.052) U36(14.9,-7.052) U38(15.497,-7.052) U39(16.094,-7.052) U40(16.691,-7.052) U42(17.289,-6.874) U44(18.173,-6.896) V1(0,-7.28) V3(0.904,-7.28) V14(5.515,-7.506) V16(6.328,-7.506) V18(7.141,-7.506) V20(7.954,-7.506) V22(8.766,-7.506) V24(9.579,-7.506) V26(10.392,-7.506) V28(11.205,-7.506) V30(12.018,-7.506) V32(12.83,-7.506) V43(17.721,-7.28) V45(18.625,-7.28) W2(0.472,-7.687) W44(18.152,-7.687) Y1(0,-8.093) Y3(0.904,-8.093) Y6(1.934,-8.03) Y7(2.531,-8.03) Y8(3.128,-8.03) Y10(3.724,-8.03) Y11(4.321,-8.03) Y12(4.918,-8.03) Y14(5.515,-8.167) Y16(6.328,-8.167) Y18(7.141,-8.167) Y20(7.954,-8.167) Y22(8.766,-8.167) Y24(9.579,-8.167) Y26(10.392,-8.167) Y28(11.205,-8.167) Y30(12.018,-8.167) Y32(12.83,-8.167) Y34(13.707,-8.03) Y35(14.304,-8.03) Y36(14.9,-8.03) Y38(15.497,-8.03) Y39(16.094,-8.03) Y40(16.691,-8.03) Y43(17.721,-8.093) Y45(18.625,-8.093)
DMG2301U-7_SOT23-3
  oval 1.016x1.524 smd: 1(0,0) 2(0.965,2.083) 3(-0.965,2.083)
DMN65D8LW-7_SOT323-3
  oval 0.711x0.889 smd: 1(0,0) 2(-0.65,-1.9) 3(0.65,-1.9)
DMN66D0LDW-7_SOT363-6
  oval 0.432x0.61 smd: 1(0,0) 2(0.65,0) 3(1.3,0) 4(1.3,1.9) 5(0.65,1.9) 6(0,1.9)
E-T_1001K-F30C-02L_30P-T
  round 0.66 hole 0.66 unplated: (-8.31,-2.425) (1.19,-2.425)
  oval 0.381x1.143 smd: 1(0,0) 2(0,-4.85) 29(-7.12,0) 30(-7.12,-4.85)
  oval 0.254x1.143 smd: 3(-0.56,0) 4(-0.56,-4.85) 5(-1.06,0) 6(-1.06,-4.85) 7(-1.56,0) 8(-1.56,-4.85) 9(-2.06,0) 10(-2.06,-4.85) 11(-2.56,0) 12(-2.56,-4.85) 13(-3.06,0) 14(-3.06,-4.85) 15(-3.56,0) 16(-3.56,-4.85) 17(-4.06,0) 18(-4.06,-4.85) 19(-4.56,0) 20(-4.56,-4.85) 21(-5.06,0) 22(-5.06,-4.85) 23(-5.56,0) 24(-5.56,-4.85) 25(-6.06,0) 26(-6.06,-4.85) 27(-6.56,0) 28(-6.56,-4.85)
  custom 0.4x0.4 smd: 31(-9.26,-2.425) 32(2.14,-2.425)
ECE5048-LZY_DQFN132_11X11
  oval 0.279x0.737 smd: A1(0,0) A2(0.5,0) A3(1,0) A4(1.5,0) A5(2,0) A6(2.5,0) A7(3,0) A8(3.5,0) A9(4,0) A10(4.5,0) A11(5,0) A12(5.5,0) A13(6,0) A14(6.5,0) A15(7,0) A16(7.5,0) A33(7.5,10.9) A34(7,10.9) A35(6.5,10.9) A36(6,10.9) A37(5.5,10.9) A38(5,10.9) A39(4.5,10.9) A40(4,10.9) A41(3.5,10.9) A42(3,10.9) A43(2.5,10.9) A44(2,10.9) A45(1.5,10.9) A46(1,10.9) A47(0.5,10.9) A48(0,10.9)
  oval 0.737x0.279 smd: A17(9.2,1.7) A18(9.2,2.2) A19(9.2,2.7) A20(9.2,3.2) A21(9.2,3.7) A22(9.2,4.2) A23(9.2,4.7) A24(9.2,5.2) A25(9.2,5.7) A26(9.2,6.2) A27(9.2,6.7) A28(9.2,7.2) A29(9.2,7.7) A30(9.2,8.2) A31(9.2,8.7) A32(9.2,9.2) A49(-1.7,9.2) A50(-1.7,8.7) A51(-1.7,8.2) A52(-1.7,7.7) A53(-1.7,7.2) A54(-1.7,6.7) A55(-1.7,6.2) A56(-1.7,5.7) A57(-1.7,5.2) A58(-1.7,4.7) A59(-1.7,4.2) A60(-1.7,3.7) A61(-1.7,3.2) A62(-1.7,2.7) A63(-1.7,2.2) A64(-1.7,1.7)
  oval 0.318x0.61 smd: B1(-0.25,0.855) B2(0.25,0.855) B3(0.75,0.855) B4(1.25,0.855) B5(1.75,0.855) B6(2.25,0.855) B7(2.75,0.855) B8(3.25,0.855) B9(3.75,0.855) B10(4.25,0.855) B11(4.75,0.855) B12(5.25,0.855) B13(5.75,0.855) B14(6.25,0.855) B15(6.75,0.855) B16(7.25,0.855) B17(7.75,0.855) B35(7.75,10.045) B36(7.25,10.045) B37(6.75,10.045) B38(6.25,10.045) B39(5.75,10.045) B40(5.25,10.045) B41(4.75,10.045) B42(4.25,10.045) B43(3.75,10.045) B44(3.25,10.045) B45(2.75,10.045) B46(2.25,10.045) B47(1.75,10.045) B48(1.25,10.045) B49(0.75,10.045) B50(0.25,10.045) B51(-0.25,10.045)
  oval 0.61x0.318 smd: B18(8.345,1.45) B19(8.345,1.95) B20(8.345,2.45) B21(8.345,2.95) B22(8.345,3.45) B23(8.345,3.95) B24(8.345,4.45) B25(8.345,4.95) B26(8.345,5.45) B27(8.345,5.95) B28(8.345,6.45) B29(8.345,6.95) B30(8.345,7.45) B31(8.345,7.95) B32(8.345,8.45) B33(8.345,8.95) B34(8.345,9.45) B52(-0.845,9.45) B53(-0.845,8.95) B54(-0.845,8.45) B55(-0.845,7.95) B56(-0.845,7.45) B57(-0.845,6.95) B58(-0.845,6.45) B59(-0.845,5.95) B60(-0.845,5.45) B61(-0.845,4.95) B62(-0.845,4.45) B63(-0.845,3.95) B64(-0.845,3.45) B65(-0.845,2.95) B66(-0.845,2.45) B67(-0.845,1.95) B68(-0.845,1.45)
  rect 5.105x5.105 smd: C1(3.75,5.45)
EMI-110X138
  rect 2.794x3.505 smd: 1(0,0)
ES2AA-13-F_SMA2
  rect 2.489x1.702 smd: 1(0,0) 2(4,0)
FDC654P-G_SSOT-6
  oval 0.711x0.991 smd: 1(0,0) 2(0.95,0) 3(1.9,0) 4(1.9,2.6) 5(0.95,2.6) 6(0,2.6)
FDS6679AZ-G_SO8
  oval 0.635x1.676 smd: 1(0,0) 2(1.27,0) 3(2.54,0) 4(3.81,0) 5(3.81,5.35) 6(2.54,5.35) 7(1.27,5.35) 8(0,5.35)
FDS6679AZ_SO8
  oval 0.635x1.854 smd: 1(0,0) 2(1.27,0) 3(2.54,0) 4(3.81,0) 5(3.81,5.16) 6(2.54,5.16) 7(1.27,5.16) 8(0,5.16)
FDV301N-G_SOT23-3
  oval 1.016x1.524 smd: 1(0,0) 2(0.965,2.083) 3(-0.965,2.083)
FIDUCIAL_C40M80
  round 1.016 smd: 1(0,0)
G547I2P81U_MSOP8
  oval 0.381x1.549 smd: 1(0,0) 2(0.65,0) 3(1.3,0) 4(1.95,0) 5(1.95,4.37) 6(1.3,4.37) 7(0.65,4.37) 8(0,4.37)
H_2P3
  round 2.819 hole 2.311: 1(0,0)
H_2P5X8P0
  oval 2.997x8.509 hole 2.489x8.001: 1(0,0)
H_2P8
  round 3.302 hole 2.794: 1(0,0)
H_3P5
  round 4.013 hole 3.505: 1(0,0)
H_3P8
  round 4.318 hole 3.81: 1(0,0)
H_4P8
  round 5.309 hole 4.801: 1(0,0)
H_6P2
  round 6.706 hole 6.198: 1(0,0)
IMD2AT-108_SC74-6
  oval 0.508x1.473 smd: 1(0,0) 2(-0.95,0) 3(-1.9,0) 4(-1.9,2.55) 5(-0.95,2.55) 6(0,2.55)
INA199A2DCKR_SC70-6
  oval 0.406x0.889 smd: 1(0,0) 2(0.65,0) 3(1.3,0) 4(1.3,2.2) 5(0.65,2.2) 6(0,2.2)
IP4223CZ6_SO6
  oval 0.508x1.422 smd: 1(0,0) 2(0.95,0) 3(1.9,0) 4(1.9,2.35) 5(0.95,2.35) 6(0,2.35)
IP4292CZ10-TBR_XSON10_2P5X1
  oval 0.254x0.889 smd: 1(0,0)
  oval 0.254x0.838 smd: 2(0.5,-0.025) 3(1,-0.025) 4(1.5,-0.025) 5(2,-0.025) 6(2,1.125) 7(1.5,1.125) 8(1,1.125) 9(0.5,1.125) 10(0,1.125)
ISL6208BCRZ-T_QFN8_2X2
  oval 0.254x0.914 smd: 1(0,0) 2(0.5,0) 3(1,0) 4(1.5,0) 5(1.5,2.075) 6(1,2.075) 7(0.5,2.075) 8(0,2.075)
  rect 1.549x0.889 smd: 9(0.75,1.038)
ISL62883CHRTZ-T_TQFN40_5X5
  oval 0.203x0.991 smd: 1(0,0) 2(0.4,0) 3(0.8,0) 4(1.2,0) 5(1.6,0) 6(2,0) 7(2.4,0) 8(2.8,0) 9(3.2,0) 10(3.6,0) 21(3.6,4.95) 22(3.2,4.95) 23(2.8,4.95) 24(2.4,4.95) 25(2,4.95) 26(1.6,4.95) 27(1.2,4.95) 28(0.8,4.95) 29(0.4,4.95) 30(0,4.95)
  oval 0.991x0.203 smd: 11(4.275,0.675) 12(4.275,1.075) 13(4.275,1.475) 14(4.275,1.875) 15(4.275,2.275) 16(4.275,2.675) 17(4.275,3.075) 18(4.275,3.475) 19(4.275,3.875) 20(4.275,4.275) 31(-0.675,4.275) 32(-0.675,3.875) 33(-0.675,3.475) 34(-0.675,3.075) 35(-0.675,2.675) 36(-0.675,2.275) 37(-0.675,1.875) 38(-0.675,1.475) 39(-0.675,1.075) 40(-0.675,0.675)
  rect 3.505x3.505 smd: 41(1.8,2.475)
ISL95812HRZ-T_QFN32_4X4
  oval 0.203x0.914 smd: 1(0,0) 2(0.4,0) 3(0.8,0) 4(1.2,0) 5(1.6,0) 6(2,0) 7(2.4,0) 8(2.8,0) 17(2.8,4.077) 18(2.4,4.077) 19(2,4.077) 20(1.6,4.077) 21(1.2,4.077) 22(0.8,4.077) 23(0.4,4.077) 24(0,4.077)
  oval 0.914x0.203 smd: 9(3.438,0.639) 10(3.438,1.039) 11(3.438,1.438) 12(3.438,1.838) 13(3.438,2.239) 14(3.438,2.639) 15(3.438,3.039) 16(3.438,3.438) 25(-0.639,3.438) 26(-0.639,3.039) 27(-0.639,2.639) 28(-0.639,2.239) 29(-0.639,1.838) 30(-0.639,1.438) 31(-0.639,1.039) 32(-0.639,0.639)
  rect 2.642x2.642 smd: 33(1.4,2.039)
JAE_WD2F144WB1R300_144P
  oval 1.702x1.092 hole 1.702x1.092 unplated: (3,-4) (34.5,-4)
  oval 0.254x1.803 smd: 1(0,0) 2(0,-8) 3(0.5,0) 4(0.5,-8) 5(1,0) 6(1,-8) 7(1.5,0) 8(1.5,-8) 9(2,0) 10(2,-8) 11(2.5,0) 12(2.5,-8) 13(3,0) 14(3,-8) 15(3.5,0) 16(3.5,-8) 17(4,0) 18(4,-8) 19(4.5,0) 20(4.5,-8) 21(5,0) 22(5,-8) 23(5.5,0) 24(5.5,-8) 25(6,0) 26(6,-8) 27(6.5,0) 28(6.5,-8) 29(7,0) 30(7,-8) 31(7.5,0) 32(7.5,-8) 33(8,0) 34(8,-8) 35(8.5,0) 36(8.5,-8) 37(9,0) 38(9,-8) 39(9.5,0) 40(9.5,-8) 41(10,0) 42(10,-8) 43(10.5,0) 44(10.5,-8) 45(11,0) 46(11,-8) 47(11.5,0) 48(11.5,-8) 49(12,0) 50(12,-8) 51(13.5,0) 52(13.5,-8) 53(14,0) 54(14,-8) 55(14.5,0) 56(14.5,-8) 57(15,0) 58(15,-8) 59(15.5,0) 60(15.5,-8) 61(16,0) 62(16,-8) 63(16.5,0) 64(16.5,-8) 65(17,0) 66(17,-8) 67(17.5,0) 68(17.5,-8) 69(18,0) 70(18,-8) 71(18.5,0) 72(18.5,-8) 73(19,0) 74(19,-8) 75(19.5,0) 76(19.5,-8) 77(20,0) 78(20,-8) 79(20.5,0) 80(20.5,-8) 81(21,0) 82(21,-8) 83(21.5,0) 84(21.5,-8) 85(22,0) 86(22,-8) 87(22.5,0) 88(22.5,-8) 89(23,0) 90(23,-8) 91(23.5,0) 92(23.5,-8) 93(24,0) 94(24,-8) 95(25.5,0) 96(25.5,-8) 97(26,0) 98(26,-8) 99(26.5,0) 100(26.5,-8) 101(27,0) 102(27,-8) 103(27.5,0) 104(27.5,-8) 105(28,0) 106(28,-8) 107(28.5,0) 108(28.5,-8) 109(29,0) 110(29,-8) 111(29.5,0) 112(29.5,-8) 113(30,0) 114(30,-8) 115(30.5,0) 116(30.5,-8) 117(31,0) 118(31,-8) 119(31.5,0) 120(31.5,-8) 121(32,0) 122(32,-8) 123(32.5,0) 124(32.5,-8) 125(33,0) 126(33,-8) 127(33.5,0) 128(33.5,-8) 129(34,0) 130(34,-8) 131(34.5,0) 132(34.5,-8) 133(35,0) 134(35,-8) 135(35.5,0) 136(35.5,-8) 137(36,0) 138(36,-8) 139(36.5,0) 140(36.5,-8) 141(37,0) 142(37,-8) 143(37.5,0) 144(37.5,-8)
  oval 1.753x3.607 hole 0.991x2.845: 145(-5.425,-4) 152(42.925,-4)
  oval 1.905x1.702 hole 1.143x0.94: 146(-1.55,-2.275) 148(-1.55,-5.725) 149(39.05,-2.275) 151(39.05,-5.725)
  oval 1.702x2.667 hole 0.94x1.905: 147(-2.475,-4) 150(39.975,-4)
  oval 3.759x1.6 hole 2.997x0.838: 153(-3.75,-0.075) 156(41.25,-0.075) 161(-3.75,-7.925) 164(41.25,-7.925)
  oval 1.753x1.6 hole 1.245x0.838: 154(12.75,-0.075) 155(24.75,-0.075) 162(12.75,-7.925) 163(24.75,-7.925)
  round 1.753 hole 0.991: 157(0.75,-4) 158(12.75,-4) 159(24.75,-4) 160(36.75,-4)
JESS_UCNR2451M005-0_5P
  rect 0.838x7.01 smd: 1(0,0) 2(1.5,0) 3(3,0) 4(4.5,0) 5(6,0)
JUMP_43X39
  custom 0.191x0.191 smd: 1(0,0) 2(0.914,0)
JUMP_43X79
  custom 0.188x0.188 smd: 1(0,0) 2(1.1,0)
JUMP_43X118
  custom 0.187x0.187 smd: 1(0,0) 2(1.1,0)
K4G20325FC-HC05_FBGA_170P
  round 0.343 smd: A1(0,0) A2(0.8,0) A3(1.6,0) A4(2.4,0) A5(3.2,0) A10(7.201,0) A11(8.001,0) A12(8.801,0) A13(9.601,0) A14(10.401,0) B1(0,-0.8) B2(0.8,-0.8) B3(1.6,-0.8) B4(2.4,-0.8) B5(3.2,-0.8) B10(7.201,-0.8) B11(8.001,-0.8) B12(8.801,-0.8) B13(9.601,-0.8) B14(10.401,-0.8) C1(0,-1.6) C2(0.8,-1.6) C3(1.6,-1.6) C4(2.4,-1.6) C5(3.2,-1.6) C10(7.201,-1.6) C11(8.001,-1.6) C12(8.801,-1.6) C13(9.601,-1.6) C14(10.401,-1.6) D1(0,-2.4) D2(0.8,-2.4) D3(1.6,-2.4) D4(2.4,-2.4) D5(3.2,-2.4) D10(7.201,-2.4) D11(8.001,-2.4) D12(8.801,-2.4) D13(9.601,-2.4) D14(10.401,-2.4) E1(0,-3.2) E2(0.8,-3.2) E3(1.6,-3.2) E4(2.4,-3.2) E5(3.2,-3.2) E10(7.201,-3.2) E11(8.001,-3.2) E12(8.801,-3.2) E13(9.601,-3.2) E14(10.401,-3.2) F1(0,-4) F2(0.8,-4) F3(1.6,-4) F4(2.4,-4) F5(3.2,-4) F10(7.201,-4) F11(8.001,-4) F12(8.801,-4) F13(9.601,-4) F14(10.401,-4) G1(0,-4.801) G2(0.8,-4.801) G3(1.6,-4.801) G4(2.4,-4.801) G5(3.2,-4.801) G10(7.201,-4.801) G11(8.001,-4.801) G12(8.801,-4.801) G13(9.601,-4.801) G14(10.401,-4.801) H1(0,-5.601) H2(0.8,-5.601) H3(1.6,-5.601) H4(2.4,-5.601) H5(3.2,-5.601) H10(7.201,-5.601) H11(8.001,-5.601) H12(8.801,-5.601) H13(9.601,-5.601) H14(10.401,-5.601) J1(0,-6.401) J2(0.8,-6.401) J3(1.6,-6.401) J4(2.4,-6.401) J5(3.2,-6.401) J10(7.201,-6.401) J11(8.001,-6.401) J12(8.801,-6.401) J13(9.601,-6.401) J14(10.401,-6.401) K1(0,-7.201) K2(0.8,-7.201) K3(1.6,-7.201) K4(2.4,-7.201) K5(3.2,-7.201) K10(7.201,-7.201) K11(8.001,-7.201) K12(8.801,-7.201) K13(9.601,-7.201) K14(10.401,-7.201) L1(0,-8.001) L2(0.8,-8.001) L3(1.6,-8.001) L4(2.4,-8.001) L5(3.2,-8.001) L10(7.201,-8.001) L11(8.001,-8.001) L12(8.801,-8.001) L13(9.601,-8.001) L14(10.401,-8.001) M1(0,-8.801) M2(0.8,-8.801) M3(1.6,-8.801) M4(2.4,-8.801) M5(3.2,-8.801) M10(7.201,-8.801) M11(8.001,-8.801) M12(8.801,-8.801) M13(9.601,-8.801) M14(10.401,-8.801) N1(0,-9.601) N2(0.8,-9.601) N3(1.6,-9.601) N4(2.4,-9.601) N5(3.2,-9.601) N10(7.201,-9.601) N11(8.001,-9.601) N12(8.801,-9.601) N13(9.601,-9.601) N14(10.401,-9.601) P1(0,-10.401) P2(0.8,-10.401) P3(1.6,-10.401) P4(2.4,-10.401) P5(3.2,-10.401) P10(7.201,-10.401) P11(8.001,-10.401) P12(8.801,-10.401) P13(9.601,-10.401) P14(10.401,-10.401) R1(0,-11.201) R2(0.8,-11.201) R3(1.6,-11.201) R4(2.4,-11.201) R5(3.2,-11.201) R10(7.201,-11.201) R11(8.001,-11.201) R12(8.801,-11.201) R13(9.601,-11.201) R14(10.401,-11.201) T1(0,-12.002) T2(0.8,-12.002) T3(1.6,-12.002) T4(2.4,-12.002) T5(3.2,-12.002) T10(7.201,-12.002) T11(8.001,-12.002) T12(8.801,-12.002) T13(9.601,-12.002) T14(10.401,-12.002) U1(0,-12.802) U2(0.8,-12.802) U3(1.6,-12.802) U4(2.4,-12.802) U5(3.2,-12.802) U10(7.201,-12.802) U11(8.001,-12.802) U12(8.801,-12.802) U13(9.601,-12.802) U14(10.401,-12.802)
KC_FBMA-L11-453215800LMA90T_2P
  rect 1.803x3.404 smd: 1(0,0) 2(3.8,0)
L2N7002WT1G_SC-70-3
  oval 0.711x0.889 smd: 1(0,0) 2(-0.65,-1.9) 3(0.65,-1.9)
L03ESDL5V0CC3-2_SOT23-3
  oval 1.016x1.524 smd: 1(0,0) 2(0.965,2.083) 3(-0.965,2.083)
L30ESD24VC3-2_SOT23-3
  oval 1.016x1.524 smd: 1(0,0) 2(0.965,2.083) 3(-0.965,2.083)
L30ESDL5V0C3-2_SOT23-3
  oval 1.016x1.524 smd: 1(0,0) 2(0.965,2.083) 3(-0.965,2.083)
LED_LTW-193ZDS5_2P
  rect 0.787x0.787 smd: 1(0,0) 2(1.5,0)
LM358DR2G_SOIC8
  oval 0.635x1.854 smd: 1(0,0) 2(1.27,0) 3(2.54,0) 4(3.81,0) 5(3.81,5.165) 6(2.54,5.165) 7(1.27,5.165) 8(0,5.165)
LNG3DMTR_LGA16_3X3
  oval 0.305x0.864 smd: 1(0,0) 2(0.5,0) 3(1,0) 4(1.5,0) 5(2,0) 9(2,2.958) 10(1.5,2.958) 11(1,2.958) 12(0.5,2.958) 13(0,2.958)
  oval 0.864x0.305 smd: 6(2.479,0.979) 7(2.479,1.479) 8(2.479,1.979) 14(-0.479,1.979) 15(-0.479,1.479) 16(-0.479,0.979)
LOTES_AZIF0012-P002B_947P-T
  round 0.508 smd: A2(0,1) A3(0,2) A33(0,32) A34(0,33) A35(0,34) AP1(33,0) AP35(33,34) AR1(34,0) AR2(34,1) AR34(34,33) AR35(34,34) AT1(35,0) AT2(35,1) AT3(35,2) AT33(35,32) AT34(35,33) AT35(35,34) B1(1,0) B2(1,1) B34(1,33) B35(1,34) C1(2,0) C35(2,34)
  oval 0.61x0.457 smd: A4(0,3) A5(0,4) A6(0,5) A7(0,6) A8(0,7) A9(0,8) A10(0,9) A11(0,10) A12(0,11) A13(0,12) A14(0,13) A15(0,14) A16(0,15) A17(0,16) A18(0,17) A19(0,18) A20(0,19) A21(0,20) A22(0,21) A23(0,22) A24(0,23) A25(0,24) A26(0,25) A27(0,26) A28(0,27) A29(0,28) A30(0,29) A31(0,30) A32(0,31) AT4(35,3) AT5(35,4) AT6(35,5) AT7(35,6) AT8(35,7) AT9(35,8) AT10(35,9) AT11(35,10) AT12(35,11) AT13(35,12) AT14(35,13) AT15(35,14) AT16(35,15) AT17(35,16) AT18(35,17) AT19(35,18) AT20(35,19) AT21(35,20) AT22(35,21) AT23(35,22) AT24(35,23) AT25(35,24) AT26(35,25) AT27(35,26) AT28(35,27) AT29(35,28) AT30(35,29) AT31(35,30) AT32(35,31)
  oval 0.457x0.61 smd: AA1(20,0) AA35(20,34) AB1(21,0) AB35(21,34) AC1(22,0) AC35(22,34) AD1(23,0) AD35(23,34) AE1(24,0) AE35(24,34) AF1(25,0) AF35(25,34) AG1(26,0) AG35(26,34) AH1(27,0) AH35(27,34) AJ1(28,0) AJ35(28,34) AK1(29,0) AK35(29,34) AL1(30,0) AL35(30,34) AM1(31,0) AM35(31,34) AN1(32,0) AN35(32,34) D1(3,0) D35(3,34) E1(4,0) E35(4,34) F1(5,0) F35(5,34) G1(6,0) G35(6,34) H1(7,0) H35(7,34) J1(8,0) J35(8,34) K1(9,0) K35(9,34) L1(10,0) L35(10,34) M1(11,0) M35(11,34) N1(12,0) N35(12,34) P1(13,0) P35(13,34) R1(14,0) R35(14,34) T1(15,0) T35(15,34) U1(16,0) U35(16,34) V1(17,0) V35(17,34) W1(18,0) W35(18,34) Y1(19,0) Y35(19,34)
  round 0.457 smd: AA2(20,1) AA3(20,2) AA4(20,3) AA5(20,4) AA6(20,5) AA7(20,6) AA8(20,7) AA9(20,8) AA10(20,9) AA11(20,10) AA25(20,24) AA26(20,25) AA27(20,26) AA28(20,27) AA29(20,28) AA30(20,29) AA31(20,30) AA32(20,31) AA33(20,32) AA34(20,33) AB2(21,1) AB3(21,2) AB4(21,3) AB5(21,4) AB6(21,5) AB7(21,6) AB8(21,7) AB9(21,8) AB10(21,9) AB11(21,10) AB25(21,24) AB26(21,25) AB27(21,26) AB28(21,27) AB29(21,28) AB30(21,29) AB31(21,30) AB32(21,31) AB33(21,32) AB34(21,33) AC2(22,1) AC3(22,2) AC4(22,3) AC5(22,4) AC6(22,5) AC7(22,6) AC8(22,7) AC9(22,8) AC10(22,9) AC11(22,10) AC25(22,24) AC26(22,25) AC27(22,26) AC28(22,27) AC29(22,28) AC30(22,29) AC31(22,30) AC32(22,31) AC33(22,32) AC34(22,33) AD2(23,1) AD3(23,2) AD4(23,3) AD5(23,4) AD6(23,5) AD7(23,6) AD8(23,7) AD9(23,8) AD10(23,9) AD11(23,10) AD25(23,24) AD26(23,25) AD27(23,26) AD28(23,27) AD29(23,28) AD30(23,29) AD31(23,30) AD32(23,31) AD33(23,32) AD34(23,33) AE2(24,1) AE3(24,2) AE4(24,3) AE5(24,4) AE6(24,5) AE7(24,6) AE8(24,7) AE9(24,8) AE10(24,9) AE11(24,10) AE25(24,24) AE26(24,25) AE27(24,26) AE28(24,27) AE29(24,28) AE30(24,29) AE31(24,30) AE32(24,31) AE33(24,32) AE34(24,33) AF2(25,1) AF3(25,2) AF4(25,3) AF5(25,4) AF6(25,5) AF7(25,6) AF8(25,7) AF9(25,8) AF10(25,9) AF11(25,10) AF25(25,24) AF26(25,25) AF27(25,26) AF28(25,27) AF29(25,28) AF30(25,29) AF31(25,30) AF32(25,31) AF33(25,32) AF34(25,33) AG2(26,1) AG3(26,2) AG4(26,3) AG5(26,4) AG6(26,5) AG7(26,6) AG8(26,7) AG9(26,8) AG10(26,9) AG11(26,10) AG25(26,24) AG26(26,25) AG27(26,26) AG28(26,27) AG29(26,28) AG30(26,29) AG31(26,30) AG32(26,31) AG33(26,32) AG34(26,33) AH2(27,1) AH3(27,2) AH4(27,3) AH5(27,4) AH6(27,5) AH7(27,6) AH8(27,7) AH9(27,8) AH10(27,9) AH11(27,10) AH25(27,24) AH26(27,25) AH27(27,26) AH28(27,27) AH29(27,28) AH30(27,29) AH31(27,30) AH32(27,31) AH33(27,32) AH34(27,33) AJ2(28,1) AJ3(28,2) AJ4(28,3) AJ5(28,4) AJ6(28,5) AJ7(28,6) AJ8(28,7) AJ9(28,8) AJ10(28,9) AJ11(28,10) AJ25(28,24) AJ26(28,25) AJ27(28,26) AJ28(28,27) AJ29(28,28) AJ30(28,29) AJ31(28,30) AJ32(28,31) AJ33(28,32) AJ34(28,33) AK2(29,1) AK3(29,2) AK4(29,3) AK5(29,4) AK6(29,5) AK7(29,6) AK8(29,7) AK9(29,8) AK10(29,9) AK11(29,10) AK25(29,24) AK26(29,25) AK27(29,26) AK28(29,27) AK29(29,28) AK30(29,29) AK31(29,30) AK32(29,31) AK33(29,32) AK34(29,33) AL2(30,1) AL3(30,2) AL4(30,3) AL5(30,4) AL6(30,5) AL7(30,6) AL8(30,7) AL9(30,8) AL10(30,9) AL11(30,10) AL12(30,11) AL13(30,12) AL14(30,13) AL15(30,14) AL16(30,15) AL17(30,16) AL18(30,17) AL19(30,18) AL20(30,19) AL21(30,20) AL22(30,21) AL23(30,22) AL24(30,23) AL25(30,24) AL26(30,25) AL27(30,26) AL28(30,27) AL29(30,28) AL30(30,29) AL31(30,30) AL32(30,31) AL33(30,32) AL34(30,33) AM2(31,1) AM3(31,2) AM4(31,3) AM5(31,4) AM6(31,5) AM7(31,6) AM8(31,7) AM9(31,8) AM10(31,9) AM11(31,10) AM12(31,11) AM13(31,12) AM14(31,13) AM15(31,14) AM16(31,15) AM17(31,16) AM18(31,17) AM19(31,18) AM20(31,19) AM21(31,20) AM22(31,21) AM23(31,22) AM24(31,23) AM25(31,24) AM26(31,25) AM27(31,26) AM28(31,27) AM29(31,28) AM30(31,29) AM31(31,30) AM32(31,31) AM33(31,32) AM34(31,33) AN2(32,1) AN3(32,2) AN4(32,3) AN5(32,4) AN6(32,5) AN7(32,6) AN8(32,7) AN9(32,8) AN10(32,9) AN11(32,10) AN12(32,11) AN13(32,12) AN14(32,13) AN15(32,14) AN16(32,15) AN17(32,16) AN18(32,17) AN19(32,18) AN20(32,19) AN21(32,20) AN22(32,21) AN23(32,22) AN24(32,23) AN25(32,24) AN26(32,25) AN27(32,26) AN28(32,27) AN29(32,28) AN30(32,29) AN31(32,30) AN32(32,31) AN33(32,32) AN34(32,33) AP2(33,1) AP3(33,2) AP4(33,3) AP5(33,4) AP6(33,5) AP7(33,6) AP8(33,7) AP9(33,8) AP10(33,9) AP11(33,10) AP12(33,11) AP13(33,12) AP14(33,13) AP15(33,14) AP16(33,15) AP17(33,16) AP18(33,17) AP19(33,18) AP20(33,19) AP21(33,20) AP22(33,21) AP23(33,22) AP24(33,23) AP25(33,24) AP26(33,25) AP27(33,26) AP28(33,27) AP29(33,28) AP30(33,29) AP31(33,30) AP32(33,31) AP33(33,32) AP34(33,33) AR3(34,2) AR4(34,3) AR5(34,4) AR6(34,5) AR7(34,6) AR8(34,7) AR9(34,8) AR10(34,9) AR11(34,10) AR12(34,11) AR13(34,12) AR14(34,13) AR15(34,14) AR16(34,15) AR17(34,16) AR18(34,17) AR19(34,18) AR20(34,19) AR21(34,20) AR22(34,21) AR23(34,22) AR24(34,23) AR25(34,24) AR26(34,25) AR27(34,26) AR28(34,27) AR29(34,28) AR30(34,29) AR31(34,30) AR32(34,31) AR33(34,32) B3(1,2) B4(1,3) B5(1,4) B6(1,5) B7(1,6) B8(1,7) B9(1,8) B10(1,9) B11(1,10) B12(1,11) B13(1,12) B14(1,13) B15(1,14) B16(1,15) B17(1,16) B18(1,17) B19(1,18) B20(1,19) B21(1,20) B22(1,21) B23(1,22) B24(1,23) B25(1,24) B26(1,25) B27(1,26) B28(1,27) B29(1,28) B30(1,29) B31(1,30) B32(1,31) B33(1,32) C2(2,1) C3(2,2) C4(2,3) C5(2,4) C6(2,5) C7(2,6) C8(2,7) C9(2,8) C10(2,9) C11(2,10) C12(2,11) C13(2,12) C14(2,13) C15(2,14) C16(2,15) C17(2,16) C18(2,17) C19(2,18) C20(2,19) C21(2,20) C22(2,21) C23(2,22) C24(2,23) C25(2,24) C26(2,25) C27(2,26) C28(2,27) C29(2,28) C30(2,29) C31(2,30) C32(2,31) C33(2,32) C34(2,33) D2(3,1) D3(3,2) D4(3,3) D5(3,4) D6(3,5) D7(3,6) D8(3,7) D9(3,8) D10(3,9) D11(3,10) D12(3,11) D13(3,12) D14(3,13) D15(3,14) D16(3,15) D17(3,16) D18(3,17) D19(3,18) D20(3,19) D21(3,20) D22(3,21) D23(3,22) D24(3,23) D25(3,24) D26(3,25) D27(3,26) D28(3,27) D29(3,28) D30(3,29) D31(3,30) D32(3,31) D33(3,32) D34(3,33) E2(4,1) E3(4,2) E4(4,3) E5(4,4) E6(4,5) E7(4,6) E8(4,7) E9(4,8) E10(4,9) E11(4,10) E12(4,11) E13(4,12) E14(4,13) E15(4,14) E16(4,15) E17(4,16) E18(4,17) E19(4,18) E20(4,19) E21(4,20) E22(4,21) E23(4,22) E24(4,23) E25(4,24) E26(4,25) E27(4,26) E28(4,27) E29(4,28) E30(4,29) E31(4,30) E32(4,31) E33(4,32) E34(4,33) F2(5,1) F3(5,2) F4(5,3) F5(5,4) F6(5,5) F7(5,6) F8(5,7) F9(5,8) F10(5,9) F11(5,10) F12(5,11) F13(5,12) F14(5,13) F15(5,14) F16(5,15) F17(5,16) F18(5,17) F19(5,18) F20(5,19) F21(5,20) F22(5,21) F23(5,22) F24(5,23) F25(5,24) F26(5,25) F27(5,26) F28(5,27) F29(5,28) F30(5,29) F31(5,30) F32(5,31) F33(5,32) F34(5,33) G2(6,1) G3(6,2) G4(6,3) G5(6,4) G6(6,5) G7(6,6) G8(6,7) G9(6,8) G10(6,9) G11(6,10) G25(6,24) G26(6,25) G27(6,26) G28(6,27) G29(6,28) G30(6,29) G31(6,30) G32(6,31) G33(6,32) G34(6,33) H2(7,1) H3(7,2) H4(7,3) H5(7,4) H6(7,5) H7(7,6) H8(7,7) H9(7,8) H10(7,9) H11(7,10) H25(7,24) H26(7,25) H27(7,26) H28(7,27) H29(7,28) H30(7,29) H31(7,30) H32(7,31) H33(7,32) H34(7,33) J2(8,1) J3(8,2) J4(8,3) J5(8,4) J6(8,5) J7(8,6) J8(8,7) J9(8,8) J10(8,9) J11(8,10) J25(8,24) J26(8,25) J27(8,26) J28(8,27) J29(8,28) J30(8,29) J31(8,30) J32(8,31) J33(8,32) J34(8,33) K2(9,1) K3(9,2) K4(9,3) K5(9,4) K6(9,5) K7(9,6) K8(9,7) K9(9,8) K10(9,9) K11(9,10) K25(9,24) K26(9,25) K27(9,26) K28(9,27) K29(9,28) K30(9,29) K31(9,30) K32(9,31) K33(9,32) K34(9,33) L2(10,1) L3(10,2) L4(10,3) L5(10,4) L6(10,5) L7(10,6) L8(10,7) L9(10,8) L10(10,9) L11(10,10) L25(10,24) L26(10,25) L27(10,26) L28(10,27) L29(10,28) L30(10,29) L31(10,30) L32(10,31) L33(10,32) L34(10,33) M2(11,1) M3(11,2) M4(11,3) M5(11,4) M6(11,5) M7(11,6) M8(11,7) M9(11,8) M10(11,9) M11(11,10) M25(11,24) M26(11,25) M27(11,26) M28(11,27) M29(11,28) M30(11,29) M31(11,30) M32(11,31) M33(11,32) M34(11,33) N2(12,1) N3(12,2) N4(12,3) N5(12,4) N6(12,5) N7(12,6) N8(12,7) N9(12,8) N10(12,9) N11(12,10) N25(12,24) N26(12,25) N27(12,26) N28(12,27) N29(12,28) N30(12,29) N31(12,30) N32(12,31) N33(12,32) N34(12,33) P2(13,1) P3(13,2) P4(13,3) P5(13,4) P6(13,5) P7(13,6) P8(13,7) P9(13,8) P10(13,9) P11(13,10) P25(13,24) P26(13,25) P27(13,26) P28(13,27) P29(13,28) P30(13,29) P31(13,30) P32(13,31) P33(13,32) P34(13,33) R2(14,1) R3(14,2) R4(14,3) R5(14,4) R6(14,5) R7(14,6) R8(14,7) R9(14,8) R10(14,9) R11(14,10) R25(14,24) R26(14,25) R27(14,26) R28(14,27) R29(14,28) R30(14,29) R31(14,30) R32(14,31) R33(14,32) R34(14,33) T2(15,1) T3(15,2) T4(15,3) T5(15,4) T6(15,5) T7(15,6) T8(15,7) T9(15,8) T10(15,9) T11(15,10) T25(15,24) T26(15,25) T27(15,26) T28(15,27) T29(15,28) T30(15,29) T31(15,30) T32(15,31) T33(15,32) T34(15,33) U2(16,1) U3(16,2) U4(16,3) U5(16,4) U6(16,5) U7(16,6) U8(16,7) U9(16,8) U10(16,9) U11(16,10) U25(16,24) U26(16,25) U27(16,26) U28(16,27) U29(16,28) U30(16,29) U31(16,30) U32(16,31) U33(16,32) U34(16,33) V2(17,1) V3(17,2) V4(17,3) V5(17,4) V6(17,5) V7(17,6) V8(17,7) V9(17,8) V10(17,9) V11(17,10) V25(17,24) V26(17,25) V27(17,26) V28(17,27) V29(17,28) V30(17,29) V31(17,30) V32(17,31) V33(17,32) V34(17,33) W2(18,1) W3(18,2) W4(18,3) W5(18,4) W6(18,5) W7(18,6) W8(18,7) W9(18,8) W10(18,9) W11(18,10) W25(18,24) W26(18,25) W27(18,26) W28(18,27) W29(18,28) W30(18,29) W31(18,30) W32(18,31) W33(18,32) W34(18,33) Y2(19,1) Y3(19,2) Y4(19,3) Y5(19,4) Y6(19,5) Y7(19,6) Y8(19,7) Y9(19,8) Y10(19,9) Y11(19,10) Y25(19,24) Y26(19,25) Y27(19,26) Y28(19,27) Y29(19,28) Y30(19,29) Y31(19,30) Y32(19,31) Y33(19,32) Y34(19,33)
MAGLA_MMD-05CZ-1R0M-M7L_2P
  rect 1.905x2.794 smd: 1(0,0) 2(4.1,0)
MARS-PRO_FCBGA_962P
  round 0.508 smd: A3(0.8,0) A37(26.8,0) A39(27.6,0) AA9(4.8,-15) AA10(5.6,-15) AA11(6.4,-14.4) AA12(7.4,-14.4) AA13(8.4,-14.4) AA15(9.4,-14.4) AA16(10.4,-14.4) AA17(11.4,-14.4) AA18(12.4,-14.4) AA20(13.4,-14.4) AA21(14.4,-14.4) AA22(15.4,-14.4) AA23(16.4,-14.4) AA24(17.4,-14.4) AA26(18.4,-14.4) AA27(19.4,-14.4) AA28(20.4,-14.4) AA29(21.2,-15) AA30(22,-15) AA31(22.8,-15) AB11(6.4,-15.4) AB12(7.4,-15.4) AB13(8.4,-15.4) AB15(9.4,-15.4) AB16(10.4,-15.4) AB17(11.4,-15.4) AB18(12.4,-15.4) AB20(13.4,-15.4) AB21(14.4,-15.4) AB22(15.4,-15.4) AB23(16.4,-15.4) AB24(17.4,-15.4) AB26(18.4,-15.4) AB27(19.4,-15.4) AB28(20.4,-15.4) AC10(5.6,-16.2) AC11(6.4,-16.4) AC12(7.4,-16.4) AC13(8.4,-16.4) AC15(9.4,-16.4) AC16(10.4,-16.4) AC17(11.4,-16.4) AC18(12.4,-16.4) AC20(13.4,-16.4) AC21(14.4,-16.4) AC22(15.4,-16.4) AC23(16.4,-16.4) AC24(17.4,-16.4) AC26(18.4,-16.4) AC27(19.4,-16.4) AC28(20.4,-16.4) AC29(21.2,-16.2) AC30(22,-16.2) AD11(6.4,-17.4) AD12(7.4,-17.4) AD13(8.4,-17.4) AD15(9.4,-17.4) AD16(10.4,-17.4) AD17(11.4,-17.4) AD18(12.4,-17.4) AD20(13.4,-17.4) AD21(14.4,-17.4) AD22(15.4,-17.4) AD23(16.4,-17.4) AD24(17.4,-17.4) AD26(18.4,-17.4) AD27(19.4,-17.4) AD28(20.4,-17.4) AD29(21.2,-17.4) AF12(7.4,-18.4) AF13(8.4,-18.4) AF15(9.4,-18.4) AF16(10.4,-18.4) AF17(11.4,-18.4) AF18(12.4,-18.4) AF20(13.4,-18.4) AF21(14.4,-18.4) AF22(15.4,-18.4) AF23(16.4,-18.4) AF24(17.4,-18.4) AF26(18.4,-18.4) AF27(19.4,-18.4) AF28(20.4,-18.4) AG13(8.4,-19.4) AG15(9.4,-19.4) AG16(10.4,-19.4) AG17(11.4,-19.4) AG18(12.4,-19.4) AG20(13.4,-19.4) AG21(14.4,-19.4) AG22(15.4,-19.4) AG23(16.4,-19.4) AG24(17.4,-19.4) AG26(18.4,-19.4) AG27(19.4,-19.4) AH13(8.4,-20.4) AH15(9.4,-20.4) AH16(10.4,-20.4) AH17(11.4,-20.4) AH18(12.4,-20.4) AH20(13.4,-20.4) AH21(14.4,-20.4) AH22(15.4,-20.4) AH23(16.4,-20.4) AH24(17.4,-20.4) AH26(18.4,-20.4) AH27(19.4,-20.4) AJ13(7.8,-21.2) AJ14(9,-21.2) AJ16(10.2,-21.2) AJ17(11.4,-21.2) AJ19(12.6,-21.2) AJ20(13.8,-21.2) AJ21(15,-21.2) AJ23(16.2,-21.2) AJ24(17.4,-21.2) AJ26(18.6,-21.2) AJ27(19.8,-21.2) AK17(11.4,-22) AK19(12.6,-22) AK20(13.8,-22) AK21(15,-22) AK23(16.2,-22) AL19(12.6,-22.8) AL20(13.8,-22.8) AL21(15,-22.8) AM20(13.8,-23.6) AU1(0,-26.8) AU3(0.8,-26.8) AU37(26.8,-26.8) AU39(27.6,-26.8) AW1(0,-27.6) AW3(0.8,-27.6) AW37(26.8,-27.6) AW39(27.6,-27.6) C1(0,-0.8) C3(0.8,-0.8) C37(26.8,-0.8) C39(27.6,-0.8) H20(13.8,-4) J19(12.6,-4.8) J20(13.8,-4.8) J21(15,-4.8) K17(11.4,-5.6) K19(12.6,-5.6) K20(13.8,-5.6) K21(15,-5.6) K23(16.2,-5.6) L13(8.4,-6.4) L15(9.4,-6.4) L16(10.4,-6.4) L17(11.4,-6.4) L18(12.4,-6.4) L20(13.4,-6.4) L21(14.4,-6.4) L22(15.4,-6.4) L23(16.4,-6.4) L24(17.4,-6.4) L26(18.4,-6.4) L27(19.4,-6.4) M13(8.4,-7.4) M15(9.4,-7.4) M16(10.4,-7.4) M17(11.4,-7.4) M18(12.4,-7.4) M20(13.4,-7.4) M21(14.4,-7.4) M22(15.4,-7.4) M23(16.4,-7.4) M24(17.4,-7.4) M26(18.4,-7.4) M27(19.4,-7.4) N13(8.4,-8.4) N15(9.4,-8.4) N16(10.4,-8.4) N17(11.4,-8.4) N18(12.4,-8.4) N20(13.4,-8.4) N21(14.4,-8.4) N22(15.4,-8.4) N23(16.4,-8.4) N24(17.4,-8.4) N26(18.4,-8.4) N27(19.4,-8.4) R12(7.4,-9.4) R13(8.4,-9.4) R15(9.4,-9.4) R16(10.4,-9.4) R17(11.4,-9.4) R18(12.4,-9.4) R20(13.4,-9.4) R21(14.4,-9.4) R22(15.4,-9.4) R23(16.4,-9.4) R24(17.4,-9.4) R26(18.4,-9.4) R27(19.4,-9.4) R28(20.4,-9.4) T11(6.4,-10.4) T12(7.4,-10.4) T13(8.4,-10.4) T15(9.4,-10.4) T16(10.4,-10.4) T17(11.4,-10.4) T18(12.4,-10.4) T20(13.4,-10.4) T21(14.4,-10.4) T22(15.4,-10.4) T23(16.4,-10.4) T24(17.4,-10.4) T26(18.4,-10.4) T27(19.4,-10.4) T28(20.4,-10.4) T29(21.2,-10.2) U10(5.6,-11.4) U11(6.4,-11.4) U12(7.4,-11.4) U13(8.4,-11.4) U15(9.4,-11.4) U16(10.4,-11.4) U17(11.4,-11.4) U18(12.4,-11.4) U20(13.4,-11.4) U21(14.4,-11.4) U22(15.4,-11.4) U23(16.4,-11.4) U24(17.4,-11.4) U26(18.4,-11.4) U27(19.4,-11.4) U28(20.4,-11.4) U29(21.2,-11.4) U30(22,-11.4) V11(6.4,-12.4) V12(7.4,-12.4) V13(8.4,-12.4) V15(9.4,-12.4) V16(10.4,-12.4) V17(11.4,-12.4) V18(12.4,-12.4) V20(13.4,-12.4) V21(14.4,-12.4) V22(15.4,-12.4) V23(16.4,-12.4) V24(17.4,-12.4) V26(18.4,-12.4) V27(19.4,-12.4) V28(20.4,-12.4) W9(4.8,-12.6) W10(5.6,-12.6) W29(21.2,-12.6) W30(22,-12.6) W31(22.8,-12.6) Y8(4,-13.8) Y9(4.8,-13.8) Y10(5.6,-13.8) Y11(6.4,-13.4) Y12(7.4,-13.4) Y13(8.4,-13.4) Y15(9.4,-13.4) Y16(10.4,-13.4) Y17(11.4,-13.4) Y18(12.4,-13.4) Y20(13.4,-13.4) Y21(14.4,-13.4) Y22(15.4,-13.4) Y23(16.4,-13.4) Y24(17.4,-13.4) Y26(18.4,-13.4) Y27(19.4,-13.4) Y28(20.4,-13.4) Y29(21.2,-13.8) Y30(22,-13.8) Y31(22.8,-13.8) Y32(23.6,-13.8)
  round 0.305 smd: A5(1.7,0) A6(2.6,0) A8(4.2,0) A10(5.8,0) A12(7.4,0) A14(9,0) A16(10.6,0) A18(12.2,0) A20(13.8,0) A22(15.4,0) A24(17,0) A26(18.6,0) A28(20.2,0) A30(21.8,0) A32(23.4,0) A34(25,0) A35(25.9,0) AA2(0.4,-14.6) AA4(1.2,-14.6) AA6(2.4,-14.8) AA34(25.2,-14.8) AA36(26.4,-14.6) AA38(27.2,-14.6) AB1(0,-15.4) AB3(0.8,-15.4) AB5(1.6,-15.4) AB6(2.4,-15.6) AB34(25.2,-15.6) AB35(26,-15.4) AB37(26.8,-15.4) AB39(27.6,-15.4) AC2(0.4,-16.2) AC4(1.2,-16.2) AC6(2.4,-16.4) AC34(25.2,-16.4) AC36(26.4,-16.2) AC38(27.2,-16.2) AD1(0,-17) AD3(0.8,-17) AD5(1.6,-17) AD6(2.4,-17.2) AD34(25.2,-17.2) AD35(26,-17) AD37(26.8,-17) AD39(27.6,-17) AE2(0.4,-17.8) AE4(1.2,-17.8) AE6(2.4,-18) AE34(25.2,-18) AE36(26.4,-17.8) AE38(27.2,-17.8) AF1(0,-18.6) AF3(0.8,-18.6) AF5(1.6,-18.6) AF6(2.4,-18.8) AF34(25.2,-18.8) AF35(26,-18.6) AF37(26.8,-18.6) AF39(27.6,-18.6) AG2(0.4,-19.4) AG4(1.2,-19.4) AG6(2.4,-19.6) AG34(25.2,-19.6) AG36(26.4,-19.4) AG38(27.2,-19.4) AH1(0,-20.2) AH3(0.8,-20.2) AH5(1.6,-20.2) AH6(2.4,-20.4) AH34(25.2,-20.4) AH35(26,-20.2) AH37(26.8,-20.2) AH39(27.6,-20.2) AJ2(0.4,-21) AJ4(1.2,-21) AJ6(2.4,-21.2) AJ34(25.2,-21.2) AJ36(26.4,-21) AJ38(27.2,-21) AK1(0,-21.8) AK3(0.8,-21.8) AK5(1.6,-21.8) AK6(2.4,-22) AK34(25.2,-22) AK35(26,-21.8) AK37(26.8,-21.8) AK39(27.6,-21.8) AL2(0.4,-22.6) AL4(1.2,-22.6) AL6(2.4,-22.8) AL34(25.2,-22.8) AL36(26.4,-22.6) AL38(27.2,-22.6) AM1(0,-23.4) AM3(0.8,-23.4) AM5(1.6,-23.4) AM6(2.4,-23.6) AM34(25.2,-23.6) AM35(26,-23.4) AM37(26.8,-23.4) AM39(27.6,-23.4) AN2(0.4,-24.2) AN4(1.2,-24.2) AN6(2.4,-24.4) AN34(25.2,-24.4) AN36(26.4,-24.2) AN38(27.2,-24.2) AP1(0,-25) AP3(0.8,-25) AP5(1.6,-25) AP6(2.4,-25.2) AP7(3.2,-25.2) AP8(4,-25.2) AP9(4.8,-25.2) AP10(5.6,-25.2) AP11(6.4,-25.2) AP12(7.2,-25.2) AP13(8,-25.2) AP14(8.8,-25.2) AP15(9.6,-25.2) AP16(10.4,-25.2) AP17(11.2,-25.2) AP18(12,-25.2) AP19(12.8,-25.2) AP20(13.8,-25.2) AP21(14.8,-25.2) AP22(15.6,-25.2) AP23(16.4,-25.2) AP24(17.2,-25.2) AP25(18,-25.2) AP26(18.8,-25.2) AP27(19.6,-25.2) AP28(20.4,-25.2) AP29(21.2,-25.2) AP30(22,-25.2) AP31(22.8,-25.2) AP32(23.6,-25.2) AP33(24.4,-25.2) AP34(25.2,-25.2) AP35(26,-25) AP37(26.8,-25) AP39(27.6,-25) AR1(0,-25.9) AR3(0.8,-25.9) AR5(1.7,-25.9) AR6(2.6,-26) AR8(4.2,-26) AR10(5.8,-26) AR12(7.4,-26) AR14(9,-26) AR16(10.6,-26) AR18(12.2,-26) AR20(13.8,-26) AR22(15.4,-26) AR24(17,-26) AR26(18.6,-26) AR28(20.2,-26) AR30(21.8,-26) AR32(23.4,-26) AR34(25,-26) AR35(25.9,-25.9) AR37(26.8,-25.9) AR39(27.6,-25.9) AT7(3.4,-26.4) AT9(5,-26.4) AT11(6.6,-26.4) AT13(8.2,-26.4) AT15(9.8,-26.4) AT17(11.4,-26.4) AT19(13,-26.4) AT21(14.6,-26.4) AT23(16.2,-26.4) AT25(17.8,-26.4) AT27(19.4,-26.4) AT29(21,-26.4) AT31(22.6,-26.4) AT33(24.2,-26.4) AU5(1.7,-26.8) AU6(2.6,-26.8) AU8(4.2,-26.8) AU10(5.8,-26.8) AU12(7.4,-26.8) AU14(9,-26.8) AU16(10.6,-26.8) AU18(12.2,-26.8) AU20(13.8,-26.8) AU22(15.4,-26.8) AU24(17,-26.8) AU26(18.6,-26.8) AU28(20.2,-26.8) AU30(21.8,-26.8) AU32(23.4,-26.8) AU34(25,-26.8) AU35(25.9,-26.8) AV7(3.4,-27.2) AV9(5,-27.2) AV11(6.6,-27.2) AV13(8.2,-27.2) AV15(9.8,-27.2) AV17(11.4,-27.2) AV19(13,-27.2) AV21(14.6,-27.2) AV23(16.2,-27.2) AV25(17.8,-27.2) AV27(19.4,-27.2) AV29(21,-27.2) AV31(22.6,-27.2) AV33(24.2,-27.2) AW5(1.7,-27.6) AW6(2.6,-27.6) AW8(4.2,-27.6) AW10(5.8,-27.6) AW12(7.4,-27.6) AW14(9,-27.6) AW16(10.6,-27.6) AW18(12.2,-27.6) AW20(13.8,-27.6) AW22(15.4,-27.6) AW24(17,-27.6) AW26(18.6,-27.6) AW28(20.2,-27.6) AW30(21.8,-27.6) AW32(23.4,-27.6) AW34(25,-27.6) AW35(25.9,-27.6) B7(3.4,-0.4) B9(5,-0.4) B11(6.6,-0.4) B13(8.2,-0.4) B15(9.8,-0.4) B17(11.4,-0.4) B19(13,-0.4) B21(14.6,-0.4) B23(16.2,-0.4) B25(17.8,-0.4) B27(19.4,-0.4) B29(21,-0.4) B31(22.6,-0.4) B33(24.2,-0.4) C5(1.7,-0.8) C6(2.6,-0.8) C8(4.2,-0.8) C10(5.8,-0.8) C12(7.4,-0.8) C14(9,-0.8) C16(10.6,-0.8) C18(12.2,-0.8) C20(13.8,-0.8) C22(15.4,-0.8) C24(17,-0.8) C26(18.6,-0.8) C28(20.2,-0.8) C30(21.8,-0.8) C32(23.4,-0.8) C34(25,-0.8) C35(25.9,-0.8) D7(3.4,-1.2) D9(5,-1.2) D11(6.6,-1.2) D13(8.2,-1.2) D15(9.8,-1.2) D17(11.4,-1.2) D19(13,-1.2) D21(14.6,-1.2) D23(16.2,-1.2) D25(17.8,-1.2) D27(19.4,-1.2) D29(21,-1.2) D31(22.6,-1.2) D33(24.2,-1.2) E1(0,-1.7) E3(0.8,-1.7) E5(1.7,-1.7) E6(2.6,-1.6) E8(4.2,-1.6) E10(5.8,-1.6) E12(7.4,-1.6) E14(9,-1.6) E16(10.6,-1.6) E18(12.2,-1.6) E20(13.8,-1.6) E22(15.4,-1.6) E24(17,-1.6) E26(18.6,-1.6) E28(20.2,-1.6) E30(21.8,-1.6) E32(23.4,-1.6) E34(25,-1.6) E35(25.9,-1.7) E37(26.8,-1.7) E39(27.6,-1.7) F1(0,-2.6) F3(0.8,-2.6) F5(1.6,-2.6) F6(2.4,-2.4) F7(3.2,-2.4) F8(4,-2.4) F9(4.8,-2.4) F10(5.6,-2.4) F11(6.4,-2.4) F12(7.2,-2.4) F13(8,-2.4) F14(8.8,-2.4) F15(9.6,-2.4) F16(10.4,-2.4) F17(11.2,-2.4) F18(12,-2.4) F19(12.8,-2.4) F20(13.8,-2.4) F21(14.8,-2.4) F22(15.6,-2.4) F23(16.4,-2.4) F24(17.2,-2.4) F25(18,-2.4) F26(18.8,-2.4) F27(19.6,-2.4) F28(20.4,-2.4) F29(21.2,-2.4) F30(22,-2.4) F31(22.8,-2.4) F32(23.6,-2.4) F33(24.4,-2.4) F34(25.2,-2.4) F35(26,-2.6) F37(26.8,-2.6) F39(27.6,-2.6) G2(0.4,-3.4) G4(1.2,-3.4) G6(2.4,-3.2) G34(25.2,-3.2) G36(26.4,-3.4) G38(27.2,-3.4) H1(0,-4.2) H3(0.8,-4.2) H5(1.6,-4.2) H6(2.4,-4) H34(25.2,-4) H35(26,-4.2) H37(26.8,-4.2) H39(27.6,-4.2) J2(0.4,-5) J4(1.2,-5) J6(2.4,-4.8) J34(25.2,-4.8) J36(26.4,-5) J38(27.2,-5) K1(0,-5.8) K3(0.8,-5.8) K5(1.6,-5.8) K6(2.4,-5.6) K34(25.2,-5.6) K35(26,-5.8) K37(26.8,-5.8) K39(27.6,-5.8) L2(0.4,-6.6) L4(1.2,-6.6) L6(2.4,-6.4) L34(25.2,-6.4) L36(26.4,-6.6) L38(27.2,-6.6) M1(0,-7.4) M3(0.8,-7.4) M5(1.6,-7.4) M6(2.4,-7.2) M34(25.2,-7.2) M35(26,-7.4) M37(26.8,-7.4) M39(27.6,-7.4) N2(0.4,-8.2) N4(1.2,-8.2) N6(2.4,-8) N34(25.2,-8) N36(26.4,-8.2) N38(27.2,-8.2) P1(0,-9) P3(0.8,-9) P5(1.6,-9) P6(2.4,-8.8) P34(25.2,-8.8) P35(26,-9) P37(26.8,-9) P39(27.6,-9) R2(0.4,-9.8) R4(1.2,-9.8) R6(2.4,-9.6) R34(25.2,-9.6) R36(26.4,-9.8) R38(27.2,-9.8) T1(0,-10.6) T3(0.8,-10.6) T5(1.6,-10.6) T6(2.4,-10.4) T34(25.2,-10.4) T35(26,-10.6) T37(26.8,-10.6) T39(27.6,-10.6) U2(0.4,-11.4) U4(1.2,-11.4) U6(2.4,-11.2) U34(25.2,-11.2) U36(26.4,-11.4) U38(27.2,-11.4) V1(0,-12.2) V3(0.8,-12.2) V5(1.6,-12.2) V6(2.4,-12) V34(25.2,-12) V35(26,-12.2) V37(26.8,-12.2) V39(27.6,-12.2) W2(0.4,-13) W4(1.2,-13) W6(2.4,-12.8) W34(25.2,-12.8) W36(26.4,-13) W38(27.2,-13) Y1(0,-13.8) Y3(0.8,-13.8) Y5(1.6,-13.8) Y6(2.4,-13.8) Y34(25.2,-13.8) Y35(26,-13.8) Y37(26.8,-13.8) Y39(27.6,-13.8)
  round 0.406 smd: AA7(3.2,-15) AA8(4,-15) AA32(23.6,-15) AA33(24.4,-15) AC7(3.2,-16.2) AC8(4,-16.2) AC9(4.8,-16.2) AC31(22.8,-16.2) AC32(23.6,-16.2) AC33(24.4,-16.2) AD7(3.2,-17.4) AD8(4,-17.4) AD9(4.8,-17.4) AD10(5.6,-17.4) AD30(22,-17.4) AD31(22.8,-17.4) AD32(23.6,-17.4) AD33(24.4,-17.4) AF7(3.2,-18.6) AF8(4,-18.6) AF9(4.8,-18.6) AF10(5.6,-18.6) AF11(6.4,-18.4) AF29(21.2,-18.6) AF30(22,-18.6) AF31(22.8,-18.6) AF32(23.6,-18.6) AF33(24.4,-18.6) AG7(3.2,-19.8) AG8(4,-19.8) AG9(4.8,-19.8) AG10(5.6,-19.8) AG11(6.4,-19.4) AG12(7.4,-19.4) AG28(20.4,-19.4) AG29(21.2,-19.8) AG30(22,-19.8) AG31(22.8,-19.8) AG32(23.6,-19.8) AG33(24.4,-19.8) AH11(6.4,-20.4) AH12(7.4,-20.4) AH28(20.4,-20.4) AH29(21.2,-20.6) AJ7(3.2,-21) AJ8(4,-21) AJ9(4.8,-21) AJ10(5.6,-21) AJ11(6.6,-21.2) AJ28(20.6,-21.2) AJ30(22,-21) AJ31(22.8,-21) AJ32(23.6,-21) AJ33(24.4,-21) AK7(3.2,-22) AK8(4,-22) AK9(4.8,-22) AK10(5.6,-22) AK11(6.6,-22) AK13(7.8,-22) AK14(9,-22) AK16(10.2,-22) AK24(17.4,-22) AK26(18.6,-22) AK27(19.8,-22) AK29(21,-22) AK30(22,-22) AK31(22.8,-22) AK32(23.6,-22) AK33(24.4,-22) AL7(3.2,-22.8) AL8(4,-22.8) AL9(4.8,-22.8) AL10(5.6,-22.8) AL11(6.6,-22.8) AL13(7.8,-22.8) AL14(9,-22.8) AL16(10.2,-22.8) AL17(11.4,-22.8) AL23(16.2,-22.8) AL24(17.4,-22.8) AL26(18.6,-22.8) AL27(19.8,-22.8) AL29(21,-22.8) AL30(22,-22.8) AL31(22.8,-22.8) AL32(23.6,-22.8) AL33(24.4,-22.8) AM7(3.2,-23.6) AM8(4,-23.6) AM9(4.8,-23.6) AM10(5.6,-23.6) AM11(6.6,-23.6) AM13(7.8,-23.6) AM14(9,-23.6) AM16(10.2,-23.6) AM17(11.4,-23.6) AM19(12.6,-23.6) AM21(15,-23.6) AM23(16.2,-23.6) AM24(17.4,-23.6) AM26(18.6,-23.6) AM27(19.8,-23.6) AM29(21,-23.6) AM30(22,-23.6) AM31(22.8,-23.6) AM32(23.6,-23.6) AM33(24.4,-23.6) AN7(3.2,-24.4) AN8(4,-24.4) AN9(4.8,-24.4) AN10(5.6,-24.4) AN11(6.6,-24.4) AN13(7.8,-24.4) AN14(9,-24.4) AN16(10.2,-24.4) AN17(11.4,-24.4) AN19(12.6,-24.4) AN20(13.8,-24.4) AN21(15,-24.4) AN23(16.2,-24.4) AN24(17.4,-24.4) AN26(18.6,-24.4) AN27(19.8,-24.4) AN29(21,-24.4) AN30(22,-24.4) AN31(22.8,-24.4) AN32(23.6,-24.4) AN33(24.4,-24.4) G7(3.2,-3.2) G8(4,-3.2) G9(4.8,-3.2) G10(5.6,-3.2) G11(6.6,-3.2) G13(7.8,-3.2) G14(9,-3.2) G16(10.2,-3.2) G17(11.4,-3.2) G19(12.6,-3.2) G20(13.8,-3.2) G21(15,-3.2) G23(16.2,-3.2) G24(17.4,-3.2) G26(18.6,-3.2) G27(19.8,-3.2) G29(21,-3.2) G30(22,-3.2) G31(22.8,-3.2) G32(23.6,-3.2) G33(24.4,-3.2) H7(3.2,-4) H8(4,-4) H9(4.8,-4) H10(5.6,-4) H11(6.6,-4) H13(7.8,-4) H14(9,-4) H16(10.2,-4) H17(11.4,-4) H19(12.6,-4) H21(15,-4) H23(16.2,-4) H24(17.4,-4) H26(18.6,-4) H27(19.8,-4) H29(21,-4) H30(22,-4) H31(22.8,-4) H32(23.6,-4) H33(24.4,-4) J7(3.2,-4.8) J8(4,-4.8) J9(4.8,-4.8) J10(5.6,-4.8) J11(6.6,-4.8) J13(7.8,-4.8) J14(9,-4.8) J16(10.2,-4.8) J17(11.4,-4.8) J23(16.2,-4.8) J24(17.4,-4.8) J26(18.6,-4.8) J27(19.8,-4.8) J29(21,-4.8) J30(22,-4.8) J31(22.8,-4.8) J32(23.6,-4.8) J33(24.4,-4.8) K7(3.2,-5.6) K8(4,-5.6) K9(4.8,-5.6) K10(5.6,-5.6) K11(6.6,-5.6) K13(7.8,-5.6) K14(9,-5.6) K16(10.2,-5.6) K24(17.4,-5.6) K26(18.6,-5.6) K27(19.8,-5.6) K29(21,-5.6) K30(22,-5.6) K31(22.8,-5.6) K32(23.6,-5.6) K33(24.4,-5.6) L7(3.2,-6.6) L8(4,-6.6) L9(4.8,-6.6) L10(5.6,-6.6) L11(6.4,-6.4) L12(7.4,-6.4) L28(20.4,-6.4) L29(21.2,-6.6) L30(22,-6.6) L31(22.8,-6.6) L32(23.6,-6.6) L33(24.4,-6.6) M11(6.4,-7.4) M12(7.4,-7.4) M28(20.4,-7.4) N7(3.2,-7.8) N8(4,-7.8) N9(4.8,-7.8) N10(5.6,-7.8) N11(6.4,-8.4) N12(7.4,-8.4) N28(20.4,-8.4) N29(21.2,-7.8) N30(22,-7.8) N31(22.8,-7.8) N32(23.6,-7.8) N33(24.4,-7.8) P7(3.2,-9) P8(4,-9) P9(4.8,-9) P10(5.6,-9) P29(21.2,-9) P30(22,-9) P31(22.8,-9) P32(23.6,-9) P33(24.4,-9) R11(6.4,-9.4) T7(3.2,-10.2) T8(4,-10.2) T9(4.8,-10.2) T10(5.6,-10.2) T30(22,-10.2) T31(22.8,-10.2) T32(23.6,-10.2) T33(24.4,-10.2) U7(3.2,-11.4) U8(4,-11.4) U9(4.8,-11.4) U31(22.8,-11.4) U32(23.6,-11.4) U33(24.4,-11.4) W7(3.2,-12.6) W8(4,-12.6) W32(23.6,-12.6) W33(24.4,-12.6) Y7(3.2,-13.8) Y33(24.4,-13.8)
MEC5075-LZY_DQFN132_11X11
  oval 0.279x0.711 smd: A1(0,0) A2(0.5,0) A3(1,0) A4(1.5,0) A5(2,0) A6(2.5,0) A7(3,0) A8(3.5,0) A9(4,0) A10(4.5,0) A11(5,0) A12(5.5,0) A13(6,0) A14(6.5,0) A15(7,0) A16(7.5,0) A33(7.5,10.9) A34(7,10.9) A35(6.5,10.9) A36(6,10.9) A37(5.5,10.9) A38(5,10.9) A39(4.5,10.9) A40(4,10.9) A41(3.5,10.9) A42(3,10.9) A43(2.5,10.9) A44(2,10.9) A45(1.5,10.9) A46(1,10.9) A47(0.5,10.9) A48(0,10.9)
  oval 0.711x0.279 smd: A17(9.2,1.7) A18(9.2,2.2) A19(9.2,2.7) A20(9.2,3.2) A21(9.2,3.7) A22(9.2,4.2) A23(9.2,4.7) A24(9.2,5.2) A25(9.2,5.7) A26(9.2,6.2) A27(9.2,6.7) A28(9.2,7.2) A29(9.2,7.7) A30(9.2,8.2) A31(9.2,8.7) A32(9.2,9.2) A49(-1.7,9.2) A50(-1.7,8.7) A51(-1.7,8.2) A52(-1.7,7.7) A53(-1.7,7.2) A54(-1.7,6.7) A55(-1.7,6.2) A56(-1.7,5.7) A57(-1.7,5.2) A58(-1.7,4.7) A59(-1.7,4.2) A60(-1.7,3.7) A61(-1.7,3.2) A62(-1.7,2.7) A63(-1.7,2.2) A64(-1.7,1.7)
  oval 0.305x0.61 smd: B1(-0.25,0.85) B2(0.25,0.85) B3(0.75,0.85) B4(1.25,0.85) B5(1.75,0.85) B6(2.25,0.85) B7(2.75,0.85) B8(3.25,0.85) B9(3.75,0.85) B10(4.25,0.85) B11(4.75,0.85) B12(5.25,0.85) B13(5.75,0.85) B14(6.25,0.85) B15(6.75,0.85) B16(7.25,0.85) B17(7.75,0.85) B35(7.75,10.05) B36(7.25,10.05) B37(6.75,10.05) B38(6.25,10.05) B39(5.75,10.05) B40(5.25,10.05) B41(4.75,10.05) B42(4.25,10.05) B43(3.75,10.05) B44(3.25,10.05) B45(2.75,10.05) B46(2.25,10.05) B47(1.75,10.05) B48(1.25,10.05) B49(0.75,10.05) B50(0.25,10.05) B51(-0.25,10.05)
  oval 0.61x0.305 smd: B18(8.35,1.45) B19(8.35,1.95) B20(8.35,2.45) B21(8.35,2.95) B22(8.35,3.45) B23(8.35,3.95) B24(8.35,4.45) B25(8.35,4.95) B26(8.35,5.45) B27(8.35,5.95) B28(8.35,6.45) B29(8.35,6.95) B30(8.35,7.45) B31(8.35,7.95) B32(8.35,8.45) B33(8.35,8.95) B34(8.35,9.45) B52(-0.85,9.45) B53(-0.85,8.95) B54(-0.85,8.45) B55(-0.85,7.95) B56(-0.85,7.45) B57(-0.85,6.95) B58(-0.85,6.45) B59(-0.85,5.95) B60(-0.85,5.45) B61(-0.85,4.95) B62(-0.85,4.45) B63(-0.85,3.95) B64(-0.85,3.45) B65(-0.85,2.95) B66(-0.85,2.45) B67(-0.85,1.95) B68(-0.85,1.45)
  rect 5.004x5.004 smd: C1(3.75,5.45)
