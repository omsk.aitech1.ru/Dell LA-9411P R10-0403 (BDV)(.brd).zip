# Allegro board LA-9411P R10-0403.brd (continued)
## Copper pours and planes (outline as drawn) (continued)
-DCIN_JACK on TOP (solid shape): 143.2,177.74 143.2,173.91 143.79,173.32 143.79,172.36 143.66,172.23 142.98,172.23 142.98,171.68 142.53,171.68 142.53,172.22 141.78,172.22 141.78,171.67 141.34,171.67 141.34,172.23 140.03,172.23 139.82,172.45 139.82,177.78 140.01,177.98 142.96,177.98
-DCIN_JACK on BOTTOM (solid shape): 142.98,177.94 142.98,176.29 142.48,175.78 142.48,166.76 142.35,166.64 140.06,166.64 139.81,166.89 139.81,177.81 140.06,178.07 142.86,178.07
BOOT1 on BOTTOM (solid shape): 124.44,156.35 124.45,156.35 124.52,156.29 125.45,156.29 125.45,156.29 125.52,156.22 125.52,155.02 125.46,154.95 124.82,154.95 124.76,155.02 124.76,155.65 124.38,156.03 123.17,156.03 122.86,155.71 121.95,155.71 121.92,155.73 121.9,155.77 121.9,155.85 121.92,155.89 121.95,155.9 122.66,155.9 123.17,156.41 124.38,156.41
BOOT1_1_VGA on BOTTOM (solid shape): 304.27,160.1 304.27,157.87 304.21,157.81 303.45,157.81 303.39,157.87 303.39,158.56 303.39,160.16 303.45,160.22 304.15,160.22
BOOT1_VGA on BOTTOM (solid shape): 308.97,159.58 308.97,159.4 308.77,159.2 308.77,159.2 308.27,158.7 306.81,158.7 305.99,157.87 304.78,157.87 304.72,157.94 304.72,158.89 304.85,159.02 306.23,159.02 306.37,159.02 306.62,159.27 308.02,159.27 308.72,159.97 308.72,160.92 308.97,160.92
BOOT2 on BOTTOM (solid shape): 121.01,153.11 121.01,151.53 121.01,151.46 121.71,150.76 122.54,150.76 122.66,150.63 122.66,149.75 122.6,149.68 121.52,149.68 121.33,149.87 121.33,150.44 120.76,151.02 120.76,153.12 120.77,153.16 120.81,153.17 120.95,153.17
BOOT2_2_VGA on BOTTOM (solid shape): 303.67,165.59 303.67,163.37 303.61,163.3 302.91,163.3 302.85,163.37 302.85,165.59 302.91,165.65 303.61,165.65
BOOT2_VGA on BOTTOM (solid shape): 307.58,165.62 307.58,165.11 307.83,164.86 308.21,164.86 308.21,164.67 307.26,164.67 307.2,164.73 307.2,165.3 307.01,165.49 305.23,165.49 305.04,165.3 305.04,164.67 304.91,164.54 304.27,164.54 304.21,164.6 304.21,165.94 304.47,166.19 307.01,166.19
BOOT3 on TOP (solid shape): 164.24,155.36 164.24,154.65 164.09,154.5 162,154.5 161.57,154.06 160.54,154.06 160.46,154.14 160.46,154.29 160.49,154.32 161.36,154.32 161.6,154.56 161.6,154.57 162.13,155.1 162.13,155.19 162.46,155.52 164.08,155.52
BOOT_1.35V on TOP (solid shape): 207.03,14.2 207.03,14.19 207.1,14.09 207.2,14.02 207.21,14.02 207.25,13.98 209.27,13.98 209.32,13.93 209.32,13.78 209.27,13.73 208.05,13.73 208.01,13.77 207.45,13.77 207.27,13.59 207.27,13.45 207.17,13.35 206.23,13.35 206.17,13.41 206.17,14.3 206.23,14.36 206.87,14.36
BQ24715_REGN on TOP (solid shape): 80.67,182.86 81.31,182.86 82.18,181.99 82.18,181.01 83.45,179.74 83.45,178.99 83.28,178.83 81.52,178.83 81.35,178.99 81.35,179.72 81.89,180.07 81.35,180.42 81.35,181.74 81.12,181.97 80.39,181.97 80.22,182.13 80.22,182.6 79.29,183.53 78.82,183.53 78.79,183.57 78.79,183.77 78.82,183.81 79.73,183.81
BST_3V on BOTTOM (solid shape): 147.43,8.65 147.43,7.95 148.45,6.93 148.76,6.93 148.83,6.87 149.59,6.87 149.63,6.83 149.63,6.71 149.6,6.68 148.5,6.68 148.5,6.68 148,6.68 146.99,7.7 146.99,7.94 146.99,8.01 146.86,8.14 146.78,8.14 145.97,8.14 145.91,8.2 145.91,9.22 146.03,9.35 146.73,9.35
BST_5V on BOTTOM (solid shape): 154.2,8.01 154.2,7.21 154.05,7.07 153.46,7.07 153.07,6.68 151.87,6.68 151.84,6.72 151.84,6.85 151.86,6.87 152.9,6.87 153.44,7.4 153.44,7.4 153.44,8.05 153.5,8.1 154.11,8.1
BST_+1.05VSP on TOP (solid shape): 238.04,12.52 238.04,11.78 237.98,11.57 238.04,11.36 238.04,11.15 237.98,10.94 238.04,10.73 238.04,10.72 238.04,10.68 238.23,10.49 238.23,9.79 237.98,9.79 237.98,10.24 236.96,11.25 236.96,12.52 237.09,12.65 237.92,12.65
CD3301_DCIN on TOP (solid shape): 149.86,165.11 149.89,165.1 149.91,165.06 149.91,163.53 149.9,163.51 149.89,163.49 149.85,163.44 149.82,163.37 149.72,163.27 149.72,161.62 149.59,161.49 148.52,161.49 148.42,161.51 148.32,161.49 146.86,161.49 146.73,161.62 146.73,162.57 146.92,162.76 148.32,162.76 149.18,163.63 149.2,163.63 149.37,163.73 149.46,163.89 149.46,163.91 149.65,164.1 149.65,165.06 149.67,165.1 149.7,165.11
CHAGER_SRC on TOP (solid shape): outline of 316 points within 83.93,179.72 97.52,189.75
CHAGER_SRC on BOTTOM (solid shape): outline of 100 points within 79.1,180.5 98.15,189.88
CHG_LGATE on TOP (solid shape): 79.8,182.32 79.8,181.81 79.68,181.69 79.23,181.69 78.44,182.47 78.44,183.43 78.49,183.48 78.65,183.48
CHG_LGATE on BOTTOM (solid shape): 88.76,175.91 88.76,174.76 88.63,174.64 87.41,174.64 87.3,174.75 87.3,175.96 87.37,176.03 88.63,176.03
CHG_LGATE on BOTTOM (solid shape): 94.34,175.89 94.34,174.64 94.22,174.51 92.96,174.51 92.85,174.62 92.85,175.89 92.92,175.97 94.27,175.97
CHG_LGATE on IN4 (solid shape): 93.45,175.78 93.45,174.89 93.33,174.76 91.85,174.76 91.75,174.87 91.75,175.88 91.92,176.05 93.19,176.05
CHG_LGATE on IN4 (solid shape): 88.88,176.54 88.88,175.92 88.87,175.91 88.87,174.7 88.68,174.51 87.36,174.51 86.98,174.89 86.98,176.54 87.1,176.67 88.76,176.67
CHG_LGATE on IN4 (solid shape): 79.79,182.78 79.79,182.75 80.15,182.4 80.69,182.4 81.02,182.07 81.02,181.84 80.41,181.23 79.88,181.23 79.39,181.72 79.19,181.72 78.91,181.99 78.91,182.79 79.02,182.89 79.68,182.89
CHG_PHASE on TOP (solid shape): 81.64,185.43 81.64,185.05 81.83,184.86 82.72,184.86 82.85,184.73 82.85,183.59 82.79,183.53 82.09,183.53 81.9,183.72 81.9,183.91 81.03,184.77 80.81,184.77 80.53,185.05 78.85,185.05 78.85,185.31 79.87,185.31 80.12,185.56 81.52,185.56
CHG_PHASE on BOTTOM (solid shape): outline of 83 points within 87.95,171.68 108.19,185.9
CHG_PHASE on IN4 (solid shape): 91.68,184.39 91.68,183.49 91.17,182.98 89.26,182.98 89.1,183.15 89.1,184.47 89.2,184.57 91.5,184.57
CHG_PHASE on IN4 (solid shape): 82.96,185.57 82.96,184.94 82.9,184.87 80.69,184.87 80.37,185.19 80.37,185.69 80.42,185.74 81.49,185.74 81.68,185.93 82.61,185.93
CHG_UGATE on TOP (solid shape): 80.51,184.73 80.63,184.61 81,184.61 81.52,184.1 81.52,183.91 81.33,183.72 81.01,183.72 80.53,184.2 80.36,184.2 80.02,184.54 78.96,184.54 78.93,184.56 78.91,184.59 78.91,184.75 78.93,184.78 78.96,184.8 80.45,184.8
CHG_UGATE on BOTTOM (solid shape): 88.08,183.54 88.08,181.64 88.01,181.56 87.02,181.56 86.66,181.91 86.66,183.1 87.23,183.67 87.96,183.67
CHG_UGATE on BOTTOM (solid shape): 94.34,183.53 94.34,181.95 94.51,181.79 94.51,181.51 94.38,181.38 93.1,181.38 92.95,181.53 92.95,183.53 93.07,183.65 94.22,183.65
CHG_UGATE on IN4 (solid shape): 94.69,182.28 94.69,181.33 94.34,180.99 92.31,180.99 92.06,181.24 91.99,181.24 91.99,182.4 92.08,182.49 94.48,182.49
CHG_UGATE on IN4 (solid shape): 88.26,182.45 89.42,182.45 89.62,182.24 89.62,181.2 89.57,181.15 87.32,181.15 85.67,182.8 85.67,183.64 85.84,183.81 86.89,183.81
CHG_UGATE on IN4 (solid shape): 80.65,184.63 81.86,184.63 81.98,184.51 82.03,184.47 82.09,184.42 82.18,184.34 82.18,183.88 81.95,183.65 80.5,183.65 80.09,184.06 80.09,184.62 80.2,184.72 80.56,184.72
CPU_B+ on TOP (solid shape): 156.02,156.32 156.02,153.05 155.94,152.82 156.02,152.59 156.02,152.43 156.85,151.59 161.3,151.59 161.35,151.55 163.26,151.55 163.27,151.57 165.08,149.76 165.08,139.46 164.07,138.44 136.63,138.44 136.25,138.82 136.25,142.63 135.87,143.01 134.35,143.01 133.84,142.51 133.84,138.95 133.33,138.44 123.05,138.44 122.66,138.06 120.76,138.06 120.51,138.32 120.51,145.05 121.14,145.68 129.09,145.68 129.09,145.68 132.5,145.68 132.5,145.68 139.3,145.68 139.56,145.93 140.5,145.93 152.51,145.94 152.64,146.06 153.91,146.06 154.16,145.81 155.05,145.81 155.3,146.06 159.34,146.06 160.3,147.01 160.3,148.39 159.02,149.66 154.38,149.66 154.12,149.92 154.12,150.66 153.73,151.05 153.73,151.13 153.65,151.13 153.64,151.14 150.77,151.14 150.52,151.39 150.52,152.78 150.33,152.97 150.31,152.97 150.3,152.98 143.63,152.98 143.59,153.01 143.15,153.01 143,153.16 143,156.13 143.14,156.28 143.76,156.28 143.76,155.7 144.51,155.7 144.51,156.28 144.95,156.28 144.95,155.71 145.72,155.71 145.72,156.23 145.74,156.26 146.59,156.26 147.32,156.98 155.35,156.98
CPU_B+ on BOTTOM (solid shape): 156.95,157.24 156.95,154.32 156.19,153.56 140.32,153.56 139.81,154.06 139.81,156.73 140.83,157.75 156.45,157.75
CPU_B+ on IN3 (solid shape): outline of 167 points within 120,137.81 163.43,156.86
CPU_B+ on IN4 (solid shape): outline of 87 points within 143.45,137.22 164.3,158.17
DH_1.35V on TOP (solid shape): 208.45,14.36 209.29,14.36 209.32,14.34 209.32,14.15 209.28,14.11 207.3,14.11 207.12,14.29 207.12,14.55 207.18,14.62 208.2,14.62
DH_1.35V on TOP (solid shape): 201.28,8.14 201.28,5.73 201.15,5.6 199.88,5.6 199.75,5.73 199.75,7 200.39,7.63 200.39,7.71 200.39,8.14 200.64,8.39 201.02,8.39
DH_1.35V on IN1 (solid shape): 201.79,8.52 201.79,7.12 201.66,7 200.64,7 200.52,7.12 200.52,8.39 200.9,8.78 201.53,8.78
DH_1.35V on IN1 (solid shape): 208.39,14.49 208.39,13.98 208.26,13.86 207.5,13.86 206.36,12.71 206.1,12.71 205.72,13.09 205.72,13.6 206.74,14.62 208.19,14.62 208.26,14.62
DL_1.35V on TOP (solid shape): 190.58,12.22 190.58,11.23 190.29,10.93 189.21,10.93 189.09,11.06 189.09,12.33 189.21,12.46 190.34,12.46
DL_1.35V on TOP (solid shape): 209.72,16.4 209.72,14.93 209.66,14.87 209.53,14.87 209.28,15.13 209.28,15.63 209.15,15.76 209.01,15.76 208.26,15.76 208.19,15.84 208.19,16.42 208.29,16.52 209.6,16.52
DL_1.35V on IN1 (solid shape): 190.86,12.33 190.86,11.19 190.74,11.06 189.21,11.06 189.09,11.19 189.09,12.33 189.21,12.46 190.74,12.46
DL_1.35V on IN1 (solid shape): 209.53,16.27 209.53,16.01 209.41,15.89 208.26,15.89 207.88,16.27 207.12,16.27 206.99,16.4 206.99,17.28 207.12,17.41 208.39,17.41
EXT_MIC on BOTTOM (solid shape): 369.51,173.72 369.51,172.72 369.22,172.43 368.03,172.43 364.64,169.04 355.72,169.04 355.63,168.95 353.83,168.95 353.74,169.04 353.74,169.65 353.93,169.83 353.93,169.84 354.03,169.94 354.03,171.13 354.22,171.32 356.24,171.32 357.5,170.07 364.16,170.07 367.9,173.81 369.43,173.81
INT_SPK_L+ on TOP (solid shape): 344.08,177.79 344.08,177.23 344.03,177.18 343.64,177.18 342.88,176.42 342.88,175.65 342.63,175.4 342.63,174.47 342.58,174.42 342.41,174.42 342.35,174.49 342.35,175.44 342.37,175.46 342.37,176.67 342.88,177.18 342.88,177.69 343,177.8 344.06,177.8
INT_SPK_L+ on BOTTOM (solid shape): 343.01,176.54 343.01,175.53 343.39,175.15 343.39,174.64 343.26,174.51 342.63,174.51 342.5,174.64 342.5,175.27 342.37,175.4 342.37,176.54 342.5,176.67 342.88,176.67
INT_SPK_L- on TOP (solid shape): 342.63,177.81 342.63,177.18 342.25,176.8 342.25,175.65 342.12,175.53 342.12,174.49 342.07,174.43 341.89,174.43 341.85,174.47 341.85,175.41 341.74,175.53 341.74,176.67 341.36,177.05 341.36,177.81 341.49,177.94 342.5,177.94
INT_SPK_L- on BOTTOM (solid shape): 342.25,176.67 342.25,174.64 342.12,174.51 341.74,174.51 341.61,174.64 341.61,176.67 341.74,176.8 342.12,176.8
INT_SPK_R+ on TOP (solid shape): 339.58,177.81 339.58,177.3 339.88,177.01 340.26,177.01 340.6,176.67 340.6,175.36 340.62,175.34 340.62,174.45 340.56,174.38 340.38,174.38 340.34,174.42 340.34,175.4 340.12,175.62 340.12,176.24 339.73,176.64 338.72,176.64 338.31,177.05 338.31,177.81 338.44,177.94 339.45,177.94
INT_SPK_R+ on BOTTOM (solid shape): 340.6,176.54 340.6,175.4 340.47,175.27 340.47,174.64 340.34,174.51 339.83,174.51 339.71,174.64 339.71,175.02 340.13,175.44 340.13,176.59 340.22,176.67 340.47,176.67
INT_SPK_R- on TOP (solid shape): 341.1,177.81 341.1,176.92 341.36,176.67 341.36,175.53 341.1,175.27 341.1,174.45 341.06,174.4 340.88,174.4 340.85,174.43 340.85,175.4 340.72,175.53 340.72,176.8 340.3,177.22 339.97,177.22 339.83,177.36 339.83,177.81 339.96,177.94 340.98,177.94
INT_SPK_R- on BOTTOM (solid shape): 341.36,176.54 341.36,174.64 341.23,174.51 340.9,174.51 340.88,174.51 340.87,174.53 340.71,174.53 340.6,174.64 340.6,175.15 340.72,175.27 340.72,176.67 340.85,176.8 341.1,176.8
INT_SPKL_L+ on TOP (solid shape): 344.15,180.12 344.15,178.57 344.14,178.56 343.1,178.56 342.98,178.68 342.98,180.16 343.23,180.4 343.88,180.4
INT_SPKL_L+ on TOP (solid shape): 115.65,8.78 115.65,8.14 115.53,8.01 111.83,8.01 111.67,8.18 111.67,8.79 111.78,8.9 115.53,8.9
INT_SPKL_L+ on IN1 (solid shape): 316.01,122.78 316.01,121.68 315.86,121.53 314.97,121.53 314.83,121.67 314.83,122.9 315.02,123.09 315.7,123.09
INT_SPKL_L+ on IN1 (solid shape): 324.55,143.6 324.55,142.12 324.34,141.91 323.95,141.91 323.52,142.34 323.52,143.54 323.85,143.87 324.29,143.87
INT_SPKL_L+ on IN2 (solid shape): 112.77,9.58 112.77,8.19 112.71,8.13 111.77,8.13 111.6,8.29 111.6,9.58 111.65,9.63 112.72,9.63
INT_SPKL_L+ on IN2 (solid shape): 323.76,144.74 323.79,144.74 324.4,144.12 324.4,142.96 324.2,142.76 323.66,142.76 323.24,143.18 323.24,144.51 323.52,144.79 323.71,144.79
INT_SPKL_L+ on IN2 (solid shape): 316.05,121.87 316.05,121.32 316.04,121.32 316.04,121.25 315.86,121.07 314.36,121.07 313.91,121.51 313.91,121.86 314.08,122.02 315.5,122.02 315.51,122.03 315.88,122.03
INT_SPKL_L+ on IN2 (solid shape): 344.6,182.85 344.6,179.64 344.23,179.27 342.98,179.27 342.69,179.57 342.69,180.71 342.7,180.74 342.74,180.76 342.8,180.77 342.86,180.78 342.94,180.79 342.99,180.74 343.51,180.62 343.57,181.14 343.55,181.21 343.57,181.27 343.43,181.82 342.94,181.55 342.89,181.48 342.81,181.46 342.77,181.47 342.74,181.47 342.7,181.49 342.69,181.52 342.69,183.1 342.87,183.29 344.17,183.29
INT_SPKL_L- on TOP (solid shape): 342.63,180.48 342.63,178.57 342.5,178.45 341.49,178.45 341.36,178.57 341.36,180.86 341.49,180.99 342.12,180.99
INT_SPKL_L- on TOP (solid shape): 115.62,7.42 115.62,6.93 115.44,6.76 111.74,6.76 111.65,6.85 111.65,7.38 111.79,7.52 115.52,7.52
INT_SPKL_L- on IN1 (solid shape): 326.45,144.06 326.45,142.6 326.12,142.27 325.32,142.27 325.32,143.87 325.59,144.13 326.37,144.13
INT_SPKL_L- on IN1 (solid shape): 317.37,120.69 317.37,120.23 317,119.86 315.06,119.86 314.68,120.24 314.68,120.74 314.9,120.97 317.09,120.97
INT_SPKL_L- on IN2 (solid shape): 113.67,7.3 113.67,6.87 113.51,6.71 111.76,6.71 111.64,6.82 111.64,7.42 111.74,7.52 113.46,7.52
INT_SPKL_L- on IN2 (solid shape): 342.17,181.77 342.17,179.73 342.04,179.6 341.54,179.6 341.36,179.78 341.36,180.73 341.08,181.01 341.08,181.89 341.18,181.99 341.96,181.99
INT_SPKL_L- on IN2 (solid shape): 315.63,120.47 315.63,119.77 315.3,119.44 314.18,119.44 313.91,119.71 313.91,120.17 314.1,120.35 314.99,120.35 315.18,120.55 315.55,120.55
INT_SPKL_L- on IN2 (solid shape): 325.75,145.19 325.75,144.55 325.74,144.54 325.74,144.13 325.85,144.02 325.85,143.26 325.74,143.14 325.34,143.14 324.99,143.5 324.99,144.5 324.76,144.73 324.76,145.1 325.12,145.45 325.48,145.45
INT_SPKR_R+ on TOP (solid shape): 339.58,180.61 339.58,178.57 339.45,178.45 338.44,178.45 338.31,178.57 338.31,180.73 338.44,180.86 339.33,180.86
INT_SPKR_R+ on IN2 (solid shape): 339.2,178.96 339.05,178.8 338.67,178.8 338.49,178.98 338.49,180.67 338.63,180.81 339.2,180.81
INT_SPKR_R+ on IN2 (solid shape): 113.11,5.16 113.11,4.72 112.67,4.28 112.45,4.28 111.7,5.03 111.23,5.03 111.13,5.13 111.13,5.93 111.16,5.96 112.31,5.96
INT_SPKR_R+ on TOP: 115.55,6.24 115.68,6.11 115.68,5.73 115.43,5.47 112.5,5.47 112.38,5.35 111.11,5.35 110.98,5.47 110.98,6.11 111.11,6.24
INT_SPKR_R- on TOP (solid shape): 341.1,180.86 341.1,178.57 340.98,178.45 339.96,178.45 339.83,178.57 339.83,180.86 339.96,180.99 340.98,180.99
INT_SPKR_R- on TOP (solid shape): 115.68,4.84 115.68,4.2 115.43,3.95 113.52,3.95 112.38,2.81 111.23,2.81 111.11,2.93 111.11,3.44 112.76,5.09 115.43,5.09
INT_SPKR_R- on IN2 (solid shape): 340.74,180.31 340.74,178.31 340.37,177.94 340.03,177.94 339.82,178.14 339.82,180.77 339.89,180.84 340.22,180.84
INT_SPKR_R- on IN2 (solid shape): 113.34,2.65 113.34,2.57 112.67,1.89 112.45,1.89 111.96,2.39 111.15,2.39 111.08,2.45 111.08,3.3 111.15,3.37 112.63,3.37
JAPS1_4 on TOP (solid shape): 302.38,113.52 302.38,112.76 302.54,112.61 303.85,112.61 303.93,112.53 303.93,112.37 303.84,112.28 300.92,112.28 300.77,112.42 300.77,112.97 300.8,112.99 301.32,112.99 301.42,113.09 301.42,113.82 301.48,113.89 302.02,113.89
JAPS1_7 on TOP (solid shape): 302.68,114.11 303.85,114.11 303.94,114.02 303.94,113.86 303.85,113.78 302.34,113.78 302,114.12 301.53,114.12 301.5,114.16 301.5,114.74 301.53,114.77 302.01,114.77
LG_3V on TOP (solid shape): 135.75,6.67 135.75,5.65 135.63,5.54 135.12,5.54 134.84,5.26 134.84,4.88 134.55,4.58 133.55,4.58 133.42,4.71 133.42,6.22 133.97,6.77 135.64,6.77
LG_3V on BOTTOM (solid shape): 150.03,8.33 150.03,7.44 149.97,7.38 149.78,7.38 148.64,8.52 148.64,8.84 148.7,8.9 149.46,8.9
LG_3V on IN1 (solid shape): 149.72,8.65 149.72,8.14 149.59,8.01 149.21,8.01 147.94,9.28 147.94,9.54 148.06,9.66 148.7,9.66
LG_3V on IN1 (solid shape): 134.86,5.85 134.86,4.84 134.73,4.71 133.52,4.71 133.43,4.8 133.43,5.91 133.51,5.98 134.73,5.98
LG_5V on TOP (solid shape): 158.95,8.77 158.95,8.5 159.37,8.08 159.37,7.12 159.24,7 158.35,7 158.26,7.09 158.29,7.11 158.29,8.88 158.44,9.03 158.69,9.03
LG_5V on BOTTOM (solid shape): 152.76,9.03 152.76,8.78 152.13,8.14 151.87,8.14 151.62,7.89 151.62,7.75 151.62,7.49 151.6,7.47 151.47,7.47 151.43,7.51 151.43,8.33 151.68,8.58 151.68,8.71 152.13,9.16 152.64,9.16
LG_5V on IN1 (solid shape): 153.27,9.41 153.27,8.78 153.14,8.65 152.64,8.65 152.13,8.14 151.87,8.14 151.75,8.27 151.75,9.28 152,9.54 153.14,9.54
LG_5V on IN1 (solid shape): 158.75,9.03 158.86,8.92 158.86,7.25 158.73,7.12 157.46,7.12 157.34,7.25 157.34,8.39 157.51,8.57 157.51,8.58 157.96,9.03 158.71,9.03
LG_+1.05VSP on TOP (solid shape): 229.85,4.84 229.85,4.33 229.73,4.2 227.57,4.2 227.44,4.33 227.44,4.84 227.57,4.96 229.73,4.96
LG_+1.05VSP on TOP (solid shape): 241.03,10.74 241.03,9.73 240.97,9.66 240.01,9.66 239.95,9.73 239.95,10.43 240.39,10.87 240.9,10.87
LG_+1.05VSP on IN1 (solid shape): 229.47,5.22 229.47,4.33 229.34,4.2 227.57,4.2 227.44,4.33 227.44,4.97 227.57,5.09 228.46,5.09 228.84,5.47 229.22,5.47
LG_+1.05VSP on IN1 (solid shape): 241.66,12.08 241.66,9.79 241.54,9.66 240.39,9.66 240.27,9.79 240.27,10.98 240.3,11.06 240.37,11.09 240.71,11.44 240.37,11.8 240.3,11.83 240.27,11.9 240.27,12.2 240.39,12.33 241.41,12.33
LGATE1 on BOTTOM (solid shape): 141.84,147.33 141.84,146.06 141.71,145.94 140.57,145.94 140.44,146.06 140.44,147.33 140.57,147.46 141.72,147.46
LGATE1 on BOTTOM (solid shape): 146.53,148.73 146.53,147.5 146.54,147.47 146.54,147.45 146.54,146.19 146.41,146.06 145.91,146.06 145.78,146.19 145.78,147.45 145.78,147.47 145.79,147.5 145.79,148.72 145.82,148.74 146.52,148.74
LGATE1 on BOTTOM (solid shape): 123.49,154.51 123.5,154.51 124.14,154.51 124.57,154.07 124.57,153.87 124.44,153.75 124.19,153.75 123.93,154 123.93,154 123.43,154 122.97,154.45 122.92,154.51 121.89,154.51 121.85,154.52 121.84,154.56 121.84,154.65 121.85,154.68 121.89,154.7 123.3,154.7
LGATE1 on IN4 (solid shape): 141.84,147.97 141.84,146.19 141.71,146.06 140.7,146.06 140.57,146.19 140.57,147.97 140.7,148.09 141.71,148.09
LGATE1 on IN4 (solid shape): 142.48,147.08 142.48,146.19 142.35,146.06 141.33,146.06 141.21,146.19 141.21,147.08 141.46,147.33 142.22,147.33
LGATE1 on IN4 (solid shape): 143.2,147.09 143.2,146.18 143.09,146.06 141.33,146.06 141.21,146.19 141.21,147.08 141.46,147.33 142.96,147.33
LGATE1 on IN4 (solid shape): 125.46,154.19 125.46,153.43 125.33,153.3 123.68,153.3 123.3,153.68 123.3,154.44 123.43,154.57 125.08,154.57
LGATE1 on IN4 (solid shape): 146.79,148.67 146.79,147.52 146.76,147.49 146.76,146.28 146.67,146.19 145.78,146.19 145.4,146.57 145.4,147.33 145.6,147.54 145.6,148.6 145.79,148.79 146.67,148.79
LGATE1_VGA on BOTTOM (solid shape): 300.72,154.7 300.72,153.56 300.59,153.43 299.32,153.43 299.19,153.56 299.19,154.7 299.32,154.83 300.59,154.83
LGATE1_VGA on BOTTOM (solid shape): 300.72,149.11 300.72,148.93 300.72,147.97 300.59,147.84 299.45,147.84 299.32,147.97 299.32,149.11 299.45,149.24 300.59,149.24
LGATE1_VGA on BOTTOM (solid shape): 308.21,161.81 307.26,161.81 306.75,161.3 305.74,161.3 305.67,161.37 305.67,161.76 306.29,161.76 306.36,161.83 306.43,161.85 306.47,161.88 306.85,161.88 307.04,162.06 308.21,162.06
LGATE1_VGA on IN1 (solid shape): 300.72,154.83 300.72,153.43 300.46,153.17 299.45,153.17 299.32,153.3 299.32,154.83 299.45,154.95 300.59,154.95
LGATE1_VGA on IN1 (solid shape): 306.94,161.94 306.94,161.56 306.69,161.3 304.53,161.3 304.4,161.43 304.4,161.94 304.53,162.06 306.81,162.06
LGATE1_VGA on IN4 (solid shape): 300.59,149.11 300.59,147.97 300.46,147.84 299.32,147.84 299.19,147.97 299.19,149.11 299.32,149.24 300.46,149.24
LGATE1_VGA on IN4 (solid shape): 300.72,153.81 300.72,152.67 300.59,152.54 299.32,152.54 299.19,152.67 299.19,153.81 299.32,153.94 300.59,153.94
LGATE2 on BOTTOM (solid shape): 128.63,147.33 128.63,146.19 128.51,146.06 127.36,146.06 127.24,146.19 127.24,147.33 127.36,147.46 128.51,147.46
LGATE2 on BOTTOM (solid shape): 133.97,147.33 133.97,146.26 133.97,146.19 133.84,146.06 132.7,146.06 132.57,146.19 132.57,147.33 132.7,147.46 133.84,147.46
LGATE2 on BOTTOM (solid shape): 122.98,153.3 122.98,153.05 123.1,152.93 123.13,152.89 123.16,152.85 123.43,152.58 123.43,152.16 123.3,152.03 123.05,152.03 122.28,152.79 122.28,153.24 122.22,153.3 121.95,153.3 121.92,153.32 121.9,153.35 121.9,153.44 121.92,153.48 121.95,153.49 122.79,153.49
LGATE2 on IN1 (solid shape): 129.27,147.08 129.27,146.19 129.14,146.06 128.13,146.06 128,146.19 128,147.08 128.13,147.21 129.14,147.21
LGATE2 on IN1 (solid shape): 134.09,147.21 134.09,146.19 133.97,146.06 132.7,146.06 132.57,146.19 132.57,147.21 132.7,147.33 133.97,147.33
LGATE2 on IN4 (solid shape): 128.62,148.11 128.63,148.09 128.63,148.08 128.63,146.06 128.51,145.94 127.62,145.94 127.49,146.06 127.49,148.09 127.62,148.22 128.51,148.22
LGATE2 on IN4 (solid shape): 123.81,152.29 123.92,152.29 124.02,152.27 124.12,152.29 124.32,152.29 124.44,152.16 124.44,151.52 124.32,151.4 123.3,151.4 123.17,151.52 123.17,151.9 122.41,152.67 122.41,153.05 122.54,153.17 122.92,153.17
LGATE2_VGA on BOTTOM (solid shape): 300.59,160.67 300.59,159.52 300.46,159.4 299.19,159.4 299.07,159.52 299.07,160.67 299.19,160.79 300.46,160.79
LGATE2_VGA on BOTTOM (solid shape): 300.59,166.26 300.59,165.11 300.6,165.11 300.6,164.85 300.54,164.79 299.32,164.79 299.16,164.63 298.79,164.63 298.66,164.76 298.66,166.23 298.81,166.38 300.46,166.38
LGATE2_VGA on BOTTOM (solid shape): 305.71,163.39 305.9,163.33 306.09,163.39 306.37,163.39 306.4,163.37 306.43,163.33 306.62,163.33 306.63,163.32 307.21,163.32 307.26,163.27 308.21,163.27 308.21,163.08 306.88,163.08 306.56,162.76 306.24,162.76 306.18,162.83 306.04,162.83 306.03,162.83 305.85,162.88 305.67,162.83 305.66,162.83 305.49,162.83 305.49,162.85 305.39,162.85 305.29,162.95 305.29,163.28 305.39,163.39
LGATE2_VGA on IN1 (solid shape): 299.58,165.62 299.58,160.79 300.46,159.91 300.46,159.52 300.34,159.4 298.69,159.4 298.56,159.52 298.56,165.62 298.69,165.75 299.45,165.75
LGATE2_VGA on IN1 (solid shape): 305.44,163.97 305.52,163.93 305.54,163.84 305.69,163.39 306.16,163.44 306.23,163.46 306.3,163.44 306.41,163.36 306.54,163.33 306.56,163.33 306.69,163.21 306.69,162.83 306.56,162.7 306.31,162.7 306.18,162.83 306.04,162.83 306.03,162.83 305.84,162.88 305.66,162.83 304.53,162.83 304.4,162.95 304.4,163.72 304.66,163.97
LGATE3 on TOP (solid shape): 159.3,155.97 159.3,155.1 159.27,155.07 158.39,155.07 158.2,155.26 158.2,156.06 158.29,156.15 159.13,156.15
LGATE3 on BOTTOM (solid shape): 154.92,147.21 154.92,146.06 154.8,145.94 153.65,145.94 153.53,146.06 153.53,147.21 153.65,147.33 154.8,147.33
LGATE3 on BOTTOM (solid shape): 160.13,148.39 160.13,146.32 159.88,146.06 158.86,146.06 158.73,146.19 158.73,147.46 158.84,147.56 158.85,147.58 158.88,147.59 158.97,147.68 158.97,148.6 159.13,148.75 159.76,148.75
LGATE3 on IN2 (solid shape): 159.28,155.92 159.28,154.72 159.06,154.51 158.4,154.51 158.1,154.81 158.1,156.03 158.2,156.13 159.06,156.13
LGATE3 on IN2 (solid shape): 160.05,148.58 160.05,147.43 158.59,145.97 154.49,145.97 154,146.47 154,148.07 154.2,148.27 154.88,148.27 155.15,148.01 155.15,147.61 155.35,147.41 158.61,147.41 158.9,147.7 158.9,148.73 159.04,148.87 159.76,148.87
LX_PCIE on TOP (solid shape): 195.63,95.71 195.63,92.98 195.82,92.79 197.96,92.79 198,92.75 198,91.49 197.84,91.33 195.31,91.33 195.12,91.13 195.12,89.36 195,89.23 194.98,89.23 194.87,89.18 194.78,89.1 193.02,89.1 192.9,89.23 192.9,95.64 193.09,95.83 195.5,95.83
MIC1_L_C on BOTTOM (solid shape): 348.91,165.5 348.91,164.11 348.78,163.98 347.97,163.98 347.83,164.12 347.83,165.6 347.9,165.68 348.73,165.68
MIC1_R_C on BOTTOM (solid shape): 347.63,165.55 347.63,164.16 347.48,164 346.62,164 346.44,164.17 346.44,165.48 346.54,165.58 347.61,165.58
P33ALW on TOP (solid shape): 157.97,170.45 157.97,169.81 157.84,169.68 155.94,169.68 155.65,169.39 154.12,169.39 154.05,169.47 154.05,169.62 154.11,169.68 155.3,169.68 156.19,170.57 157.84,170.57
P33ALW2 on TOP: 153.91,164.54 155.39,163.06 156.41,163.06 156.54,162.93 156.54,161.91 156.43,161.81 156.02,161.81 155.91,161.91 155.91,162.43 155.77,162.58 155.17,162.58 153.63,164.12 153.63,165.2 153.67,165.24 153.85,165.24 153.91,165.18
PCIE_B+ on TOP (solid shape): 195.91,100.37 195.91,99.87 195.94,99.83 196.45,99.83 196.49,99.87 196.49,100.37 196.53,100.41 196.68,100.41 196.72,100.37 196.72,99.89 196.77,99.83 197.16,99.83 197.2,99.82 197.21,99.78 197.21,96.64 198,95.86 198,95.01 197.95,94.97 196.75,94.97 195.31,96.41 195.31,98.18 194.93,98.56 194.93,99.71 195.05,99.83 195.63,99.83 195.68,99.89 195.68,100.37 195.72,100.41 195.87,100.41
PHASE1 on TOP (solid shape): 139.81,137.68 139.81,134.56 139.48,134.23 136.17,134.23 135.97,134.42 135.97,134.76 136,134.78 136,137.81 136.13,137.93 139.56,137.93
PHASE1 on TOP (solid shape): 145.52,137.81 145.52,136.16 146.03,135.65 146.03,133.91 145.92,133.79 142.31,133.79 141.97,134.14 141.97,134.14 141.97,137.68 142.22,137.93 145.4,137.93
PHASE1 on BOTTOM (solid shape): 124.7,154.89 124.76,154.83 125.52,154.83 125.59,154.76 125.59,153.75 125.52,153.68 124.76,153.68 124.7,153.75 124.7,154.13 124.19,154.63 123.55,154.63 123.3,154.89 121.95,154.89 121.92,154.9 121.9,154.94 121.9,155.09 121.92,155.13 121.95,155.14 123.11,155.14 123.17,155.21 124.38,155.21
PHASE1 on BOTTOM (solid shape): outline of 173 points within 134.86,133.74 146.67,145.43
PHASE1 on IN2 (solid shape): 146.03,136.41 146.03,135.39 145.91,135.27 144.51,135.27 144.38,135.39 144.38,136.54 144.51,136.66 145.78,136.66
PHASE1 on IN2 (solid shape): 125.84,155.33 125.84,154.36 125.83,154.32 125.79,154.3 124.51,154.3 124.34,154.36 124.16,154.34 124.09,154.34 124.03,154.4 123.86,154.59 123.6,154.63 123.58,154.62 123.56,154.63 123.44,154.75 123.44,155.22 123.45,155.25 123.49,155.27 123.62,155.29 123.74,155.36 123.81,155.39 123.87,155.36 124.15,155.27 124.42,155.4 124.43,155.42 124.46,155.42 125.75,155.42
PHASE1_VGA on TOP (solid shape): 290.94,157.37 290.94,154.44 290.69,154.19 286.62,154.19 286.24,153.81 286.24,152.16 286.37,152.03 290.81,152.03 291.07,151.78 291.07,148.17 290.81,147.92 284.45,147.92 283.95,148.41 283.95,157.37 284.08,157.49 290.81,157.49
PHASE1_VGA on BOTTOM (solid shape): 308.21,161.18 308.21,160.67 307.89,160.35 307.39,160.35 306.18,159.14 304.85,159.14 304.72,159.27 304.72,160.22 304.78,160.29 306.31,160.29 306.32,160.3 306.55,160.3 307.27,161.02 307.27,161.19 307.32,161.24 308.15,161.24
PHASE1_VGA on BOTTOM (solid shape): 298.94,158.13 298.94,148.73 298.18,147.97 294.52,147.97 294.12,148.37 291.2,148.37 291.03,148.2 291.03,146.76 290.85,146.58 289.75,146.58 289.68,146.65 289.68,148.23 289.44,148.48 287.13,148.48 286.24,149.36 286.24,151.9 286.37,152.03 288.53,152.03 288.78,152.29 288.78,153.05 288.91,153.17 289.02,153.17 291.59,153.17 291.7,153.17 291.7,154.06 287.92,154.06 287.64,154.19 287.35,154.06 287.16,154.06 286.99,154.17 286.79,154.18 286.76,154.18 286.37,154.57 286.37,157.75 286.62,158 290.92,158 291.68,158.76 292.59,158.76 292.59,158.76 298.31,158.76
PHASE1_VGA on IN1 (solid shape): 290.43,149.75 290.43,148.98 290.18,148.73 288.4,148.73 288.15,148.98 288.15,149.75 288.27,149.87 290.3,149.87
PHASE1_VGA on IN1 (solid shape): 307.96,160.79 307.96,160.41 307.83,160.29 307.2,160.29 306.56,159.65 305.8,159.65 305.67,159.78 305.67,160.41 305.73,160.47 305.75,160.47 305.92,160.48 306.06,160.57 306.13,160.6 306.19,160.57 306.6,160.53 306.82,160.87 306.83,160.91 306.87,160.92 307.83,160.92
PHASE2 on TOP (solid shape): 126.86,137.81 126.86,134.63 126.6,134.38 122.92,134.38 122.79,134.51 122.79,137.68 123.05,137.93 126.73,137.93
PHASE2 on TOP (solid shape): 132.19,137.81 132.19,136.54 132.34,136.39 133.08,136.39 133.33,136.13 133.33,134.76 132.95,134.38 128.89,134.38 128.76,134.51 128.76,137.68 129.01,137.93 132.06,137.93
PHASE2 on BOTTOM (solid shape): 121.78,153.11 121.78,152.92 123.93,150.76 123.93,149.68 123.87,149.62 122.92,149.62 122.86,149.68 122.86,150.7 122.28,151.27 122.28,151.59 121.52,152.35 121.52,153.11 121.59,153.17 121.71,153.17
PHASE2 on BOTTOM (solid shape): outline of 108 points within 121.65,134 133.33,145.43
PHASE2 on IN4 (solid shape): 130.16,136.79 130.16,135.39 130.03,135.27 128.51,135.27 128.38,135.39 128.38,136.79 128.51,136.92 130.03,136.92
PHASE2 on IN4 (solid shape): 123.05,151.78 123.05,151.47 123.05,151.4 123.17,151.27 123.17,150.76 123.05,150.63 122.54,150.63 122.28,150.89 122.28,151.58 121.9,151.96 121.9,152.29 122.03,152.41 122.41,152.41
PHASE2_VGA on TOP (solid shape): outline of 105 points within 283.57,157.89 291.07,169.6
PHASE2_VGA on BOTTOM (solid shape): 307.07,164.16 307.2,164.16 307.26,164.1 308.08,164.1 308.15,164.03 308.15,163.84 306.94,163.84 306.91,163.88 306.9,163.89 306.83,163.99 306.73,164.06 306.72,164.06 306.69,164.1 305.35,164.1 305.04,163.78 305.04,163.37 304.96,163.3 304.26,163.3 304.21,163.35 304.21,164.35 304.27,164.41 304.96,164.41 304.97,164.41 305.04,164.48 305.16,164.6 306.62,164.6
PHASE2_VGA on BOTTOM (solid shape): 295.38,172.35 295.38,170.45 295.64,170.19 298.31,170.19 298.69,169.81 298.69,167.33 298.45,167.09 298.45,164.4 298.69,164.16 298.69,159.14 298.56,159.02 289.8,159.02 289.03,158.25 285.99,158.25 285.61,158.64 285.61,162.36 286.1,162.85 287.94,162.85 288.1,163 291.54,163 291.64,163.11 291.64,163.8 291.56,163.88 289.17,163.88 289.09,163.95 289.09,165.69 288.9,165.89 285.83,165.89 285.73,165.98 285.73,167.78 286.24,168.29 293.1,168.29 293.73,168.92 293.73,170.32 294.11,170.7 294.11,172.35 294.37,172.61 295.13,172.61
PHASE2_VGA on IN1 (solid shape): 289.77,160.32 289.77,159.56 289.47,159.26 288.17,159.26 287.94,159.49 287.94,160.4 288.17,160.63 289.47,160.63
PHASE2_VGA on IN1 (solid shape): 305.16,164.6 306.56,164.6 306.69,164.48 306.69,164.22 306.56,164.1 305.98,164.1 304.6,164.1 304.6,164.1 304.15,164.1 304.02,164.22 304.02,164.86 304.15,164.99 304.78,164.99
PHASE3 on TOP (solid shape): 152.51,137.55 152.51,134.07 152.27,133.83 148.93,133.83 148.6,134.16 148.6,134.73 148.57,134.76 148.57,137.55 148.83,137.81 152.26,137.81
PHASE3 on TOP (solid shape): 158.35,137.55 158.35,136.16 158.9,135.61 158.9,133.85 158.77,133.72 155.16,133.72 154.84,134.04 154.84,134.59 154.67,134.76 154.67,137.55 154.92,137.81 158.1,137.81
PHASE3 on TOP (solid shape): 159.25,153.73 159.25,153.66 159.46,153.45 159.61,153.45 160.09,152.97 160.4,152.97 160.61,152.76 160.61,151.96 160.51,151.85 159.76,151.85 159.15,152.46 158.52,152.46 158.2,152.78 158.2,153.71 158.31,153.82 159.16,153.82
PHASE3 on BOTTOM (solid shape): outline of 112 points within 147.68,133.36 159.75,145.3
PHASE3 on IN2 (solid shape): 158.75,136.23 158.75,135.28 158.61,135.14 157.59,135.14 157.48,135.25 157.48,136.13 157.76,136.41 158.57,136.41
PHASE3 on IN2 (solid shape): 160.6,152.68 160.6,152.46 160.61,152.45 160.61,151.84 160.45,151.68 159.94,151.68 159.2,152.41 159.2,153.23 159.42,153.44 159.84,153.44
REGCTL_PNP10 on BOTTOM (solid shape): 315.2,196.48 315.2,194.83 314.94,194.58 314.94,193.05 314.82,192.93 313.29,192.93 313.16,193.05 313.16,193.69 313.17,193.69 313.17,193.95 314.41,195.19 314.66,195.19 315.01,195.53 315.01,196.48 315.07,196.54 315.13,196.54
RING2 on IN4 (solid shape): 349.77,183.39 349.77,182.03 348.97,181.23 348.97,180.16 348.93,180.14 348.64,179.81 348.74,179.38 348.74,176.36 348.71,176.35 348.5,176.1 348.58,175.79 348.61,175.72 348.58,175.66 348.5,175.35 348.71,175.1 348.74,175.09 348.74,169.6 348.15,169.01 346.04,169.01 346.03,169.04 345.76,169.25 345.44,169.14 345.31,169.14 345.22,169.23 345.22,170.21 345.32,170.31 346.35,170.31 346.36,170.27 346.98,169.95 347.27,170.59 347.26,170.6 347.26,179.77 347.3,179.85 347.38,179.87 347.73,180.05 347.7,180.45 347.67,180.51 347.7,180.58 347.74,180.98 347.38,181.16 347.3,181.19 347.26,181.26 347.26,183.32 347.59,183.65 349.5,183.65
RING2 on BOTTOM: 351.06,183.69 348.79,183.69 348.39,183.3 348.39,182.63 348.56,182.46 349.94,182.46 350.29,182.8 351.1,182.8 351.16,182.87 351.16,183.59
RING2_L on BOTTOM (solid shape): 369.12,183.17 369.12,182.6 368.99,182.47 366.97,182.47 365.92,183.53 364.96,183.53 364.92,183.53 364.11,183.53 364.07,183.53 360.86,183.53 360.82,183.53 360.01,183.53 359.97,183.53 358.28,183.53 355.67,180.92 354.01,180.92 353.65,181.28 350.72,181.28 350.3,181.7 350.3,182.13 350.36,182.19 351.39,182.19 351.48,182.28 355.52,182.28 358,184.76 367.53,184.76
RUN_ON_CPU1.5VS3# on TOP (solid shape): 139.82,71.64 139.82,71.39 139.92,71.28 140.61,71.28 140.86,71.03 140.86,68.63 140.7,68.47 138.96,68.47 138.03,69.39 138.03,70.24 137.65,70.62 137.65,71.77 137.78,71.89 139.56,71.89
SLEEVE on BOTTOM (solid shape): 353.46,168.39 354.39,168.39 354.47,168.31 354.47,166.83 354.46,166.82 354.46,166.6 354.34,166.48 352.41,166.48 352.29,166.6 352.29,168.64 352.41,168.76 353.09,168.76
SLEEVE on IN2: 353.4,166.36 353.23,166.52 353.23,167.94 353.82,168.53 353.82,170.55 353.44,170.93 353.38,170.93 353.07,171.12 352.75,170.93 349.93,170.93 349.53,171.34 349.16,171.69 348.81,171.32 347.96,170.47 345.47,170.47 345.31,170.64 345.31,171.47 345.35,171.55 345.45,171.56 345.9,171.56 346.21,171.89 346.23,171.92 346.5,171.92 347.44,172.86 350.58,172.86 351.1,172.34 351.1,172.34 351.28,172.16 352.03,172.16 352.25,172.21 352.44,172.34 353.36,172.34 353.44,172.3 353.47,172.22 353.82,171.82 354.17,172.22 354.19,172.3 354.27,172.34 354.41,172.34 355.08,171.67 355.08,167.4 354.03,166.36
SNUB_1.05V on BOTTOM (solid shape): 229.48,4.22 229.48,2.65 229.31,2.48 227.33,2.48 227.07,2.73 227.07,3.86 227.5,4.29 229.41,4.29
SNUB_1.5VSP on TOP (solid shape): 242.19,109.12 242.19,107.6 242.07,107.48 240.57,107.48 240.39,107.66 240.39,109.11 240.65,109.36 241.96,109.36
SNUB_1.8VSP on TOP (solid shape): 281.16,142.06 281.16,139.46 281.1,139.39 279.95,139.39 279.83,139.52 279.83,142.13 279.89,142.19 281.03,142.19
SNUB_1.35V on BOTTOM (solid shape): 194.85,14.53 194.85,12.88 194.72,12.75 193.73,12.75 193.21,13.27 192.49,13.27 192.45,13.29 192.44,13.32 192.44,14.08 192.45,14.12 192.49,14.13 193.4,14.13 193.55,14.29 193.55,14.57 193.65,14.66 194.72,14.66
SNUB_3V on TOP (solid shape): 134.48,8.01 134.48,7.12 134.35,7 131.68,7 131.55,7.12 131.55,8.01 131.68,8.14 134.35,8.14
SNUB_5V on TOP (solid shape): 158.16,8.95 158.16,7.16 158.03,7.04 156.42,7.04 156.1,7.35 156.1,9.04 156.23,9.17 157.95,9.17
SNUB_CHARGER on BOTTOM (solid shape): 98.05,172.82 98.05,171.4 97.84,171.18 95.87,171.18 95.74,171.31 95.74,172.87 95.83,172.96 97.91,172.96
SNUB_GPU_P1 on BOTTOM (solid shape): 294.11,147.71 294.51,147.71 294.74,147.48 294.76,147.48 294.76,146 294.45,145.68 292.57,145.68 292.32,145.92 292.32,148.07 292.43,148.17 293.66,148.17
SNUB_GPU_P2 on BOTTOM (solid shape): 298.32,172.33 298.32,172 298.43,171.88 299.03,171.88 299.08,171.83 299.08,170.88 298.95,170.75 296.95,170.75 296.82,170.88 296.82,172.29 296.99,172.45 298.19,172.45
SNUB_PCIE on TOP (solid shape): 197.8,90.74 197.8,90.26 197.72,90.18 197.04,90.18 196.83,89.98 196.83,89.29 196.76,89.22 195.66,89.22 195.61,89.27 195.61,90.84 195.72,90.94 197.59,90.94
SW1 on TOP (solid shape): 163.05,5.35 164.57,5.35 164.7,5.22 164.7,4.2 164.45,3.95 162.42,3.95 162.29,3.82 162.29,2.93 162.03,2.68 156.32,2.68 156.19,2.81 156.19,6.49 156.32,6.62 161.78,6.62
SW1 on BOTTOM (solid shape): 161.37,7.29 161.37,4.02 162.16,3.23 162.16,2.81 162.03,2.68 156.38,2.68 155.94,3.12 155.94,5.28 156.38,5.73 156.38,7.45 156.53,7.6 161.06,7.6
SW1 on BOTTOM (solid shape): 154.52,6.36 154.52,5.67 154.62,5.58 154.62,5.34 154.47,5.19 153.55,5.19 153.48,5.26 153.48,6.14 153.38,6.24 151.87,6.24 151.84,6.27 151.84,6.43 151.9,6.49 153.13,6.49 153.39,6.74 154.14,6.74
SW1 on IN1 (solid shape): 160.51,4.2 160.51,3.7 160.38,3.57 158.73,3.57 158.61,3.7 158.61,4.2 158.73,4.33 160.38,4.33
SW1 on IN1 (solid shape): 154.53,5.75 155.34,4.94 155.34,4.66 155.27,4.58 154.14,4.58 153.47,5.25 153.47,5.68 153.56,5.77 154.53,5.77
SW2 on TOP (solid shape): 133.26,5.45 133.26,4.57 133.37,4.46 134.86,4.46 135.24,4.84 135.24,5 135.53,5.3 138.11,5.3 138.41,4.99 138.41,4.2 138.69,3.92 140.89,3.92 141.11,3.71 141.11,1.69 140.9,1.49 133.02,1.49 131.55,2.95 131.55,5.47 131.68,5.6 133.1,5.6
SW2 on BOTTOM (solid shape): 146.86,7.89 146.86,7.63 147.94,6.55 148.45,6.55 148.51,6.49 149.59,6.49 149.62,6.46 149.62,6.29 149.59,6.26 148.6,6.26 148.32,5.98 146.92,5.98 146.79,6.11 146.79,6.49 146.48,6.81 146.03,6.81 145.91,6.93 145.91,7.89 146.03,8.01 146.73,8.01
SW2 on BOTTOM (solid shape): outline of 91 points within 132.19,1.56 143.75,8.52
SW2 on IN1 (solid shape): 148.32,6.36 148.32,6.01 147.16,4.85 146.88,4.85 146.67,5.07 146.67,5.98 147.18,6.49 148.19,6.49
SW2 on IN1 (solid shape): 140.5,2.37 140.5,1.75 140.28,1.54 138.88,1.54 138.6,1.82 138.6,2.43 138.54,2.49 138.54,3.06 138.67,3.19 139.68,3.19
SW_1.35V on TOP (solid shape): 209.09,15.51 209.09,15.13 209.32,14.9 209.32,14.57 209.3,14.55 208.52,14.55 208.26,14.81 207.06,14.81 206.8,14.55 206.29,14.55 206.1,14.74 206.1,15.57 206.17,15.63 208.96,15.63
SW_1.35V on TOP (solid shape): 195.18,10.3 195.18,7.38 195.44,7.12 198.9,7.12 199.25,6.78 199.25,2.55 199.12,2.43 188.96,2.43 188.83,2.55 188.83,10.3 188.96,10.43 195.05,10.43
SW_1.35V on BOTTOM (solid shape): 199.59,13.79 199.59,3.95 198.83,3.19 189.47,3.19 189.21,3.44 189.21,4.98 189.44,5.21 190.21,5.21 190.23,5.23 190.24,5.23 190.27,5.26 190.33,5.26 190.33,5.32 190.81,5.8 190.81,9.01 191.71,9.92 195.18,9.92 195.56,10.3 195.56,14.25 196.16,14.85 198.53,14.85
SW_1.35V on IN1 (solid shape): 199.5,6.11 199.5,5.09 199.12,4.71 197.85,4.71 197.72,4.84 197.72,6.11 197.85,6.24 199.37,6.24
SW_1.35V on IN1 (solid shape): 208.26,15.38 208.26,14.87 208.14,14.74 206.23,14.74 206.1,14.87 206.1,15.38 206.23,15.51 208.14,15.51
SW_+1.05VSP on TOP (solid shape): 234.68,10.05 234.68,4.71 234.3,4.33 230.36,4.33 230.23,4.46 230.23,7.38 230.49,7.63 231,7.63 231.25,7.89 231.25,10.05 231.38,10.17 234.55,10.17
SW_+1.05VSP on TOP (solid shape): 239.7,12.46 239.7,11.38 239.38,11.06 239.38,10.86 239.38,10.81 239.25,10.68 239.25,9.73 239,9.73 239,10.43 238.87,10.55 238.87,11.62 238.87,11.63 238.62,11.89 238.62,12.52 238.68,12.59 239.57,12.59
SW_+1.05VSP on BOTTOM (solid shape): 234.36,10.49 234.36,2.68 233.98,2.3 230.74,2.3 230.23,2.81 230.23,10.3 230.61,10.68 234.17,10.68
SW_+1.05VSP on IN1 (solid shape): 234.93,10.3 234.93,9.41 234.81,9.28 233.03,9.28 232.9,9.41 232.9,10.3 233.03,10.43 234.81,10.43
SW_+1.05VSP on IN1 (solid shape): 240.01,11.7 240.01,11.54 240,11.44 240.01,11.35 240.01,9.92 239.76,9.66 239.12,9.66 238.87,9.92 238.87,10.75 238.87,10.75 238.87,11.82 239,11.95 239.76,11.95
UG_3V on TOP (solid shape): 142.73,3.82 142.73,2.96 142.45,2.68 141.58,2.68 141.37,2.88 141.37,3.75 141.58,3.95 142.6,3.95
UG_3V on BOTTOM (solid shape): 149.65,7.25 149.65,7.12 149.59,7.06 148.51,7.06 147.94,7.63 147.94,7.89 148,7.95 148.95,7.95
UG_3V on IN1 (solid shape): 149.14,7.82 149.14,7.12 149.02,7 147.05,7 146.92,7.12 146.92,7.89 146.99,7.95 149.02,7.95
UG_3V on IN1 (solid shape): 143.11,4.97 143.11,3.7 142.86,3.44 142.86,2.94 142.59,2.68 141.97,2.68 141.84,2.81 141.84,4.97 141.97,5.09 142.98,5.09
UG_5V on TOP (solid shape): 165.72,4.97 165.72,3.81 165.46,3.56 165.46,2.68 165.34,2.55 164.83,2.55 164.7,2.68 164.7,3.95 164.96,4.2 164.96,5.14 165.03,5.22 165.46,5.22
UG_5V on BOTTOM (solid shape): 153.27,7.82 153.27,7.44 152.89,7.06 151.81,7.06 151.75,7.12 151.75,7.37 151.76,7.41 151.76,7.44 151.76,7.71 152,7.95 153.14,7.95
UG_5V on IN1 (solid shape): 154.16,7.89 154.16,7.12 154.03,7 152.26,7 152.13,7.12 152.13,7.89 152.26,8.01 154.03,8.01
UG_5V on IN1 (solid shape): 165.34,4.04 165.34,2.68 165.16,2.5 164.13,2.5 164.07,2.57 164.07,3.77 164.42,4.13 165.25,4.13
UG_+1.05VSP on TOP (solid shape): 232.65,11.32 232.65,10.43 232.52,10.3 231.5,10.3 231.38,10.43 231.38,11.32 231.5,11.44 232.52,11.44
UG_+1.05VSP on TOP (solid shape): 238.74,11.57 238.74,9.79 238.49,9.79 238.49,10.36 238.36,10.49 238.36,10.54 238.17,10.73 238.17,11.7 238.23,11.76 238.55,11.76
UG_+1.05VSP on IN1 (solid shape): 233.79,11.44 233.79,10.81 233.66,10.68 231.38,10.68 231.25,10.81 231.25,11.44 231.38,11.57 233.66,11.57
UG_+1.05VSP on IN1 (solid shape): 238.74,11.82 238.74,10.81 238.62,10.68 237.35,10.68 237.22,10.81 237.22,11.82 237.35,11.95 238.62,11.95
UGATE1 on TOP (solid shape): 141.08,137.68 141.08,134.76 140.83,134.51 140.32,134.51 140.19,134.63 140.19,137.68 140.32,137.81 140.95,137.81
UGATE1 on TOP (solid shape): 147.43,137.81 147.43,136.66 147.3,136.54 145.91,136.54 145.78,136.66 145.78,137.81 145.91,137.93 147.3,137.93
UGATE1 on IN1 (solid shape): 141.21,136.92 141.21,134.63 141.08,134.51 140.19,134.51 140.06,134.63 140.06,136.92 140.19,137.05 141.08,137.05
UGATE1 on IN1 (solid shape): 147.43,137.81 147.43,136.41 147.18,136.16 146.16,136.16 145.91,136.41 145.91,137.81 146.03,137.93 147.3,137.93
UGATE1 on IN1 (solid shape): 125.59,156.35 125.59,155.46 125.46,155.33 123.3,155.33 123.17,155.46 123.17,156.35 123.3,156.48 125.46,156.48
UGATE1_VGA on TOP (solid shape): 290.94,147.26 290.94,146.05 290.77,145.88 289.73,145.88 289.6,146.01 289.6,147.26 289.72,147.39 290.81,147.39
UGATE1_VGA on TOP (solid shape): 291.07,153.68 291.07,152.79 290.94,152.67 289.54,152.67 289.16,152.29 287.38,152.29 287.26,152.41 287.26,153.05 287.38,153.17 288.53,153.17 289.16,153.81 290.94,153.81
UGATE1_VGA on BOTTOM (solid shape): 308.53,159.97 307.96,159.4 307.2,159.4 307.07,159.52 307.07,159.78 307.51,160.22 307.95,160.22 308.02,160.22 308.34,160.54 308.34,160.61 308.34,160.92 308.53,160.92
UGATE1_VGA on IN2 (solid shape): 289.42,152.92 289.42,152.16 289.29,152.03 287.38,152.03 287.26,152.16 287.26,152.92 287.38,153.05 289.29,153.05
UGATE1_VGA on IN2 (solid shape): 308.34,159.91 308.34,158.89 308.08,158.64 307.07,158.64 306.94,158.76 306.94,159.78 307.32,160.16 308.08,160.16
UGATE1_VGA on IN2 (solid shape): 291.9,147.08 291.9,145.88 291.71,145.69 289.77,145.69 289.44,146.03 289.44,147.08 289.58,147.22 291.76,147.22
UGATE2 on TOP (solid shape): 127.87,137.68 127.87,134.63 127.74,134.51 127.11,134.51 126.98,134.63 126.98,137.68 127.11,137.81 127.74,137.81
UGATE2 on TOP (solid shape): 134.22,137.68 134.22,136.66 134.09,136.54 132.7,136.54 132.57,136.66 132.57,137.81 132.7,137.93 133.97,137.93
UGATE2 on BOTTOM (solid shape): 121.39,153.11 121.39,152.3 121.39,152.29 122.03,151.65 122.03,151.14 121.9,151.02 121.71,151.02 121.14,151.59 121.14,153.11 121.2,153.17 121.33,153.17
UGATE2 on IN1 (solid shape): 127.87,136.41 127.87,134.63 127.74,134.51 127.11,134.51 126.98,134.63 126.98,136.41 127.11,136.54 127.74,136.54
UGATE2 on IN1 (solid shape): 134.09,137.68 134.09,136.66 133.97,136.54 132.95,136.54 132.82,136.66 132.82,137.68 132.95,137.81 133.97,137.81
UGATE2 on IN4 (solid shape): 122.16,151.52 122.16,150.38 122.03,150.25 121.14,150.25 120.89,150.51 120.89,152.03 121.01,152.16 121.52,152.16
UGATE2 on IN4 (solid shape): 128,136.41 128,134.63 127.87,134.51 127.11,134.51 126.98,134.63 126.98,136.41 127.24,136.66 127.74,136.66
UGATE2_VGA on TOP (solid shape): 290.94,159.55 290.94,158.44 290.8,158.3 289.75,158.3 289.61,158.45 289.61,159.53 289.72,159.64 290.85,159.64
UGATE2_VGA on TOP (solid shape): 290.98,165.58 290.98,164.95 290.85,164.82 287.61,164.82 287.55,164.88 287.55,165.58 287.68,165.71 290.85,165.71
UGATE2_VGA on BOTTOM (solid shape): 307.07,165.18 307.07,164.68 307.07,164.67 307.26,164.48 308.21,164.48 308.21,164.29 307.25,164.29 307.12,164.29 306.68,164.73 306.62,164.73 306.56,164.79 305.93,164.79 305.74,164.99 305.74,165.24 305.86,165.37 306.88,165.37
UGATE2_VGA on IN1 (solid shape): 290.14,165.44 290.14,164.92 289.87,164.66 287.84,164.66 287.54,164.96 287.54,165.44 287.94,165.85 289.73,165.85
UGATE2_VGA on IN1 (solid shape): 306.94,165.62 306.94,164.86 306.81,164.73 306.61,164.73 305.29,164.73 304.91,165.11 304.85,165.18 304.78,165.24 304.66,165.37 304.66,165.49 304.91,165.75 306.81,165.75
UGATE2_VGA on IN4 (solid shape): 290.95,159.18 290.95,158.44 290.85,158.33 289.73,158.33 289.58,158.49 289.58,158.93 289.97,159.33 290.8,159.33
UGATE2_VGA on IN4 (solid shape): 288.53,165.58 288.79,165.32 288.79,164.15 288.48,163.83 288.29,163.83 287.54,164.58 287.54,165.42 287.71,165.6 288.53,165.6
UGATE3 on TOP (solid shape): 153.78,137.68 153.78,134.51 153.65,134.38 153.14,134.38 152.89,134.63 152.89,137.68 153.02,137.81 153.65,137.81
UGATE3 on TOP (solid shape): 160,137.68 160,136.54 159.88,136.41 158.73,136.41 158.61,136.54 158.61,137.68 158.73,137.81 159.88,137.81
UGATE3 on TOP (solid shape): 161.9,153.7 161.9,153.7 161.9,153.02 161.78,152.91 160.73,152.91 160.45,153.19 160.45,153.78 160.49,153.82 161.78,153.82
UGATE3 on IN1 (solid shape): 154.16,136.28 154.16,134.76 153.78,134.38 153.14,134.38 153.02,134.51 153.02,136.41 153.14,136.54 153.91,136.54
UGATE3 on IN1 (solid shape): 160.13,137.68 160.13,136.54 160,136.41 158.48,136.41 158.35,136.54 158.35,137.68 158.48,137.81 160,137.81
UGATE3 on IN2 (solid shape): 162.63,152.63 162.63,152.22 162.42,152.01 161.64,152.01 160.75,152.9 160.75,153.29 160.96,153.49 161.77,153.49
UGATE3 on IN2 (solid shape): 160.18,138.32 160.18,136.85 159.76,136.44 159.37,136.44 159.03,136.78 159.03,138.18 159.25,138.4 160.09,138.4
VLDOIN_1.35V on TOP (solid shape): 208.77,10.17 208.77,9.6 209.28,9.6 209.28,9.47 208.77,9.47 208.77,8.97 208.64,8.84 207.82,8.84 207.75,8.9 207.75,10.17 207.82,10.24 208.71,10.24
VLDOIN_1.35V on TOP (solid shape): 208.03,13.56 209.28,13.56 209.31,13.53 209.31,13.39 209.28,13.36 208.24,13.36 208.09,13.21 208.09,12.59 207.92,12.42 207.56,12.42 207.39,12.6 207.39,13.35 207.4,13.36 207.4,13.54 207.5,13.64 207.96,13.64
VLDOIN_1.35V on IN4 (solid shape): 208.58,13.35 208.58,8.94 208.43,8.79 207.96,8.79 207.78,8.97 207.78,12.27 207.45,12.6 207.45,13.37 207.63,13.55 208.38,13.55
Z4304 on TOP (solid shape): 122.96,189.99 122.96,189.01 122.63,188.68 121.71,188.68 121.53,188.86 121.53,189.98 121.8,190.25 122.7,190.25
Z4305 on TOP (solid shape): 120.94,190.12 120.94,188.96 120.66,188.68 119.73,188.68 119.53,188.89 119.53,190.17 119.68,190.32 120.73,190.32
Z4306 on TOP (solid shape): 118.94,190.25 118.94,188.84 118.75,188.65 117.71,188.65 117.53,188.82 117.53,190.23 117.7,190.4 118.79,190.4
Z5304 on TOP (solid shape): 233.59,63.42 233.59,62.53 233.49,62.42 232.32,62.42 232.14,62.6 232.14,63.32 232.42,63.6 233.41,63.6
Z5305 on TOP (solid shape): 233.56,61.94 233.56,61.11 233.36,60.91 232.38,60.91 232.16,61.12 232.16,61.91 232.34,62.09 233.41,62.09
Z5306 on TOP (solid shape): 233.62,60.43 233.62,59.56 233.46,59.4 232.46,59.4 232.22,59.64 232.22,60.36 232.47,60.62 233.43,60.62
N16994246 on TOP (solid shape): 84.88,184.35 84.88,182.05 84.51,181.69 84.08,181.69 83.79,181.39 83.79,181.03 83.54,180.77 82.63,180.77 82.32,181.08 82.32,181.97 82.43,182.08 83.09,182.08 83.36,182.35 83.36,184.43 83.46,184.53 84.7,184.53
N18894554 on BOTTOM (solid shape): 126.98,155.97 126.98,153.75 126.86,153.62 126.16,153.62 126.09,153.68 126.09,155.97 126.16,156.03 126.92,156.03
N18894680 on BOTTOM (solid shape): 136,144.79 136,142.76 135.87,142.63 134.84,142.63 134.66,142.68 134.48,142.64 134.47,142.63 134.35,142.63 134.09,142.89 134.09,144.79 134.22,144.92 135.87,144.92
N18894698 on BOTTOM (solid shape): 125.48,158.29 125.48,156.5 125.4,156.41 124.57,156.41 124.44,156.54 123.11,156.54 122.66,156.1 121.95,156.1 121.92,156.11 121.9,156.15 121.9,156.3 121.92,156.33 121.95,156.35 122.47,156.35 123.36,157.24 124.32,157.24 124.44,157.37 124.44,158.32 124.51,158.38 125.38,158.38
N19359966 on BOTTOM (solid shape): 155.99,7.94 155.99,5.96 155.8,5.77 154.92,5.77 154.81,5.88 154.81,7.99 154.86,8.04 155.89,8.04
N19360218 on BOTTOM (solid shape): 145.4,9.28 145.4,7.12 145.27,7 144.51,7 144.38,7.12 144.38,9.28 144.51,9.41 145.27,9.41
N48711348 on BOTTOM (solid shape): 123.93,149.05 123.93,148.28 123.87,148.22 121.71,148.22 121.65,148.28 121.65,148.98 121.78,149.11 123.87,149.11
N49563382 on BOTTOM (solid shape): 122.79,144.79 122.79,142.63 122.66,142.51 121.01,142.51 120.89,142.63 120.89,144.79 121.01,144.92 122.66,144.92
N49574226 on BOTTOM (solid shape): 149.08,144.79 149.08,142.76 148.95,142.63 147.3,142.63 147.18,142.76 147.18,144.79 147.3,144.92 148.95,144.92
N51290432 on TOP (solid shape): 164.26,153.64 164.26,152.73 163.2,151.68 161.4,151.68 161.25,151.83 161.25,152.6 161.39,152.74 162.52,152.74 162.96,153.19 162.96,153.61 163.17,153.81 164.09,153.81
N51302473 on TOP (solid shape): 157.25,155.52 157.67,155.52 157.74,155.45 157.74,154.99 157.92,154.81 159.23,154.81 159.3,154.74 159.3,154.13 159.24,154.06 158.05,154.06 157.79,153.81 156.74,153.81 156.45,154.1 156.45,155.31 156.66,155.52 157.25,155.52
N53085144 on TOP (solid shape): 205.53,15.57 205.53,13.41 205.49,13.37 204.74,13.37 204.71,13.41 204.71,15.51 204.83,15.63 205.47,15.63
N78936752 on BOTTOM (solid shape): 120.12,168.41 120.12,167.02 120,166.89 117.84,166.89 117.71,167.02 117.71,167.78 117.84,167.91 118.73,167.91 118.98,168.16 118.98,168.41 119.11,168.54 120,168.54
N78945927 on TOP (solid shape): 56.56,187.17 56.56,186.07 56.99,185.64 56.99,184.72 56.75,184.47 55.98,184.47 55.69,184.77 55.69,187.22 55.75,187.29 56.45,187.29
N78957298 on TOP (solid shape): 120.98,177.25 120.98,175.97 121.5,175.45 121.88,175.45 122.06,175.27 122.06,174.72 121.5,174.16 121.5,172.61 121.44,172.55 120.57,172.55 120.48,172.64 120.48,173.68 120.43,173.74 117.9,173.74 117.75,173.89 117.75,177.24 117.97,177.46 120.77,177.46
N78957298 on BOTTOM (solid shape): 122.22,177.29 122.22,175.23 121.15,174.15 119.27,174.15 118.89,174.54 118.89,177.3 119.03,177.44 122.07,177.44
