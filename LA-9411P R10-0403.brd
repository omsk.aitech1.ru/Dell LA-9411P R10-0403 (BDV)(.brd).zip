# Allegro board LA-9411P R10-0403.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
EDCB0_3: length 33.7
  TOP w0.102: UV7.C2 v2(211.51,166.1)
  IN4 w0.102: 213.72,165.42 213.56,165.42 213.29,165.68 211.61,165.68 211.51,165.79 v2(211.51,166.1)
  IN4 w0.127: v2(221.77,148.04) 221.8,148.07 221.8,150.22 220.07,151.95 220.07,152.64 218.69,154.03 218.69,155.8 218.36,156.13 218.36,163.64 218.21,163.79 217.65,163.79 217.52,163.92 217.52,165 217.39,165.13 217.03,165.13 216.9,165 216.9,163.92 216.77,163.79 216.37,163.79 216.24,163.92 216.24,164.97 216.11,165.1 215.66,165.1 215.45,164.89 214.59,164.89 214.46,165.02 214.46,165.29 214.33,165.42 213.72,165.42
  BOTTOM w0.102: UV1.V5 220.85,144.18 221.18,144.51 221.18,144.93 221.14,144.97 221.14,144.97 221.05,145.06 221.05,145.33 221.15,145.43 221.15,145.87 221.77,146.49 221.77,147.21
  BOTTOM w0.13: v2(221.77,148.04) 221.59,147.85 221.59,147.47 221.77,147.29 221.77,147.21
EDCB1_0: length 35.8
  BOTTOM w0.102: UV10.C2 222.65,165.7 222.78,165.82 222.78,166.01 222.65,166.13 222.35,166.13 222.1,166.39 222.1,167.09 222.01,167.18 220.7,167.18 220.47,166.95 ; UV1.AB5 223.92,144.12 223.92,144.28 224.02,144.39 224.18,144.39 224.51,144.06 224.94,144.06 225.15,144.27 225.15,144.52 224.94,144.74 224.87,144.74 224.55,145.07 224.55,145.32 224.57,145.35 224.57,145.68 225.33,146.44 225.33,147.21
  BOTTOM w0.13: 220.47,166.95 220.12,166.61 220.12,165.96 218.52,164.36 218.52,164.3 218.08,163.86 218.08,155.74 220.4,153.42 223.34,153.42 223.84,152.93 223.84,151.98 224.62,151.19 225.22,151.19 225.34,151.07 225.34,150.67 225.22,150.55 224.95,150.55 224.82,150.42 224.82,149.97 224.95,149.85 225.21,149.85 225.33,149.72 v1(225.33,149.25) 225.33,147.21
EDCB1_1: length 18.6
  TOP w0.102: 221.95,154.57 222.13,154.74 222.13,156.17 222.4,156.44 222.4,156.79 UV9.R13
  TOP w0.13: 221.95,154.57 220.88,153.5 220.88,151.23 v1(221.83,150.29) 222.31,149.81 222.53,149.81 223.03,150.32 223.21,150.32 223.45,150.07 223.45,149.89 222.97,149.41 222.97,149.22 223.19,148.99 223.39,148.99 223.88,149.48 224.05,149.48 227.54,145.99 227.93,145.99 v2(228.32,145.6)
  BOTTOM w0.102: UV1.AH1 v2(228.32,145.6)
EDCB1_2: length 36.2
  TOP w0.102: v2(232.51,166.1) UV9.C2
  IN4 w0.102: v2(230.26,141.18) 230.91,141.18 232.1,139.99 234.65,139.99 236.53,141.88 236.53,143.15 236.74,143.35 236.74,147.21 ; v2(232.51,166.1) 232.89,166.48 233.47,166.48 233.7,166.24 233.7,165.97 233.97,165.7 234.34,165.7 235.06,164.97
  IN4 w0.127: 235.06,164.97 236.1,163.93 236.1,155.65 236.74,155.02 236.74,147.21
  BOTTOM w0.102: UV1.AJ9 229.87,140.8 v2(230.26,141.18)
EDCB1_3: length 14.1
  IN1 w0.102: 233.17,147.21 233.17,146.91 232.35,146.1 v2(232.35,144.41) ; 232.96,154.57 232.16,155.37 232.16,156.15 v2(232.51,156.49)
  IN1 w0.127: 232.96,154.57 233.14,154.39 233.14,147.23 233.17,147.21
  BOTTOM w0.102: UV1.AM5 232.05,144.1 v2(232.35,144.41) ; v2(232.51,156.49) UV10.R13
EDID_SELECT#: length 10.9
  TOP w0.102: v2(270.9,42.19) 271.39,42.19 T121.1 ; v2(268.91,49.42) 268.47,48.99 268.47,48.53 268.69,48.31 U46.B61
  IN1 w0.102: v2(270.9,42.19) 270.7,42.19 270.27,42.61 270.27,43.77 269.85,44.2 269.85,46.72 269.67,46.9 269.67,49 269.24,49.42 v2(268.91,49.42)
EDP_COMP: length 3.3
  TOP w0.089: RC73.2 166.37,101.72 166.48,101.61 167.38,101.61 v2(167.71,101.94) v1(167.71,102.76)
  BOTTOM w0.089: JCPU1.E24 168.2,102.43 v2(167.71,101.94)
EDP_CPU_AUX: length 47.4
  TOP w0.089: 160.07,115.46 159.84,115.23 158.51,115.23 157.32,114.05 157.32,113.3 157.54,113.08 157.54,110.99 157.91,110.62 159.22,110.62 160.34,109.5 160.34,107.31 161.34,106.31 161.34,105.65 161,105.31 160.33,105.31 160.03,105.61 160.03,105.78 159.89,105.92 v2(159.73,105.92)
  TOP w0.102: 160.07,115.46 166.42,121.81 166.42,138.67 167.03,139.28 167.06,139.28 167.45,139.67 167.45,139.69 167.91,140.16 168.03,140.16 v2(168.35,139.84) 168.5,139.99 168.66,139.99 C104.2
  BOTTOM w0.089: v2(159.73,105.92) JCPU1.N27
  BOTTOM w0.102: v2(168.35,139.84) 168.52,140 168.65,140 C104.2
EDP_CPU_AUX#: length 47.5
  TOP w0.089: v2(160.73,105.92) 160.47,106.18 160.33,106.18 160.23,106.08 160.23,105.7 160.41,105.51 160.92,105.51 161.14,105.73 161.14,106.23 160.14,107.23 160.14,109.41 159.13,110.42 157.83,110.42 157.34,110.9 157.34,113 157.13,113.21 157.13,114.13 158.43,115.43 159.74,115.43 159.77,115.46
  TOP w0.102: C105.2 168.75,140.28 168.49,140.28 v2(168.35,140.42) 168.3,140.37 167.83,140.37 v4(167.09,139.64) 166.21,138.76 166.21,121.9 159.77,115.46
  BOTTOM w0.089: v2(160.73,105.92) JCPU1.M27
  BOTTOM w0.102: v2(168.35,140.42) 168.53,140.25 168.72,140.25 C105.2
EDP_CPU_AUX#_C: length 3.2
  TOP w0.102: U27.3 172.04,139.46 171.91,139.33 171.65,139.33 v4(171.22,139.76) 170.78,140.2 170.39,140.2 C105.1
EDP_CPU_AUX_C: length 3.2
  TOP w0.102: C104.1 170.39,139.99 170.69,139.99 170.85,139.83 170.85,139.79 171.35,139.29 171.39,139.29 171.56,139.12 171.9,139.12 171.96,139.06 U27.4
EDP_CPU_LANE_N0: length 31.4
  TOP w0.089: v2(158.7,113.97) 158.58,113.86 158.43,113.86 158.29,114 158.29,114.19 158.63,114.53 159.95,114.53 159.96,114.53 160.13,114.53 160.17,114.57 160.18,114.57 160.19,114.58
  TOP w0.102: C101.2 168.66,137.96 167.93,137.96 167.14,137.17 167.14,136.97 167.16,136.95 167.16,136.4 167.14,136.39 167.14,121.53 160.19,114.58
  BOTTOM w0.089: v2(158.7,113.97) 159.2,113.46 JCPU1.P35
EDP_CPU_LANE_N0_C: length 3
  TOP w0.102: U27.8 172.16,137.46 172.07,137.56 171.83,137.56 171.49,137.9 171.36,137.9 171.33,137.87 170.7,137.87 170.67,137.9 170.33,137.9 C101.1
EDP_CPU_LANE_N1: length 31.3
  TOP w0.089: 162.53,114.38 162.06,113.91 160.83,113.91 160.33,113.41 160.33,113.32 v2(160.73,112.92)
  TOP w0.102: C118.2 169.13,135.58 169.13,135.83 168.92,136.04 168.12,136.04 167.84,135.76 167.84,133.91 167.94,133.81 168.76,133.81 168.97,133.61 168.97,133.13 168.73,132.88 167.94,132.88 167.84,132.78 167.84,121.2 162.53,115.9 162.53,115.8 162.55,115.78 162.55,115.23 162.53,115.21 162.53,114.38
  BOTTOM w0.089: v2(160.73,112.92) 160.26,112.45 JCPU1.N34
EDP_CPU_LANE_N1_C: length 3.2
  TOP w0.102: C118.1 170.41,135.95 170.73,135.95 171,136.21 171.04,136.21 171.51,136.67 171.51,136.72 171.55,136.76 172.07,136.76 172.17,136.66 U27.10
EDP_CPU_LANE_P0: length 31.4
  TOP w0.089: 160.04,114.73 158.55,114.73 v2(157.73,113.92)
  TOP w0.102: C100.2 169.07,138.56 168.68,138.17 167.84,138.17 166.93,137.26 v4(166.93,136.68) 166.93,121.62 160.04,114.73
  BOTTOM w0.089: v2(157.73,113.92) JCPU1.R35
EDP_CPU_LANE_P0_C: length 3
  TOP w0.102: C100.1 170.44,138.11 v4(170.99,138.11) 171.57,138.11 171.92,137.77 172.07,137.77 172.16,137.86 U27.7
EDP_CPU_LANE_P1: length 31.3
  TOP w0.089: 162.32,114.45 161.98,114.1 160.75,114.1 160.13,113.49 160.13,113.32 v2(159.73,112.92)
  TOP w0.102: C103.2 168.78,136.25 168.03,136.25 167.63,135.84 167.63,133.83 167.85,133.6 168.68,133.6 168.76,133.52 168.76,133.21 168.64,133.09 167.85,133.09 167.63,132.87 167.63,121.29 162.32,115.99 v4(162.32,115.51) 162.32,114.45
  BOTTOM w0.089: JCPU1.P34 159.67,112.92 v2(159.73,112.92)
EDP_CPU_LANE_P1_C: length 3.2
  TOP w0.102: U27.9 172.13,137.06 172.04,136.97 171.46,136.97 v4(171.1,136.61) 170.65,136.16 170.37,136.16 C103.1
EDP_HPD#: length 32.3
  TOP w0.089: 158.15,115.46 158.14,115.46 156.99,114.31 156.59,114.31 156.32,114.05 156.32,113.46 156.12,113.26 156.12,110.01 156.71,109.41 157.89,109.41 158.2,109.11 158.2,105.96 158.74,105.42 v2(158.74,104.92)
  TOP w0.102: QC3.1 RC74.1 165.34,124.04 165.68,123.7 v1(165.68,123.09) 165.68,122.1 159.37,115.79 158.49,115.79 158.15,115.46
  BOTTOM w0.089: JCPU1.P27 159.2,105.39 v2(158.74,104.92)
EMBCLK_REQ#: length 74.2
  TOP w0.089: 200.69,62.19 200.85,62.19 201.4,62.75 201.4,63.13 201.19,63.35 v2(201.16,63.35)
  TOP w0.102: 200.69,62.19 v1(200.45,62.19) 200.22,62.19 199.89,61.86 199.16,61.86 RPH9.1
  IN4 w0.089: v2(201.16,63.35) 201.32,63.19 201.32,62.34 200.93,61.96
  IN4 w0.102: v2(238.87,50.27) 238.76,50.38 226.55,50.38 225.46,49.29 219.1,49.29 217.37,47.56 210.87,47.56 210.52,47.22 209,47.22 208.82,47.4 206.45,47.4 203.61,50.24 200.71,50.24 197.46,53.49 197.46,54.71 197.23,54.94 197.23,56.31 199.52,58.6 199.52,60.55 200.93,61.96
  BOTTOM w0.089: 201.54,64.14 202.04,64.65 202.24,64.65 202.46,64.86 202.46,65.2 202.58,65.33 202.69,65.43 202.69,65.49 202.8,65.6 UH1.Y3
  BOTTOM w0.102: JSATA2.26 238.7,42.29 238.7,46.96 239.52,47.78 239.52,49.61 v2(238.87,50.27) ; 201.54,64.14 201.26,63.87 201.26,63.45 v2(201.16,63.35)
EN_1.5VSP: length 8.8
  TOP w0.102: v1(233.37,110.02) 232.76,109.41 232.76,107.89 232.27,107.39 PC406.1
  TOP w0.254: PU400.5 236.05,105.79 236.16,105.91 236.16,106.13 236.08,106.22 235.64,106.22 235.31,106.55 PR403.2 PR406.2 PR404.1 PC406.1
EN_1.8VSP: length 4.8
  TOP w0.102: v1(278.48,136.12) 278.52,136.08 PR688.2
  TOP w0.254: PR688.2 PR690.1 PC675.1 280.77,135.2 281.54,135.2 281.68,135.06 PU603.5
EN_+1.05VSP: length 6.5
  TOP w0.102: 240.1,4.91 239.66,4.47 239.66,2.88 v1(239.63,2.86)
  TOP w0.254: PU300.3 239.11,4.93 PC307.1 ; PC307.1 PR303.2 ; PC307.1 PR308.2
EN_DK_PWRBAR: length 8.5
  TOP w0.254: PR866.2 156.53,169.16 v4(156.4,169.03) PU800.17 ; PR874.1 157.6,171.16 v1(156.23,171.16) 155.6,171.16 v2(154.76,170.32)
  IN4 w0.254: v2(154.76,170.32) 155.1,170.32 v4(156.4,169.03)
EN_DOCK_PWR_BAR: length 243.7
  TOP w0.102: v2(265.12,54.99) 265.09,55.02 265.09,55.02 264.55,55.57 264.08,55.57 264.01,55.64 U46.B37
  TOP w0.254: v2(159.93,169.58) 159.93,169.07 v1(159.53,168.67) 159.05,168.67 PR866.1
  IN3 w0.127: v2(265.12,54.99) 264.22,55.89 264.12,55.89 263.63,56.38 263.63,58.61 263.44,58.8 263.44,59.41 262.66,60.19 262.66,62.3 266.12,65.75 266.12,71.95 267.39,73.22 267.39,75.2 267.72,75.54 267.72,81.23 268.5,82.01 268.5,86.94 269.63,88.07 269.63,94.78 268.59,95.81 268.59,99.38 268.11,99.87 268.11,101.76 268.65,102.31 268.65,105.07 268.53,105.19 268.53,125.05 267.93,125.65 267.93,127.86 268.17,128.1 268.17,138.78 267.64,139.31 267.64,140.96 266.43,142.16 266.43,143.67 264.23,145.87 264.23,149.96 263.3,150.89 263.3,173.86 263.11,174.05 263.11,175.81 262.47,176.45 261.89,176.45 259.09,179.26 251.99,179.26 251.42,179.83 248.02,179.83 247.56,180.29 237.73,180.29 234.98,177.55 233.11,177.55 225.87,177.55 225.61,177.55 225.17,177.99 221.54,177.99 219.88,176.33 219.88,176.33 217.92,174.37 200.3,174.37 199.96,174.71 196.42,174.71 196.38,174.68 193.5,174.68 192.94,174.12 188.25,174.12 187.41,173.28 185.49,173.28 184.83,173.94 183.26,173.94 182.98,174.22 179.71,174.22 179.54,174.05 178.38,174.05 177.92,174.52 177.01,174.52 176.45,173.96 176.11,173.96 176.11,173.97 169.36,173.97 166.4,171.01 166.4,170.65 165.33,169.58 v2(159.93,169.58)
EN_I2S_NB_CODEC#: length 207.6
  TOP w0.102: U74.48 338.48,175.37 338.34,175.51 337.63,175.51 337.42,175.31 336.76,175.31 336,176.07 336,177.37 335.44,177.93 v2(334.64,177.93) ; U46.B36 263.97,56.14 v2(264.4,56.57)
  IN1 w0.102: v2(312.86,106.76) 312.9,106.79 312.9,110 311.34,111.56 311.34,136.05 312.37,137.08 312.93,137.08 317.79,141.95 317.79,142.91 322.7,147.83 322.7,157.4 322.12,157.98 322.12,162 322.84,162.72 322.84,166.28 322.35,166.78 322.35,169.74 321.91,170.18 321.91,170.57 322.08,170.74 323.29,170.74 323.74,171.19 325.81,171.19 326.58,170.42 328.8,170.42 329.18,170.04 330.89,170.04 332.72,168.21 333.92,168.21 334.37,168.67 334.37,171.21 v2(333.99,171.59)
  IN4 w0.102: v2(287.68,59.03) 287.68,60.47 280.02,68.13 280.02,90.83 288.12,98.93 305.04,98.93 v2(312.86,106.76) ; v2(333.99,171.59) 334.04,171.63 334.04,176.62 334.67,177.25 334.67,177.9 v2(334.64,177.93)
  BOTTOM w0.102: v2(264.4,56.57) 264.12,56.57 263.36,55.8 263.36,53.36 264,52.72 265.27,52.72 265.27,52.73 265.51,52.73 266.3,51.94 v1(269.1,51.94) 270.42,51.94 270.62,52.15 277.17,52.15 278.51,53.48 282.13,53.48 v2(287.68,59.03)
EN_INVPWR: length 250.6
  TOP w0.102: R882.2 286.94,121.16 v2(287.35,120.75) 286.91,120.31 286.91,119.94 287.22,119.64 U51.A25 ; v2(181.95,139.74) 181.47,140.22 v1(181.47,140.47)
  IN3 w0.127: v2(287.35,120.75) 286.23,119.63 284.96,119.63 282.49,122.1 281.99,122.1 280.59,123.49 280.59,125.75 278.01,128.33 278.01,134.14 277.78,134.37 277.78,144.9 275,147.68 275,148.09 274.05,149.05 274.05,151 274.49,151.45 274.49,152.34 272.7,154.13 272.7,163.66 274.52,165.48 274.52,169.21 274.62,169.32 274.62,170.11 274.66,170.15 274.66,172.53 275.2,173.08 275.2,175.28 273.37,177.11 273.37,178.54 268.36,183.56 268.36,186.16 267.44,187.08 262.15,187.08 259.96,189.27 257.77,189.27 257.16,188.66 253.21,188.66 252.4,189.47 248.98,189.47 247.49,187.99 242.2,187.99 241.46,188.72 239.98,188.72 239.36,189.34 220.97,189.34 220.95,189.32 220.3,189.32 216.81,185.83 213.06,185.83 211.27,187.62 207.21,187.62 207.01,187.82 206.83,187.82 205.84,188.81 201.72,188.81 200.58,187.67 200.58,187.05 198.56,185.03 193.74,185.03 192.45,183.74 190.98,183.74 190.03,184.68 187.58,184.68 185.79,182.89 182.94,182.89 182.67,182.63 182.05,182.63 181.01,183.67 178.81,183.67 178.52,183.96 172.88,183.96 171.33,182.41 170.87,182.41 170.04,181.57 169.32,181.57 166.65,178.89 v2(166.63,178.89)
  IN4 w0.102: v2(166.63,178.89) 166.87,178.65 169.1,178.65 170.19,179.74 172.08,179.74 172.97,178.85 172.97,177.43 176.37,174.03 176.59,174.03 177.02,173.6 177.02,170.66 178.19,169.49 178.19,168.55 179.75,166.99 179.75,165.61 179.38,165.24 179.38,160.03 179.79,159.63 179.79,157.56 179.43,157.2 179.43,149.76 181.25,147.94 181.78,147.94 182.55,147.18 182.55,140.49 181.95,139.89 v2(181.95,139.74)
  BOTTOM w0.102: Q22.2 181.1,141.09 181.95,140.24 v2(181.95,139.74)
EN_LCDPWR: length 14.4
  TOP w0.102: U104.3 170.54,165.77 v2(170.39,165.91) ; D73.1 D65.1 171.23,158.38 170.79,158.83 R517.2 170.46,158.89 169.59,158.89 v1(169.53,158.83) 169.27,158.57 v2(169.27,158.38)
  IN3 w0.127: v2(169.27,158.38) 169.79,158.9 169.79,161.24 171.04,162.49 171.04,165.68 170.81,165.91 v2(170.39,165.91)
EN_PCIE: length 5.1
  TOP w0.102: v1(201.15,90.75) 201.18,90.78 PC665.1
  TOP w0.254: PU602.5 198.87,91.86 199.14,91.59 199.61,91.59 199.91,91.88 PR682.1 PC665.1 PR681.2
ENVDD_PCH: length 214.3
  TOP w0.089: v2(216.46,71.88) 216.34,71.76 216.34,71.46 216.76,71.05 218.01,69.79 218.37,69.79 219.32,68.84 219.43,68.84
  TOP w0.102: v2(173.29,153.21) 173.17,153.21 172.58,153.81 U55.2 ; v2(264.23,54.98) 264.07,55.14 U46.B38 ; v2(226.77,56.4) 226.77,57.2 227.15,57.59 227.15,62.56 226.2,63.51 226.2,65.07 225.19,66.08 225.19,66.52 224.77,66.94 224.27,66.94 RH118.2 221.79,68.16 220.12,68.16 219.43,68.84
  IN2 w0.127: v2(264.23,54.98) 263.77,54.98 262.75,56.01 260.81,56.01 259.7,57.12 252.33,57.12 250.99,55.78 248.39,55.78 245.46,52.84 230.92,52.84 227.37,56.4 v2(226.77,56.4) ; v2(227.74,102.68) 227.37,102.3 227.37,101.71 226.13,100.47 226.13,98.69 v2(226.18,98.64) ; v2(185.52,149.66) 185.52,149.54 185.3,149.33 180.09,149.33 178.24,151.18 175.32,151.18 v2(173.29,153.21)
  IN3 w0.089: v2(216.46,71.88) 216.46,71.88 217.01,71.88 217.44,71.45 217.44,71.28 218.45,70.28 220.87,70.28
  IN3 w0.127: 220.87,70.28 224.36,70.28 226.18,72.1 226.18,75.35 v2(226.04,75.49)
  IN4 w0.102: v2(227.74,102.68) 227.74,103.77 227.03,104.49 221.33,104.49 220.04,105.78 218.38,105.78 217.93,106.24 205.96,106.24 200.46,111.74 194.92,111.74 192.58,114.08 186.28,114.08 185.53,114.83 185.53,149.61 185.52,149.62 v2(185.52,149.66)
  BOTTOM w0.089: v2(216.46,71.88) 216.35,71.77 UH1.G36
  BOTTOM w0.102: v2(226.18,98.64) 225.67,99.15 225.27,99.15 225.03,98.91 225.03,98.36 225.34,98.04 225.34,92.49 229.12,88.72 230.02,88.72 231.35,87.39 231.35,85.86 226.04,80.55 v1(226.04,79.79) v2(226.04,75.49)
ERC1: length 6.6
  TOP w0.102: v1(149.22,158.69) 149.86,159.32 149.86,161.12 150.48,161.74 PC815.1
  TOP w0.254: PU800.3 150.75,164.16 150.68,164.09 150.68,162.33 PC815.1
ERC2: length 3.9
  TOP w0.254: PC817.1 157.39,165.44 v1(156.17,166.66) 155.91,166.92 155.39,166.92 155.28,167.03 PU800.13
ERC3: length 5.6
  TOP w0.102: v1(157.93,162.94) 157.65,163.22 PC816.1
  TOP w0.254: PU800.12 155.64,166.53 156.34,165.82 156.41,165.82 157.65,164.58 PC816.1
ESATA_USB_PWR_EN#: length 260.3
  TOP w0.102: v2(258.62,54.8) 258.77,54.8 259,55.03 259.79,55.03 R769.2 ; v2(348.51,213.94) 348.45,214 U91.4 ; v2(334.11,177.46) 333.19,176.54 321.14,176.54 319.73,175.13 v2(319.73,175.02) ; v2(264.25,52.08) 264.2,52.14 U46.B44 ; U93.4 347.88,199.47 347.43,199.92 347.43,199.94 v2(346.44,200.93)
  IN1 w0.102: v2(285.11,142.32) 285.8,141.63 287.11,141.63 287.89,140.84 303.67,140.84 304.19,141.36 305.46,141.36 v2(305.98,140.85) ; v2(348.51,213.94) 348.51,212.17 346.1,209.75 346.1,205.45 346.44,205.1 v2(346.44,200.93) 345.64,200.13 345.64,197.77 343.06,195.2 340.55,195.2 337.19,191.84 337.19,188.21 336.43,187.46 336.43,181.9 334.11,179.57 v2(334.11,177.46)
  IN2 w0.127: v2(264.25,52.08) 264.25,52.35 263.66,52.95 262.5,52.95 262.15,53.31 261.86,53.31 261.85,53.31 260.47,53.31 259.74,54.05 259.37,54.05 v2(258.62,54.8) ; v2(275.04,141.92) 276.09,141.92 277.12,142.95 284.48,142.95 v2(285.11,142.32) ; v2(319.73,175.02) 321.17,173.58 321.17,172.08 320.15,171.06 320.15,168.69 322.31,166.53 322.31,166.1 324.21,164.19 324.21,159.5 323.51,158.8 323.28,158.8 323.03,158.56 323.03,155.7 316.58,149.25 316.58,145.92 311.3,140.64 310.3,140.64 310.19,140.75 308.37,140.75 308.25,140.64 306.18,140.64 v2(305.98,140.85)
  BOTTOM w0.102: v2(275.04,141.92) 275,141.92 274,142.93 273.44,142.93 273.24,142.72 273.24,137.49 274.44,136.29 274.44,130.5 273.58,129.64 273.15,129.64 272.83,129.32 272.83,127.34 272.55,127.06 272.55,126.61 264.73,118.78 264.73,113.86 258.89,108.01 258.89,101.84 v1(258.1,101.05) 257.58,100.53 257.58,81.53 258.12,80.98 258.12,79.52 259.11,78.53 259.11,76.17 261.1,74.19 261.1,62.67 260.55,62.12 260.55,58.48 260.32,58.24 260.32,56.69 261.09,55.92 262.47,55.92 262.9,55.49 262.9,53.14 263.9,52.14 264.2,52.14 v2(264.25,52.08)
EXPCLK_REQ#: length 146
  TOP w0.089: v2(201.66,63.69) 201.45,63.89 v1(199.94,63.89) 198.99,63.89
  TOP w0.102: v2(280.41,21.72) 276.17,21.72 270.59,27.29 257.13,27.29 256.61,26.77 v2(253.26,26.77) ; 197.47,62.29 197.75,62.57 197.75,62.67 198.97,63.89 198.99,63.89 ; JEXP1.27 v2(286.85,34.06)
  IN1 w0.102: v2(280.41,21.72) 280.41,26.75 282.71,29.04 282.71,29.77 286.85,33.91 v2(286.85,34.06)
  IN2 w0.089: 200.46,62.43 200.97,62.43 201.66,63.12 v2(201.66,63.69)
  IN2 w0.127: 200.46,62.43 200.36,62.43 199.73,61.8 199.73,61.51 199.09,60.87 199.09,58.85 197.19,56.95 195.47,56.95 v2(194.14,55.61)
  IN4 w0.102: v2(253.26,26.77) 252.57,26.08 250.76,26.08 249.3,24.62 243.59,24.62 242.96,25.25 241.97,25.25 240.57,23.85 234.56,23.85 231.37,27.04 217.28,27.04 213.85,30.47 213.85,34.7 201.62,46.93 199.08,46.93 194.71,51.3 194.71,52.3 194.18,52.83 194.18,55.57 v2(194.14,55.61)
  BOTTOM w0.089: v2(201.66,63.69) 201.89,63.92 201.89,64.04 202.61,64.76 202.91,64.76 203.23,65.08 UH1.V3
EXPRCRD_CPPE#: length 15.9
  TOP w0.102: U41.10 273.4,33.77 273.96,33.21 273.96,32.7 274.1,32.56 278.01,32.56 278.48,33.03 v1(278.48,35.42) 278.96,35.9 280.27,35.9 CE11.1 280.97,35.2 282.67,35.2 283.82,34.06 JEXP1.28
EXPRCRD_STBY_R#: length 3.9
  TOP w0.102: U41.1 270.06,36.95 269.32,37.69 v1(269.32,37.76) 269.3,37.78 R734.2 268.28,37.83 R717.2
EXT_MIC:
  vias: v1(356.92,169.63)
FAN1_PWM: length 330.9
  TOP w0.102: v2(116.57,87.9) v1(116.57,88.51) ; v2(287.35,120.12) 287.72,119.75 U51.A24
  IN2 w0.127: v2(116.57,87.9) 117.08,87.39 118.73,87.39 119.74,86.37 119.74,81.79 120.51,81.03 120.51,66.76 128.45,58.81 179.47,58.81 v2(180.98,60.32)
  IN3 w0.127: v2(278.34,96.7) 278.15,96.7 277.73,96.28 277.73,66.21 282.63,61.31 282.63,49.3 273.79,40.46 273.27,40.46 271.27,38.46 267.94,38.46 265.75,36.27 265.75,30.2 251.97,16.42 224.93,16.42 221.6,19.75 218.58,19.75 213.12,25.2 213.12,26.66 213.71,27.25 213.71,28.13 209.98,31.86 206.64,31.86 204.42,34.08 195.45,34.08 193.63,35.89 193.63,43.01 180.55,56.09 180.55,59.89 v2(180.98,60.32)
  BOTTOM w0.102: v2(116.57,87.9) 116.75,88.07 R38.2 115.83,88.79 115.32,89.29 113.39,89.29 112.99,89.7 112.99,91.52 112.5,92 JFAN1.3 ; v2(278.34,96.7) 278.76,97.12 278.76,97.56 278.49,97.83 278.32,97.83 277.85,98.3 277.85,99.66 278.56,100.37 280.81,100.37 281.33,100.89 281.65,100.89 283.19,102.43 283.19,102.81 281.45,104.55 281.45,105.33 281.9,105.78 283.29,105.78 283.85,106.34 284.28,106.34 284.64,106.69 285.66,106.69 286,107.04 286,109.6 286.04,109.64 286.04,111.43 286.41,111.8 286.41,114.26 283.93,116.74 283.93,118.21 284.2,118.48 285.71,118.48 v2(287.35,120.12)
FAN1_TACH_FB: length 266.1
  TOP w0.102: v2(119.86,88.54) 118.59,89.81 v2(114.09,89.81) ; v1(253.22,113.3) 253.17,113.25 v2(252.51,113.25) ; v2(289.71,117.23) 289.28,117.67 289.28,118.12 289.47,118.31 U51.B22
  IN1 w0.102: v2(184.26,100.22) 184.26,100.19 184.93,99.52 184.93,90.65 187.26,88.33 187.26,79.79 187.08,79.61 187.08,78.59 186.48,77.99 v2(186.42,77.99)
  IN2 w0.127: v2(119.86,88.54) 120.02,88.38 120.02,81.87 120.76,81.13 120.76,67.88 128.79,59.85 175.62,59.85 185.12,69.36 185.12,76.7 v2(186.42,77.99) ; v2(289.71,117.23) 288.96,116.48 287.22,116.48 285.15,114.41 282.16,114.41 281.54,115.04 280.09,115.04 279.65,114.6 277.08,114.6 277.07,114.62 274.42,114.62 274.24,114.44 259.32,114.44 258.12,113.25 v2(252.51,113.25)
  IN3 w0.127: v2(252.51,113.25) 252.56,113.19 252.56,112.55 252.07,112.05 251.38,112.05 250.91,111.58 250.91,108.42 246.91,104.42 246.91,103.34 237.63,94.06 222.68,94.06 219.65,97.08 217.5,97.08 213.23,101.35 207.2,101.35 206.51,100.66 203.56,100.66 202.51,101.7 200.13,101.7 199.88,101.96 194.61,101.96 193.95,102.62 189.45,102.62 188.08,101.24 184.65,101.24 184.26,100.85 v2(184.26,100.22)
  BOTTOM w0.102: JFAN1.2 112.54,93.19 113.65,92.08 113.65,90.26 v2(114.09,89.81) 114.11,89.8 R30.2
FB: length 9.6
  TOP w0.254: v2(117.19,156.41) 117.19,157.63 v1(116.82,158) PR537.2 PC523.1
  BOTTOM w0.203: v2(117.19,156.41) 117.67,156.41 117.86,156.23 PU500.8
  BOTTOM w0.254: v2(117.19,156.41) 117.19,156.54 117.12,156.62 117.12,157.07 116.19,158 PR537.2 PC523.1 PR533.2
FB2/VSEN: length 5.4
  TOP w0.254: v4(118.28,157.64) 118.28,157 PC517.1 PR529.2
  BOTTOM w0.203: PR531.2 117.2,158.72 v1(117.54,158.39) v4(118.28,157.64) 118.49,157.64 118.85,157.28 PU500.9
FB_+1.05VSP: length 4.2
  TOP w0.254: PU300.4 239.61,6.3 v1(240.09,5.82) 240.73,5.82 241.16,5.39 PR307.2 241.17,4.9 PR306.2
FB_PCIE: length 5
  TOP w0.102: v1(200.77,95.64) PR683.2
  TOP w0.254: PU602.6 198.87,96.83 PR684.1 PC668.2 PR683.2
FC_G6: length 21.5
  TOP w0.089: v2(172.7,94.91) 173.21,94.4 173.59,94.4
  TOP w0.102: 173.59,94.4 174.48,94.4 174.79,94.09 RC69.2 RC68.1 173.96,92.8 v1(173.77,92.61)
  IN2 w0.089: v2(172.7,94.91) 172.25,94.45 168.56,94.45 168.21,94.09 168.21,85.74 167.9,85.43 166.25,85.43 v2(165.73,84.92)
  BOTTOM w0.089: JCPU1.G6 v2(165.73,84.92)
FDI_CSYNC: length 65.6
  TOP w0.102: v2(176.34,106.27) v1(176.34,108.13) RC2.2
  IN2 w0.089: v2(209.87,79.73) 209.87,80.55 210.47,81.15 210.47,82.91 209.62,83.76 209.62,86.7
  IN2 w0.127: 209.62,86.7 208.82,87.5 208.82,91.32 210.96,93.45 210.96,95.12 207.75,98.32 201.89,98.32 200.95,99.26 194.43,99.26 192.72,100.98 185.19,100.98 184.74,100.53 184.74,100 184.21,99.47 177.2,99.47 175.54,101.14 175.54,105.47 v2(176.34,106.27)
  BOTTOM w0.089: UH1.AL39 210.21,79.73 v2(209.87,79.73)
FDI_CSYNC_R: length 10.9
  TOP w0.089: 173.47,108.52 v1(172.32,108.52) 166.33,108.52 v2(165.73,107.92)
  TOP w0.102: RC2.1 174.84,108.52 173.47,108.52
  BOTTOM w0.089: v2(165.73,107.92) 165.26,107.45 JCPU1.H29
FDI_CTX_PRX_N0: length 76.3
  IN4 w0.089: 173.56,103.97 173.01,104.52 166.84,104.52 166.83,104.53 160.54,104.53 160.36,104.71 160.36,107.66 160.33,107.68 160.33,109.05 159.75,109.64 159.75,110.36 159.43,110.68 159.43,111.04 159.18,111.3 159.18,111.53 159.55,111.9 v2(159.61,111.9) ; 200.56,80.44 200.98,80.02 201.37,80.02 202.93,78.46 202.93,77.94 203.35,77.52 203.35,76.94 205.51,74.78 206.62,74.78 207.31,75.46 207.31,76.31 208.25,77.25 209.38,77.25 209.64,77.52 209.64,77.55 209.98,77.89 209.98,78.07 209.89,78.16 209.68,78.16 v2(209.64,78.12)
  IN4 w0.114: 200.56,80.44 199.88,81.12 199.88,82.6 197.58,84.9 197.58,85.71 196.36,86.93 189.47,86.93 176.61,99.78 176.61,100.92 173.56,103.97
  BOTTOM w0.089: UH1.AJ35 209.81,77.95 v2(209.64,78.12) ; v2(159.61,111.9) 159.32,111.9 159.2,111.79 JCPU1.P33
FDI_CTX_PRX_N1: length 71.3
  IN4 w0.089: 201.18,81.07 204.32,77.93 205.08,77.93 205.18,78.03 205.68,78.03 206.83,76.88 207.28,76.88 208.26,77.85 208.58,77.85 208.89,78.16 208.89,78.29 208.75,78.42 208.57,78.42 v2(208.49,78.35) ; v2(160.56,109.92) 160.66,110.02 160.66,110.53 160.56,110.63 160.24,110.63 160.16,110.54 160.16,109.79 160.94,109 160.94,108.53 161.34,108.14 161.34,105.69 161.51,105.51 166.78,105.51 166.79,105.52 172.94,105.52 173.59,104.86
  IN4 w0.114: 201.18,81.07 200.67,81.58 200.67,83.11 198.75,85.03 198.75,86.7 197.86,87.59 189.73,87.59 177.26,100.06 177.26,101.19 173.59,104.86
  BOTTOM w0.089: v2(208.49,78.35) 208.56,78.29 UH1.AL35 ; JCPU1.N32 160.2,110.14 160.42,109.92 v2(160.56,109.92)
FDI_CTX_PRX_P0: length 76.4
  IN4 w0.089: v2(158.82,111.01) 159.18,111.01 159.23,110.96 159.23,110.6 159.55,110.28 159.55,109.55 160.13,108.97 160.13,107.6 160.16,107.57 160.16,104.63 160.45,104.33 166.75,104.33 166.76,104.32 172.89,104.32 173.4,103.81 ; 200.4,80.28 200.4,80.27 200.42,80.27 200.42,80.28 200.47,80.23 200.49,80.23 200.89,79.82 201.28,79.82 202.73,78.38 202.73,77.86 203.14,77.44 203.14,76.85 205.42,74.57 206.71,74.57 207.51,75.38 207.51,76.23 208.33,77.05 209.48,77.05 209.89,77.46 209.89,77.51 210.18,77.8 210.18,78.19 210.1,78.27 v2(210.1,78.58)
  IN4 w0.114: 200.4,80.28 199.65,81.03 199.65,82.51 197.35,84.8 197.35,85.61 196.26,86.7 189.37,86.7 176.39,99.69 176.39,100.82 173.4,103.81
  BOTTOM w0.089: v2(210.1,78.58) 210.23,78.45 UH1.AJ36 ; JCPU1.R33 158.21,111.45 158.65,111.01 v2(158.82,111.01)
FDI_CTX_PRX_P1: length 71.3
  IN4 w0.089: 173.36,104.77 172.82,105.32 166.87,105.32 166.86,105.31 161.43,105.31 161.13,105.6 161.13,108.06 160.74,108.45 160.74,108.92 159.95,109.71 159.95,110.85 159.85,110.95 v2(159.81,110.95) ; v2(208.91,78.76) 208.91,78.55 209.09,78.37 209.09,78.08 208.66,77.65 208.34,77.65 207.37,76.67 206.75,76.67 205.6,77.83 205.26,77.83 205.16,77.72 204.24,77.72 201.11,80.85 201.09,80.85 201.04,80.9 201.03,80.9 201.02,80.91
  IN4 w0.114: 201.02,80.91 200.44,81.48 200.44,83.02 198.52,84.94 198.52,86.61 197.77,87.36 189.63,87.36 177.03,99.96 177.03,101.1 173.36,104.77
  BOTTOM w0.089: v2(208.91,78.76) 208.94,78.73 209.52,78.73 UH1.AL36 ; JCPU1.P32 159.31,110.45 v2(159.81,110.95)
FDI_INT: length 65.3
  TOP w0.102: v2(176.88,105.96) 177.1,106.17 RC3.2
  IN2 w0.089: v2(210.29,80.15) 210.27,80.15 210.27,80.17 210.32,80.22 210.32,80.71 210.68,81.06 210.68,83.17 209.98,83.87 209.98,86.63 210.01,86.66
  IN2 w0.127: 210.01,86.66 210.04,86.69 210.04,91.82 211.46,93.24 211.46,95.33 207.96,98.83 202.1,98.83 201.13,99.8 194.65,99.8 192.88,101.56 182.8,101.56 181.21,99.97 177.41,99.97 176.04,101.35 176.04,105.12 v2(176.88,105.96)
  BOTTOM w0.089: UH1.AL40 210.46,79.97 210.28,80.15 v2(210.29,80.15)
FDI_INT_R: length 14.3
  TOP w0.089: v2(164.73,107.92) 164.36,108.29 164.36,109.08 164.8,109.52 173.59,109.52
  TOP w0.102: RC3.1 175.42,110.12 174.82,109.52 v1(174.15,109.52) 173.59,109.52
  BOTTOM w0.089: v2(164.73,107.92) 164.26,107.45 JCPU1.J29
FDI_IREF: length 9.1
  BOTTOM w0.254: RH96.2 208,90.61 208,89.94 208.59,89.34 208.59,89.14 v1(208.9,88.83) 210.46,87.27 210.46,85.25 210.76,84.95 210.76,82.82 UH1.AT45
FDI_RCOMP: length 9.1
  BOTTOM w0.254: RH99.2 208.96,89.85 208.96,89.52 209.67,88.81 209.67,88.54 210.87,87.35 210.87,85.41 211.18,85.09 v1(211.18,84.42) 211.18,82.66 UH1.AR44
FFS_INT2: length 180.8
  IN3 w0.089: v2(197.25,68.21) 197.48,67.98 197.77,67.98 198.26,68.47 198.26,69.09 195.62,71.72
  IN3 w0.127: v2(127.21,4.09) 128.2,5.08 128.2,7.12 128.94,7.85 128.94,10.75 131.96,13.77 145.07,13.77 145.3,13.54 156.02,13.54 156.82,14.34 162.6,14.34 162.68,14.43 181.04,14.43 185.34,18.72 185.34,21.45 188.12,24.23 190.49,24.23 191.28,25.02 191.28,27.14 190.97,27.46 190.97,34.18 192.82,36.04 192.82,42.62 177.54,57.9 177.54,69.94 v2(181.33,73.72) ; v2(186.38,79.24) 186.53,79.24 188.08,80.78 189.8,80.78 195.07,75.51 195.07,72.28 195.62,71.72
  IN4 w0.102: v2(186.38,79.24) 186.28,79.13 185.91,79.13 181.33,74.55 v2(181.33,73.72)
  BOTTOM w0.089: v2(197.25,68.21) 197.42,68.05 197.98,68.05 198.15,68.21 198.15,68.34 198.57,68.76 198.9,68.76 198.99,68.85 198.99,68.89 199.04,68.94 199.04,69.38 UH1.AN4
  BOTTOM w0.254: 124.2,6.81 124.2,4.7 124.81,4.09 v1(125.14,4.09) v2(127.21,4.09) ; 124.2,6.81 124.81,7.42 124.81,8.13 123.97,8.97 121.18,8.97 120.67,8.46 120.21,8.46 119.98,8.69 U88.9 ; 124.2,6.81 Q29.2
FFS_INT2_Q: length 48
  TOP w0.102: R506.2 v2(110.47,36.46)
  IN3 w0.127: v2(117.53,3.75) 116.85,3.75 114.7,5.89 114.7,11.03 115.59,11.92 115.59,31.34 v2(110.47,36.46)
  BOTTOM w0.102: v2(110.47,36.46) 112.21,36.46 JSATA1.18
  BOTTOM w0.254: v2(117.53,3.75) v1(120.06,3.75) 122.92,3.75 123.35,4.18 Q29.3
FFS_PCH_INT: length 26.1
  TOP w0.089: v2(208.49,66.58) 208.15,66.24 v1(207.79,66.24)
  TOP w0.102: RH106.2 196.78,56.74 197.86,56.74 198.46,56.15 198.74,56.15 201.43,53.45 201.76,53.45 v2(202.32,52.9)
  IN1 w0.089: v2(208.49,66.58) 207.91,66 207.35,66 205.21,63.87 205.21,61.35 204.53,60.67 204.53,60.64
  IN1 w0.102: 204.53,60.64 204.4,60.52 204.4,59.62 205.2,58.83 205.2,58.08 204.08,56.96 203.5,56.96 203.25,56.71 203.25,53.91 202.4,53.06 202.4,52.97 v2(202.32,52.9)
  BOTTOM w0.089: v2(208.49,66.58) 208.7,66.79 UH1.M15
FWP#: length 24.5
  TOP w0.102: U51.B65 289.97,109.53 289.54,109.96 289.54,110.42 289.67,110.55 290.64,110.55 290.84,110.75 v2(290.86,110.75) ; R879.2 290.79,100.83 v2(290.98,100.83) 291.07,100.91 291.63,100.91 R872.2
  BOTTOM w0.102: v2(290.86,110.75) 291.25,111.14 291.63,111.14 293.35,109.41 294.57,109.41 296.02,107.96 296.91,107.96 297.47,107.4 297.47,106.82 297.04,106.39 295.44,106.39 293.23,104.18 v1(293.23,103.14) 293.23,100.9 292.72,100.39 291.41,100.39 v2(290.98,100.83)
GENLK_CLK: length 15.6
  IN2 w0.102: 237.85,123.91 237.84,123.9 233.98,123.9 233.71,123.63 230.01,123.63 229.27,122.9 228.8,122.9 228.27,122.36 227.55,122.36 226.61,123.3 v2(226.61,123.52)
  IN2 w0.127: v2(238.95,124.35) 238.7,124.1 238.04,124.1 237.85,123.91
  BOTTOM w0.102: v2(226.61,123.52) 226.61,123.58 226.05,124.15 UV1.AD29 ; v2(238.95,124.35) RV95.2
GENLK_VSYNC: length 1.7
  TOP w0.102: v2(225.45,124.52) 224.93,125.04 RV96.2
  BOTTOM w0.102: v2(225.45,124.52) 225.33,124.4 UV1.AC29
GFX_CLK_REQ#: length 317.4
  TOP w0.102: v2(184.46,63.51) 185.02,62.95 185.02,62.28 v1(186.11,61.19) 189.82,57.48 192.45,57.48 192.98,58.01 192.98,58.83 193.26,59.11 193.77,59.11 QH3.1 194.93,60.26 195.45,60.26 RH128.1
  IN2 w0.089: 198.09,67.08 199.66,68.65 200.28,68.65 200.44,68.81 201.43,68.81 v2(201.59,68.65)
  IN2 w0.127: 198.09,67.08 195.93,64.92 194.15,64.92 193.02,66.05 191.27,66.05 191.01,65.79 189.93,65.79 187.27,63.13 186.46,63.13 186.02,63.58 184.53,63.58 v2(184.46,63.51) ; v2(244.37,140.86) 244.46,140.77 249.68,140.77 251.51,142.6 251.51,144.74 252.36,145.59 252.76,145.59 254.46,143.89 255.55,143.89 256.17,143.27 260.72,143.27 263.06,145.61 273.48,145.61 v2(273.52,145.64)
  IN4 w0.102: v2(273.52,145.64) 272.36,144.49 272.36,141.26 272.09,141 272.09,138.48 271.1,137.49 271.1,131.38 271.43,131.05 271.43,129.97 272.3,129.11 272.3,112.38 271.75,111.83 271.75,100.48 270.99,99.72 270.99,98.97 268.17,96.15 268.17,95.86 267.9,95.59 267.9,95.59 267.53,95.22 267.53,94.82 267.53,93.82 266.15,92.44 266.15,88 265.98,87.84 265.98,84.53 265.85,84.39 265.85,74.83 265.65,74.64 265.65,73.14 266.09,72.71 266.09,65.19 268.68,62.6 268.68,62.3 270.39,60.58 270.39,59.92 270.85,59.46 270.85,55.49 270.76,55.4 270.76,50.74 271.09,50.41 272.31,50.41 272.55,50.16 272.55,48.6 271.64,47.69 271.64,47.02 271.05,46.43 271.05,44.56 270.3,43.81 270.3,42.34 268.65,40.69 268.65,37.15 268.47,36.97 268.47,34.99 268.65,34.81 268.65,32.03 267.57,30.95 267.57,28.07 266.02,26.52 264.7,26.52 256.11,17.93 232.15,17.93 230.85,19.23 223.2,19.23 221.8,17.83 215.2,17.83 192.86,40.17 192.86,43.47 185.02,51.31 185.02,59.05 186.11,60.14 186.11,61.9 185.03,62.97 185.03,63.18 184.71,63.51 v2(184.46,63.51)
  BOTTOM w0.089: v2(201.59,68.65) 201.76,68.48 UH1.AF6
  BOTTOM w0.102: RV52.1 v2(244.37,140.86)
GFX_CLK_REQ#_R: length 19.1
  IN2 w0.102: v2(233.55,137.21) 233.76,137.21 234.48,136.48 237.85,136.48
  IN2 w0.127: v2(244.79,136.08) 243.25,136.08 242.77,136.56 237.94,136.56 237.85,136.48
  BOTTOM w0.102: v2(233.55,137.21) 233.05,137.71 UV1.AN13 ; v2(244.79,136.08) 244.99,136.28 v1(244.99,138.87) 244.99,139.86 244.5,140.36 243.2,140.36 242.73,140.83 RV52.2
GFX_MEM_VTT_EN: length 8.9
  TOP w0.102: RV85.1 RV80.1 186.5,104.28 v1(185.4,104.28) QV2.1 183.64,104.28 183.5,104.42 183.5,105.04 183.73,105.27 185.57,105.27 185.87,105.57 185.87,106.16 186.55,106.83 RV67.2
GFX_MEM_VTT_ON: length 6.8
  TOP w0.102: U46.A2 274.04,49.39 274.85,48.57 276.14,48.57 R1583.2 276.9,48.34 277.72,48.34 277.9,48.51 278.75,48.51 T137.1
GPIO_PSID_SELECT: length 266.8
  TOP w0.102: v2(158.1,180.48) v1(157.59,180.99) ; v2(275.59,51.59) 275.2,51.2 274.23,51.2 274.05,51.39 U46.A6
  IN1 w0.102: v2(188.93,179.55) 188.93,179.43 189.64,178.71 189.64,178.02 191.37,176.29 v2(192.02,176.29)
  IN3 w0.127: v2(275.59,51.59) 275.59,51.62 275.06,52.15 274.45,52.15 273.94,52.66 273.94,57.38 275,58.44 275,59.74 277.02,61.76 277.02,63.96 276.46,64.52 276.46,93.37 275.23,94.6 275.23,102.4 272.25,105.38 272.25,125.26 272.04,125.46 272.04,129.08 271.36,129.77 271.36,135.69 271.59,135.92 271.59,137.09 272.21,137.72 272.21,142.55 271.89,142.87 271.77,142.87 267.91,146.73 267.91,149.89 268.54,150.51 268.54,165.38 267.52,166.39 267.52,172.92 268.6,174 268.83,174 269.29,174.46 269.29,175.29 268.56,176.01 268.24,176.01 267.64,176.61 267.64,177.83 262.53,182.94 251.94,182.94 251.11,182.11 249.12,182.11 248.07,183.16 235.73,183.16 232.46,179.88 227.02,179.88 226.58,180.33 220.64,180.33 217.6,177.28 217.3,176.98 212.83,176.98 212.58,176.73 205.19,176.73 204.47,177.44 202.23,177.44 202.15,177.52 198.04,177.52 197.78,177.25 195.83,177.25 195.67,177.41 194.75,177.41 194.6,177.25 192.85,177.25 192.02,176.43 v2(192.02,176.29)
  IN4 w0.102: v2(188.93,179.55) 187.5,180.99 182.23,180.99 180.73,179.49 179.39,179.49 178.25,180.63 178.21,180.63 177.97,180.87 167.69,180.87 167.08,180.26 166.09,180.26 165.67,179.84 161.86,179.84 161.22,180.48 v2(158.1,180.48)
  BOTTOM w0.254: PU1.6 153.24,176.3 153.69,176.76 153.69,177.28 156.89,180.48 v2(158.1,180.48)
GPIOE4: length 10.8
  TOP w0.102: U46.B45 264.07,51.64 264.09,51.65 264.49,51.65 264.9,51.24 v2(264.9,51.21) ; T136.1 258.5,50.24 v2(258.66,50.39)
  IN2 w0.127: v2(264.9,51.21) 265.43,50.69 265.43,50.09 265.15,49.82 264.81,49.82 264.64,49.99 264.12,49.99 264.03,50.08 259.61,50.08 259.29,50.39 v2(258.66,50.39)
GPU_7_BLON: length 3
  TOP w0.102: v1(230.6,132.92) 230.6,133.81 230.33,134.08 RV113.2 230.33,134.14 v2(230.98,134.79)
  BOTTOM w0.102: v2(230.98,134.79) 230.65,134.46 UV1.AK17
GPU_DAC_RESET: length 3.8
  TOP w0.102: v2(224.19,120.92) 224.19,120.18 224.9,119.47 RV69.1 224.66,119.21 v1(223.97,118.53)
  BOTTOM w0.102: UV1.AB34 224.25,120.86 v2(224.19,120.92)
GPU_GPIO1: length 1.5
  TOP w0.102: T123.1 229.2,133.24 v2(228.62,132.66)
  BOTTOM w0.102: v2(228.62,132.66) 229.05,133.09 UV1.AH18
GPU_GPIO2: length 2.1
  TOP w0.102: v2(234.43,135.51) 234.81,135.13 T124.1
  BOTTOM w0.102: UV1.AN16 233.18,135.53 234.41,135.53 v2(234.43,135.51)
GPU_GPIO6: length 21.3
  TOP w0.102: v2(245.41,136.79) 245.33,136.87 v1(244.89,136.87)
  IN2 w0.102: v2(230.22,133.49) 230.23,133.49 231.36,134.62 231.36,135.08 231.54,135.25 233.93,135.25 234.12,135.06 234.59,135.06 235.44,135.92 237.19,135.92 237.8,135.31 237.85,135.31
  IN2 w0.127: v2(245.41,136.79) 245.41,136.64 245.93,136.12 245.93,135.42 245.61,135.1 239.85,135.1 239.64,135.31 237.85,135.31
  BOTTOM w0.102: v2(230.22,133.49) 230.22,133.48 229.85,133.85 UV1.AJ17 ; RV64.2 v2(245.41,136.79)
GPU_GPIO10: length 18.1
  TOP w0.102: v1(246.13,135.8) 246.11,135.78 v2(245.42,135.78)
  IN2 w0.102: 237.85,135.58 237.31,136.13 233.96,136.13 233.36,135.53 230.95,135.53 v2(230.32,134.91)
  IN2 w0.127: 237.85,135.58 237.87,135.57 239.81,135.57 239.96,135.42 245.07,135.42 v2(245.42,135.78)
  BOTTOM w0.102: UV1.AJ16 229.85,135.38 v2(230.32,134.91) ; RV40.2 v2(245.42,135.78)
GPU_GPIO11: length 2.2
  TOP w0.102: v2(231.81,134.74) 232.27,134.29 T125.1
  BOTTOM w0.102: v2(231.81,134.74) 231.56,134.74 230.91,135.4 UV1.AK16
GPU_GPIO12: length 3.8
  TOP w0.102: v2(232.61,134.77) 233.22,134.16 RV2.2 233.67,134.03 v1(234.34,133.36)
  BOTTOM w0.102: v2(232.61,134.77) 232.34,134.77 231.71,135.4 UV1.AL16
GPU_GPIO13: length 2.1
  TOP w0.102: T127.1 233.45,135.31 v2(233.45,134.77)
  BOTTOM w0.102: v2(233.45,134.77) 233.15,134.77 232.52,135.4 UV1.AM16
GPU_GPIO14: length 1.8
  TOP w0.102: T128.1 231.38,135.19 v2(232.18,135.99)
  BOTTOM w0.102: v2(232.18,135.99) 232.25,136.06 UV1.AM14
GPU_GPIO15: length 16
  TOP w0.102: v2(241.99,143.34) 241.54,143.34 v1(240.99,142.8)
  IN1 w0.102: v2(231.8,137.31) 231.79,137.32 231.79,137.33 232.45,137.99 236.3,137.99 237.22,138.9 237.22,139.33 239.8,141.91 240.9,141.91 241.99,143 v2(241.99,143.34)
  BOTTOM w0.102: v2(231.8,137.31) 232.25,137.76 UV1.AM13 ; v2(241.99,143.34) 242.45,142.89 RV38.2
GPU_GPIO16: length 29.3
  TOP w0.102: v2(242.21,137.9) 242.21,138.1 v1(241.94,138.37)
  IN1 w0.102: v2(242.21,137.9) 242.21,137.91 242.95,138.65 242.95,143.29 242.18,144.06 240.65,144.06 240.23,143.64 240.23,143.48 237.85,141.11 237.82,141.11 237.42,140.71 237.42,140.68 236.23,139.48 236.23,139.34 235.5,138.62 230.61,138.62 229.97,137.98 229.63,137.98 229.09,137.44 229.09,135.66 229.43,135.32 229.65,135.32 230.3,135.97 v2(230.92,135.97)
  BOTTOM w0.102: v2(230.92,135.97) 230.65,136.24 UV1.AK14 ; v2(242.21,137.9) 242.21,138.3 RV37.2
GPU_GPIO19: length 1.8
  TOP w0.102: v2(232.96,137.22) 233.4,136.79 T129.1
  BOTTOM w0.102: v2(232.96,137.22) 232.96,136.82 233.05,136.73 UV1.AN14
GPU_GPIO20: length 15.7
  TOP w0.102: v1(242.3,141.87) 241.88,141.45 v2(241.84,141.45)
  IN1 w0.102: v2(241.84,141.45) 241.77,141.53 239.74,141.53 237.51,139.3 237.51,138.84 236.39,137.72 232.9,137.72 v2(232.37,137.18)
  BOTTOM w0.102: v2(232.37,137.18) 232.69,137.5 232.69,137.96 232.37,138.27 231.93,138.27 UV1.AL13 ; RV39.2 242.41,141.87 241.99,141.45 v2(241.84,141.45)
GPU_GPIO21: length 23.6
  TOP w0.102: v2(242.04,140.31) 242.31,140.31 v1(242.6,140.02)
  IN1 w0.102: v2(242.04,140.31) 242.67,140.93 242.67,143.25 242.09,143.83 240.95,143.83 240.38,143.26 240.32,143.26 237.95,140.88 237.91,140.88 237.85,140.82 237.82,140.82 237.63,140.63 237.63,140.59 236.77,139.74 236.77,139.04 236,138.26 230.75,138.26 230.21,137.72 229.76,137.72 229.56,137.53 v2(229.56,135.91)
  BOTTOM w0.102: RV102.2 242.51,139.84 v2(242.04,140.31) ; UV1.AJ14 229.85,136.45 229.56,136.16 229.56,135.91 v2(229.56,135.91)
GPU_GPIO29: length 1.3
  TOP w0.102: v2(227.97,121.67) 228.01,121.7 228.01,121.78 228.29,122.06 T126.1
  BOTTOM w0.102: v2(227.97,121.67) 228.3,122 UV1.AG32
GPU_GPIO30: length 1.2
  TOP w0.102: T138.1 228.25,120.54 v2(227.97,120.81)
  BOTTOM w0.102: UV1.AG33 228.35,121.2 v2(227.97,120.81)
GPU_HOT#: length 129
  TOP w0.102: v1(241.54,134.89) 241.61,134.81 v2(241.61,134) 241.87,133.74 242.38,133.74 243.29,134.66 QV8.1 243.29,136 CV358.1
  IN1 w0.102: v2(310.15,143.57) 310.61,143.1 312.73,143.1 316.11,146.48 316.11,146.84 317.62,148.35 317.62,163.07 v4(316.97,163.72)
  IN2 w0.102: 237.85,133.48 235.44,133.48 234.89,132.93 229.46,132.93 v2(228.69,133.7)
  IN2 w0.127: 237.85,133.48 241.09,133.48 v2(241.61,134) 242.41,133.2 246.32,133.2 246.93,133.81 249.5,133.81 250.11,133.2 256.73,133.2 256.96,132.97 258.19,132.97 259.1,133.88 259.1,139.23 260.49,140.61 262.09,140.61 265.72,144.25 276.26,144.25 276.51,144.5 285.88,144.5 288.69,141.69 301.21,141.69 304.02,141.69 305.05,142.72 309.31,142.72 v2(310.15,143.57)
  BOTTOM w0.102: UV1.AH17 229.05,134.07 v2(228.69,133.7) ; RV76.2 243.06,137.12 RV103.2 242.73,135.75 241.61,134.63 v2(241.61,134) ; PR633.2 v4(316.97,163.72)
GPU_JTAG_TCK: length 2.6
  TOP w0.102: RV88.2 230.92,130.75 v2(230.11,129.94) 230.11,129.51 v3(229.99,129.39)
  BOTTOM w0.102: v2(230.11,129.94) 230.65,129.4 UV1.AK23
GPU_JTAG_TDI: length 6.8
  BOTTOM w0.102: RV86.2 239.67,129.66 v2(237.14,129.66) 236.06,129.66 236.03,129.7 234.93,129.7 234.89,129.65 233.31,129.65 UV1.AN23
GPU_JTAG_TDO: length 8.1
  BOTTOM w0.102: RV141.2 v2(237.85,127.65) 237.32,128.18 234.87,128.18 234.68,127.99 233.78,127.99 233.22,128.55 232.61,128.55 UV1.AM24
GPU_JTAG_TMS: length 8.7
  BOTTOM w0.102: UV1.AL24 232.09,128.84 v2(233.49,128.84) 234.36,128.84 234.55,129.03 238.12,129.03 238.49,128.66 RV87.2
GPU_JTAG_TRSTB: length 8.8
  BOTTOM w0.102: UV1.AM23 232.25,129.93 232.47,130.15 233.35,130.15 233.59,130.39 233.93,130.39 234.04,130.5 235.58,130.5 235.86,130.22 235.86,130.15 236.12,129.89 236.69,129.89 237.5,130.7 v2(238.44,130.7) RV97.2
GPU_PANEL_ON: length 4.5
  TOP w0.102: v1(231.63,128.41) 230.97,127.75 v2(230.96,127.75) 230.53,127.32 RV62.1
  BOTTOM w0.102: v2(230.96,127.75) 231.08,127.62 231.08,126.82 230.06,125.8 UV1.AJ27
GPU_PSI#: length 121.8
  TOP w0.102: RV79.2 229.16,131.99 229.61,132.44 v2(229.61,132.44) ; v4(317.08,164.73) v1(317.74,164.73)
  IN1 w0.102: v4(317.08,164.73) 317.08,164.66 317.86,163.87 317.86,148.27 316.34,146.75 316.34,146.32 312.76,142.74 310.43,142.74 309.98,142.28 v2(309.98,142.18)
  IN2 w0.102: v2(229.61,132.44) 230.61,131.43 234.55,131.43 235.81,132.69 237.85,132.69
  IN2 w0.127: 237.85,132.69 246.64,132.69 247.21,133.26 249.33,133.26 249.9,132.69 256.52,132.69 256.75,132.46 258.4,132.46 259.61,133.67 259.61,138.84 260.74,139.97 262.16,139.97 265.93,143.74 276.47,143.74 276.72,143.99 285.67,143.99 288.51,141.15 305.33,141.15 305.8,141.62 307.2,141.62 307.7,142.13 309.93,142.13 v2(309.98,142.18)
  BOTTOM w0.102: UV1.AH20 229.37,132.2 229.61,132.44 v2(229.61,132.44)
  BOTTOM w0.254: PR631.1 v4(317.08,164.73)
GPU_PWM: length 2.5
  TOP w0.102: v1(231.47,125.74) 231.05,125.32 v2(231.05,125.15) 230.65,125.54 RV63.1
  BOTTOM w0.102: UV1.AK27 230.65,125.54 v2(231.05,125.15)
GPU_PWR_LEVEL: length 154.4
  TOP w0.102: U46.A52 265.94,46.81 265.82,46.69 265.82,46.27 v1(265.41,45.86) v2(264.82,45.27)
  IN2 w0.127: v2(274.23,144.92) 274.15,144.84 263.75,144.84 258.75,139.84 255.15,139.84 253.79,138.48 249.36,138.48 248.15,137.27 246.82,137.27 246.25,137.85 245.08,137.85 v2(244.56,137.32)
  IN3 w0.127: v2(264.82,45.27) 265.71,44.37 269.93,44.37 270.59,45.03 v2(273.2,45.03)
  IN4 w0.102: v2(274.23,144.92) 272.92,143.61 272.92,141.1 272.58,140.75 272.58,138.28 271.59,137.29 271.59,131.58 271.92,131.25 271.92,130.33 272.82,129.43 272.82,112.21 272.23,111.63 272.23,103.55 272.65,103.13 272.65,100.7 272.03,100.08 272.03,98.22 271.39,97.59 270.29,97.59 268.67,95.97 268.67,95.68 268.02,95.02 268.02,93.62 266.64,92.25 266.64,90.37 266.67,90.34 266.67,87.84 266.48,87.65 266.48,84.34 266.33,84.19 266.33,74.63 266.14,74.44 266.14,73.34 266.57,72.91 266.57,65.39 269.16,62.8 269.16,62.5 269.69,61.96 270.26,61.96 272.53,59.69 272.53,50.87 273.03,50.36 273.03,48.39 272.53,47.88 272.53,45.76 273.2,45.08 v2(273.2,45.03)
  BOTTOM w0.102: RV76.1 244.1,137.78 v2(244.56,137.32)
GPU_ROMCSB: length 2.6
  TOP w0.102: T120.1 232.14,136.54 231.76,136.92 231.47,136.92 v2(231.19,137.2)
  BOTTOM w0.102: v2(231.19,137.2) 230.65,137.74 UV1.AK13
GPU_ROMSI: length 1.6
  TOP w0.102: T119.1 229.09,137.17 v2(228.65,136.72)
  BOTTOM w0.102: v2(228.65,136.72) 229.05,136.32 UV1.AH15
GPU_ROMSO: length 2
  TOP w0.102: T118.1 231.29,136.54 v2(230.6,137.23)
  BOTTOM w0.102: v2(230.6,137.23) 230.03,137.8 UV1.AJ13
GPU_SMBCLK: length 18.6
  TOP w0.102: R822.2 282.38,99.66 281.54,100.49 281.32,100.49 280.95,100.86 v2(280.7,100.86) ; v2(283.57,110.91) U51.B49
  IN1 w0.102: v2(283.57,110.91) 283.57,110.85 283.43,110.72 283.29,110.72 282.86,110.29 282.86,109.53 283.07,109.33 283.07,106.9 282.51,106.34 281.87,106.34 280.23,104.7 280.23,104.19 279.1,103.06 279.1,101.67 279.71,101.07 280.5,101.07 v2(280.7,100.86)
GPU_SMBDAT: length 20.8
  TOP w0.102: R829.2 285.35,99.68 284.91,100.13 283.87,100.13 283.62,99.89 v4(282.96,99.89) 282.47,99.89 281.64,100.72 281.42,100.72 281.11,101.03 281.11,101.03 280.87,101.27 280.87,101.27 280.7,101.43 v2(280.7,101.45) ; v2(284.24,110.91) 283.81,111.34 283.28,111.34 283.22,111.41 U51.B48
  IN1 w0.102: v2(280.7,101.45) 280.55,101.29 279.8,101.29 279.33,101.76 279.33,102.97 280.46,104.1 280.46,104.6 281.97,106.11 282.6,106.11 283.3,106.8 283.3,109.42 283.09,109.63 283.09,110.19 283.39,110.49 283.81,110.49 v2(284.24,110.91)
GPU_THERMAL_INT: length 18.1
  TOP w0.102: v1(242.44,123.32) v2(242.44,122.63) 242.44,122.61 RV53.1
  IN4 w0.102: v2(229.03,122.44) 229.52,121.96 229.52,121.32 229.83,121.02 230.65,121.02 230.83,121.2 232.22,121.2 232.49,120.92 238.1,120.92 239.44,122.26 242.07,122.26 v2(242.44,122.63)
  BOTTOM w0.102: UV1.AG30 228.45,123.42 229.03,122.84 v2(229.03,122.44)
GPU_VDD_SENSE: length 119.5
  TOP w0.254: v2(316.61,155.33) 316.53,155.26 315.5,155.26 v1(315.2,154.95) 314.69,154.44 313.93,154.44 313.61,154.76 313.61,155.43 313,156.04 PR650.1
  IN2 w0.254: v2(285.71,142.52) 285.71,142.58 285.01,143.28 277,143.28 276.73,143.01 266.28,143.01 262.29,139.03 261.17,139.03 260.33,138.19 260.33,131.71 259.75,131.13 254.69,131.13 253.91,131.91 249.45,131.91 248.91,132.45 248.19,132.45 246.45,130.71 245.82,130.71 241.78,126.67 237.07,126.67 236.86,126.87 231.13,126.87 228.97,124.71 228.32,124.71 v2(227.87,124.27)
  BOTTOM w0.254: v2(316.61,155.33) 316.61,153.3 316.24,152.93 316.24,148.29 313.01,145.06 312.57,145.06 311.63,144.12 304.85,144.12 304.3,143.58 292.63,143.58 290.6,141.55 286.51,141.55 285.71,142.35 v2(285.71,142.52) ; v2(227.87,124.27) 227.87,124.37 227.68,124.56 227.68,124.57 227.43,124.83 227.36,124.83 227.05,125.14 UV1.AF28
GPU_VGA_B: length 5.6
  BOTTOM w0.254: UV1.AF37 227.25,118.59 227.87,117.97 228.15,117.97 228.54,117.58 228.54,117.09 v1(229.8,115.84) 230.23,115.4 RV71.1
GPU_VGA_DDCCLK: length 7.7
  TOP w0.102: RV74.1 235.16,122.82 234.62,123.37 234.62,123.58 v1(233.76,124.44) 233.55,124.65 232.15,124.65 231.15,123.65 230.74,123.65 v2(230.16,123.06)
  BOTTOM w0.102: v2(230.16,123.06) 230.16,123.09 UV1.AJ30
GPU_VGA_DDCDAT: length 7.8
  TOP w0.102: v2(230.22,122.45) 230.77,123 v1(230.92,123) 231.5,123.58 232.29,123.58 232.44,123.74 233.96,123.74 235.19,122.51 235.19,121.91 235.29,121.81 RV75.1
  BOTTOM w0.102: v2(230.22,122.45) 229.88,122.8 UV1.AJ31
GPU_VGA_G: length 8.6
  BOTTOM w0.102: v1(229.76,112.72) 229.76,114.16 229.28,114.64 RV70.1
  BOTTOM w0.254: RV70.1 229.22,115.68 228.24,116.66 227.59,116.66 226.04,118.21 226.04,118.79 UV1.AE36
GPU_VGA_HSYNC: length 8.5
  BOTTOM w0.102: UV1.AC36 225.17,118.88 225.17,118.73 225.27,118.62 225.27,118.1 225.01,117.84 225.01,117.07 225.99,116.09 226.63,116.09 227.19,115.53 RV72.1 227.2,114.64 227.64,114.2 227.64,113.37 v1(228.32,112.7)
GPU_VGA_R: length 8.3
  BOTTOM w0.102: UV1.AD39 225.65,117.91 226.14,117.41 226.14,117.09 228.2,115.04 RV54.1 228.27,114.64 228.67,114.24 228.67,112.34 v1(229.66,111.35)
GPU_VGA_VSYNC: length 5.3
  BOTTOM w0.102: v1(226.11,113.65) 225.87,113.89 RV73.1 225.87,115.75 224.81,116.8 224.81,118.36 UV1.AC38
GPU_VID0: length 6
  TOP w0.102: v4(306.69,167.14) 306.69,166.87 v1(306.28,166.46)
  TOP w0.254: PR611.1 v4(306.69,167.14)
  BOTTOM w0.203: PU600.32 308.84,166.3 307.58,167.56 PR628.2
  BOTTOM w0.254: v4(306.69,167.14) PR611.1 PR628.2
GPU_VID1: length 8.2
  TOP w0.102: PR625.2 307.95,170.12 v1(307.72,170.34)
  TOP w0.254: PR625.2 308.85,169.94 v4(308.34,169.43)
  BOTTOM w0.203: v4(308.34,169.43) 308.47,169.3 308.47,167.21 309.24,166.43 PU600.33
  BOTTOM w0.254: v4(308.34,169.43) 308.34,169.74 PR609.2 PR625.2
GPU_VID2: length 5.3
  TOP w0.102: v1(308.59,167.14) v4(309.35,167.14) 309.56,167.14 PR606.1
  BOTTOM w0.203: v4(309.35,167.14) 309.64,166.86 PU600.34
  BOTTOM w0.254: PR606.1 PR621.2 v4(309.35,167.14)
GPU_VID3: length 7
  TOP w0.254: PR618.2 310.88,169.61 v4(310.88,169.43)
  BOTTOM w0.203: PU600.35 v1(310.04,166.74) 310.88,167.58 v4(310.88,169.43)
  BOTTOM w0.254: v4(310.88,169.43) 311.26,169.81 PR604.1 PR618.2
GPU_VID4: length 8.9
  TOP w0.102: v4(312.86,169.42) 313.22,169.42 v1(313.51,169.71)
  TOP w0.254: PR617.2 312.68,169.71 312.68,169.6 v4(312.86,169.42)
  BOTTOM w0.203: PU600.36 310.44,166.67 311.26,167.49 311.26,169.1 311.59,169.43 311.59,169.53 312.17,170.12 PR617.2
  BOTTOM w0.254: PR617.2 PR601.2 313.16,169.96 312.86,169.66 v4(312.86,169.42)
GPU_VID_0: length 120.8
  TOP w0.102: v1(232.7,131.65) 232.67,131.68 v2(232.67,132.39) 233.22,132.94 RV2.1
  IN1 w0.102: v4(307.58,169.47) 308.2,168.85 309.1,168.85 309.79,168.16 309.79,165.24 309.34,164.79 309.34,161.96 310.57,160.73 310.57,158.33 310.94,157.96 310.94,156.39 311.06,156.27 311.06,152.91 310.12,151.97 310.12,146.05 310.62,145.54 310.62,144.02 310.76,143.89 v2(310.76,143.57)
  IN2 w0.102: 237.85,132.94 235.47,132.94 234.2,131.67 233.38,131.67 v2(232.67,132.39)
  IN2 w0.127: v2(310.76,143.57) 310.75,143.57 309.65,142.47 305.15,142.47 304.12,141.44 302.68,141.44 301.31,141.44 301.31,141.44 288.58,141.44 285.77,144.25 276.62,144.25 276.36,143.99 265.82,143.99 262.19,140.36 260.65,140.36 259.36,139.06 259.36,133.78 258.29,132.71 256.86,132.71 256.63,132.94 250,132.94 249.39,133.55 247.05,133.55 246.44,132.94 237.85,132.94
  BOTTOM w0.254: PR628.1 v4(307.58,169.47)
GPU_VID_1: length 109
  TOP w0.102: v2(244.39,139) 244.39,138.89 v1(243.95,138.44)
  TOP w0.254: v4(309.62,171.13) 309.52,171.03 PR625.1
  IN1 w0.102: v2(315.24,149.24) 315.11,149.24 314.52,149.82 314.52,151.8 315.39,152.67 315.39,157.33 315.77,157.72 315.77,159.2 314.21,160.76 313.74,160.76 312.67,161.82 312.67,164.41 311.35,165.73 311.35,170.34 310.73,170.97 309.79,170.97 v4(309.62,171.13)
  IN2 w0.127: v2(244.39,139) 244.41,138.99 245.68,138.99 246.39,138.28 248.8,138.28 249.25,138.73 253.69,138.73 255.33,140.37 258.54,140.37 263.27,145.1 273.72,145.1 274.26,145.64 285.46,145.64 288.9,142.2 301,142.2 303.81,142.2 304.84,143.23 308.37,143.23 309.26,144.12 312.71,144.12 315.74,147.15 315.74,148.74 v2(315.24,149.24)
  BOTTOM w0.102: RV37.1 244.22,138.82 v2(244.39,139)
GPU_VID_2: length 113.7
  TOP w0.102: v2(244.31,143.4) 244.29,143.4 243.91,143.78 v1(243.91,144.2)
  IN1 w0.102: v2(315.15,151.63) 315.15,152.01 315.68,152.54 315.68,157.3 316,157.62 316,159.3 314.31,160.98 313.83,160.98 312.9,161.92 312.9,164.51 311.58,165.83 311.58,170.44 310.82,171.2 310.29,171.2 309.9,171.59 309.24,171.59 308.95,171.3 308.95,170.03 309.35,169.62 v4(309.35,169.43)
  IN2 w0.127: v2(282.18,148.98) 282.18,148.86 281.31,147.99 277.92,147.99 276.97,147.04 262.52,147.04 260.78,145.3 255.03,145.3 253.86,146.47 253.34,146.99 251.78,146.99 249.44,144.64 249.44,144.13 248.48,143.18 247.05,143.18 246.5,143.73 244.64,143.73 v2(244.31,143.4)
  IN3 w0.127: v2(282.18,148.98) 281.72,148.53 281.72,147.56 285.33,143.95 287.25,143.95 287.55,143.65 293.65,143.65 293.77,143.52 304.58,143.52 305.01,143.95 305.89,143.95 308.26,146.33 312.45,146.33 313.33,147.21 313.33,150.81 314.1,151.59 314.44,151.59 314.48,151.63 v2(315.15,151.63)
  BOTTOM w0.102: RV38.1 243.8,142.89 v2(244.31,143.4)
  BOTTOM w0.254: PR621.1 v4(309.35,169.43)
