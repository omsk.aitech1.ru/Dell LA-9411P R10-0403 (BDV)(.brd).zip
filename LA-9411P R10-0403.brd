# Allegro board LA-9411P R10-0403.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
MAA0_3: length 30.8
  TOP w0.102: v2(193.05,118.7) UV5.K10
  IN1 w0.127: v2(213.15,127.6) 212.7,128.05 209.36,128.05 208.21,129.2 207.28,129.2 206.52,129.96 203.44,129.96 202.79,129.32 200.87,129.32 199.04,127.5 199.04,122.45 197.24,120.65 194.53,120.65 193.14,119.25 193.14,118.78 v2(193.05,118.7)
  BOTTOM w0.102: v2(213.15,127.6) 213.45,127.89 UV1.J24 ; v2(193.05,118.7) UV5.K10
MAA0_4: length 30
  TOP w0.102: v2(193.85,117.9) UV5.H11
  IN1 w0.127: v2(211.7,127.59) 209.06,127.59 207.86,128.79 207.04,128.79 206.33,129.5 203.63,129.5 202.98,128.86 201.05,128.86 199.86,127.66 199.86,122.51 197.47,120.12 194.65,120.12 193.46,118.92 193.46,118.29 v2(193.85,117.9)
  BOTTOM w0.102: v2(193.85,117.9) UV5.H11 ; UV1.H26 212.37,127 211.78,127.59 v2(211.7,127.59)
MAA0_5: length 31.5
  TOP w0.102: v2(193.85,118.7) UV5.H10
  IN1 w0.127: v2(193.85,118.7) 194.1,118.7 195.02,119.61 197.63,119.61 200.67,122.64 200.67,126.74 202.26,128.33 203.54,128.33 203.69,128.48 203.69,128.92 203.81,129.04 204.09,129.04 204.22,128.92 204.22,128.46 204.35,128.33 204.6,128.33 204.73,128.46 204.73,128.92 204.85,129.04 205.11,129.04 205.24,128.92 205.24,128.46 205.36,128.33 205.62,128.33 205.74,128.46 205.74,128.92 205.87,129.04 206.14,129.04 206.26,128.92 206.26,128.46 206.39,128.33 206.74,128.33 208.14,126.94 212.62,126.94 v2(213.03,126.53)
  BOTTOM w0.102: UV1.J26 213.45,126.95 v2(213.03,126.53) ; v2(193.85,118.7) UV5.H10
MAA0_6: length 30.9
  TOP w0.102: v2(194.65,122.7) UV5.H5
  IN1 w0.102: v2(212.66,129.98) 212.64,129.98 212.3,130.32 210.21,130.32 209.89,130.64 209.89,131.08 209.65,131.32 207.59,131.32 207.12,131.79 207.12,131.79
  IN1 w0.127: v2(194.65,122.7) 195.06,123.1 195.61,123.1 195.84,123.33 195.84,126.06 195.51,126.39 195.51,126.78 195.64,126.91 196.06,126.91 196.19,127.04 196.19,127.29 196.06,127.42 195.64,127.42 195.51,127.55 195.51,127.8 195.64,127.93 196.06,127.93 196.19,128.05 196.19,128.31 196.06,128.43 195.64,128.43 195.51,128.56 195.51,129.63 196.53,130.64 199.5,130.64 200,131.15 202.04,131.15 202.68,131.79 207.12,131.79
  BOTTOM w0.102: UV1.H21 212.56,130.51 212.56,130.06 212.64,129.97 212.64,129.97 v2(212.66,129.98) ; v2(194.65,122.7) UV5.H5
MAA0_7: length 30.8
  TOP w0.102: UV5.H4 v2(193.85,123.5)
  IN1 w0.102: 207.12,132.94 207.41,132.94 207.86,133.39 209.1,133.39 209.44,133.04 209.44,132.55 209.93,132.07 210.95,132.07 211.18,131.83 211.88,131.83 212.34,131.37 v2(212.34,131.08)
  IN1 w0.127: 207.12,132.94 206.89,132.94 206.65,132.7 202.3,132.7 201.66,132.06 194.71,132.06 193.44,130.8 193.44,123.9 v2(193.85,123.5)
  BOTTOM w0.102: UV1.G21 212.02,130.6 212.34,130.91 v2(212.34,131.08) ; UV5.H4 v2(193.85,123.5)
MAA0_8: length 35
  TOP w0.127: UV5.J5 193.45,121.98 v2(193.65,121.78)
  IN1 w0.102: 207.19,130.58 207.37,130.58 207.71,130.24 208.82,130.24 209.28,129.78 209.28,129.36 209.43,129.21 211.73,129.21 211.74,129.23 212.62,129.23 212.87,128.97 212.87,128.61 213.54,127.95 213.54,127.38 213.36,127.2 212.75,127.2 v2(212.36,127.59)
  IN1 w0.127: v2(193.65,121.78) 193.96,121.48 196.44,121.48 197.46,122.49 197.46,129.15 198.04,129.73 199.87,129.73 200.38,130.23 202.42,130.23 203.06,130.87 206.89,130.87 207.19,130.58
  BOTTOM w0.102: UV5.J5 193.45,121.98 v2(193.65,121.78) ; v2(212.36,127.59) 212.56,127.59 213.05,128.09 213.05,128.36 212.89,128.52 212.89,129.16 UV1.H23
MAA1_0: length 30
  TOP w0.102: v2(194.65,136.9) UV3.K4
  IN1 w0.102: 207.12,141.36 208.23,141.36 209.95,139.64 209.95,138.64 211.01,137.59 211.01,135.88 211.1,135.79 211.1,134.62 211.03,134.56 211.03,133.4 211.53,132.89 212.57,132.89 v2(213.04,132.43) ; 195.47,139.05 194.27,137.85 194.27,137.28 v2(194.65,136.9)
  IN1 w0.127: 207.12,141.36 201.96,141.36 199.65,139.05 195.47,139.05
  BOTTOM w0.102: v2(194.65,136.9) UV3.K4 ; v2(213.04,132.43) 212.65,132.81 UV1.H19
MAA1_1: length 28.7
  TOP w0.102: v2(194.65,137.7) UV3.K5
  IN1 w0.102: 195.56,138.61 v2(194.65,137.7) ; v2(212.37,132.5) 211.9,132.03 211.54,132.03 211.18,132.38 211.18,132.59 210.26,133.51 210.26,135.24 210.75,135.74 210.75,137.56 209.7,138.61 209.7,139.61 208.27,141.03 207.79,141.03 207.6,140.84 207.15,140.84
  IN1 w0.127: 207.15,140.84 202.08,140.84 199.85,138.61 195.56,138.61
  BOTTOM w0.102: v2(212.37,132.5) 212.65,132.22 UV1.H20 ; v2(194.65,137.7) UV3.K5
MAA1_2: length 33.5
  TOP w0.102: v2(193.85,141.7) UV3.K11
  IN1 w0.102: 194.46,145.94 194.1,145.58 194.1,144.08 193.47,143.45 193.47,142.08 v2(193.85,141.7) ; v2(215.54,137.94) 215.67,138.07 215.67,139.67 215.5,139.83 215.5,140.1 214.75,140.85 214.58,140.85 214.36,141.07 214.36,142.01 212.95,143.42 212.22,143.42 212,143.64 212,143.69 211.72,143.97 211.4,143.97 211.34,143.91 209.31,143.91 207.12,146.1
  IN1 w0.127: 194.46,145.94 194.76,146.24 206.98,146.24 207.12,146.1
  BOTTOM w0.102: UV1.L13 215.05,137.45 v2(215.54,137.94) ; v2(193.85,141.7) UV3.K11
MAA1_3: length 31.1
  TOP w0.102: v2(194.69,140.83) 194.25,141.27 UV3.K10
  IN1 w0.102: 201.28,142.98 200.73,142.43 200.73,141.7 199.55,140.51 195,140.51 v2(194.69,140.83) ; v2(211.9,134.83) 212.66,135.58 213.82,135.58 214.22,135.98 214.22,137.35 213.73,137.84 213.73,138.5 213.16,139.07 212.99,139.07 211.82,140.23 211.82,140.59 211.6,140.8 210.66,140.8 207.3,144.17 207.12,144.17
  IN1 w0.127: 207.12,144.17 202.47,144.17 201.28,142.98
  BOTTOM w0.102: UV3.K10 194.25,141.27 v2(194.69,140.83) ; v2(211.9,134.83) 211.86,134.86 211.86,135.38 UV1.G16
MAA1_4: length 28.9
  TOP w0.102: v2(193.05,141.7) UV3.H11
  IN4 w0.102: 212.75,135.23 212.69,135.29 209.09,135.29 208.79,135 207.41,135 207.24,135.17 207.12,135.17
  IN4 w0.127: v2(193.05,141.7) 193.02,141.7 192.26,140.93 192.26,140.58 194.05,138.79 194.92,138.79 195.74,137.97 195.84,137.86 195.84,136.74 196.09,136.5 196.38,136.5 196.4,136.49 196.41,136.49 196.64,136.26 196.64,135.14 196.89,134.9 199.58,134.9 199.84,135.17 200.17,135.17 200.87,135.86 204.71,135.86 204.97,135.59 206.66,135.59 207.08,135.17 207.12,135.17
  IN4 w0.13: v2(213.14,134.84) 212.75,135.23
  BOTTOM w0.102: v2(193.05,141.7) UV3.H11 ; UV1.J16 213.45,135.15 v2(213.14,134.84)
MAA1_5: length 33.1
  TOP w0.102: v2(192.65,140.77) UV3.H10
  IN1 w0.102: 207.12,144.63 207.54,144.63 210.92,141.25 211.66,141.25 212.13,140.78 212.41,140.78 212.63,140.55 212.63,140.28 212.79,140.12 212.9,140 213.22,140 213.44,139.78 213.44,139.5 214.21,138.74 214.27,138.74 214.49,138.52 214.49,135.97 213.88,135.36 213.04,135.36 v2(212.51,134.83)
  IN1 w0.127: v2(192.65,140.77) 193.11,141.22 193.94,141.22 194.81,142.1 195.61,142.1 195.86,142.34 195.86,142.66 196.09,142.89 200.54,142.89 202.28,144.63 207.12,144.63
  BOTTOM w0.102: UV3.H10 v2(192.65,140.77) ; v2(212.51,134.83) 212.65,134.97 UV1.H16
MAA1_6: length 31
  TOP w0.102: UV3.H5 v2(193.05,137.7)
  IN1 w0.102: 207.12,141.82 207.31,141.82 207.48,141.66 208.22,141.66 210.23,139.65 210.23,138.65 211.25,137.64 211.25,135.94 211.3,135.89 211.3,134.22 211.23,134.16 211.23,133.48 211.49,133.23 213.2,133.23 v2(213.56,133.59) ; 194.9,139.55 v2(193.05,137.7)
  IN1 w0.127: 207.12,141.82 201.77,141.82 199.5,139.55 194.9,139.55
  BOTTOM w0.102: v2(213.56,133.59) 213.59,133.59 213.63,133.59 213.63,133.59 213.64,133.59 213.62,133.59 213.7,133.67 213.7,133.94 UV1.J17 ; UV3.H5 v2(193.05,137.7)
MAA1_7: length 33.4
  TOP w0.102: v2(193.05,136.9) UV3.H4
  IN1 w0.102: v2(193.05,136.9) 192.55,137.39 192.55,138.34 194.23,140.02 199.5,140.02 201.02,141.53 201.02,142.07 201.28,142.33 ; v2(212.2,133.62) 211.5,134.32 211.5,134.94 211.5,135 211.73,135.22 211.78,135.22 212.28,135.71 212.28,135.82 212.27,135.82 212.27,136.37 212.07,136.58 212.07,137.5 211.5,138.07 211.5,138.43 211.8,138.72 211.82,138.72 211.82,139.73 211.57,139.98 210.59,139.98 208.68,141.9 207.82,141.9 207.12,142.6
  IN1 w0.127: 201.28,142.33 201.62,142.67 207.04,142.67 207.12,142.6
  BOTTOM w0.102: UV1.H17 212.64,134.2 212.2,133.76 v2(212.2,133.62) ; v2(193.05,136.9) UV3.H4
MAA1_8: length 25.9
  TOP w0.102: v2(193.85,136.9) UV3.J5
  IN4 w0.102: 207.12,133.79 207.37,134.04 207.79,134.04 208.07,133.76 208.83,133.76 208.97,133.9 210.5,133.9 211.16,133.24 212.41,133.24 212.77,133.61 v2(212.79,133.61)
  IN4 w0.127: v2(193.85,136.9) 194.25,136.49 194.25,134.26 195.17,133.35 199.75,133.35 200.19,133.79 200.74,133.79 201.43,134.49 204.14,134.49 204.4,134.22 205.07,134.22 205.2,134.09 205.2,133.91 205.33,133.79 205.58,133.79 205.71,133.91 205.71,134.09 205.83,134.22 206.09,134.22 206.21,134.09 206.21,133.91 206.34,133.79 207.12,133.79
  BOTTOM w0.102: v2(193.85,136.9) UV3.J5 ; v2(212.79,133.61) 212.8,133.61 212.8,133.61 212.77,133.61 213.38,133 UV1.J19
MAB0_0: length 30.5
  TOP w0.102: v2(205.91,163.7) UV7.K4
  IN4 w0.102: 214.91,147.21 214.91,147.07 215.45,146.52 215.45,145.08 215.92,144.61 215.92,143.83 216.48,143.27 217.17,143.27 217.5,142.94 217.5,142.47 217.71,142.27 217.71,142.06 v2(218.26,141.51) ; 210.29,154.57 210.29,160.21 209.44,161.06 207.6,161.06 206.13,162.53 206.13,162.77 206.13,162.78 206.13,163.48 v2(205.91,163.7)
  IN4 w0.127: 210.29,154.57 210.29,152.9 212.71,150.49 212.71,149.77 214.91,147.57 214.91,147.21
  BOTTOM w0.102: v2(218.26,141.51) 218.17,141.6 UV1.P8 ; v2(205.91,163.7) UV7.K4
MAB0_1: length 32.2
  TOP w0.102: v2(205.51,162.77) UV7.K5
  IN4 w0.102: 214.39,146.62 214.39,145.92 214.94,145.37 214.94,144.78 215.51,144.21 215.51,143.19 216.57,142.14 216.57,140.25 216.89,139.93 218.15,139.93 v2(218.23,140.02)
  IN4 w0.127: v2(205.51,162.77) 205.51,162.25 207.55,160.21 208.5,160.21 208.7,160.01 208.7,153.03 209.85,151.88 209.85,150.11 212.49,147.47 213.53,147.47 214.39,146.62
  BOTTOM w0.102: UV1.T9 218.85,140.63 v2(218.23,140.02) ; UV7.K5 v2(205.51,162.77)
MAB0_2: length 30.1
  TOP w0.102: UV7.K11 205.51,158.49 v2(205.11,158.89)
  IN1 w0.102: v2(218.26,140.89) 217.3,139.93 216.89,139.93 216.23,140.59 216.23,141.99 215.76,142.46 215.07,142.46 212.68,144.84 212.68,146.27 212.09,146.86 210.11,146.86 209.77,147.21
  IN1 w0.127: v2(205.11,158.89) 203.72,157.5 203.72,153.25 209.77,147.21
  BOTTOM w0.102: UV1.P9 218.16,140.8 v2(218.26,140.89) ; UV7.K11 205.51,158.49 v2(205.11,158.89)
MAB0_3: length 30.3
  TOP w0.102: UV7.K10 v2(205.91,159.7)
  IN1 w0.102: v2(217.05,142.07) 217.05,142.31 215.9,143.47 215.9,144.17 214.03,146.03 214.03,146.97
  IN1 w0.127: 214.03,146.97 212.88,148.12 212.15,148.12 210,150.27 210,151.18 209.58,151.6 208.71,151.6 207.82,152.48 207.82,152.66 208.44,153.28 208.44,153.46 208.26,153.64 208.08,153.64 207.46,153.02 207.29,153.02 207.11,153.2 207.11,153.38 207.73,154 207.73,154.18 207.5,154.4 207.32,154.4 206.71,153.79 206.53,153.79 206.28,154.04 206.28,154.22 207.42,155.36 207.42,155.79 207.12,156.1 207.12,157.04 207.19,157.12 207.19,158.31 207.11,158.39 207.11,159.05 206.47,159.7 v2(205.91,159.7)
  BOTTOM w0.102: UV1.N7 216.73,142.4 v2(217.05,142.07) ; UV7.K10 v2(205.91,159.7)
MAB0_4: length 30.2
  TOP w0.102: v2(207.51,158.9) UV7.H11
  IN1 w0.102: 214.42,147.21 214.42,145.93 216.1,144.25 216.1,143.66 216.49,143.27 217.17,143.27 217.43,143.01 217.43,141.82 v2(217.1,141.49)
  IN1 w0.127: 214.42,147.21 214.42,147.22 212.91,148.74 212.66,148.74 212.51,148.58 212.33,148.58 212.1,148.82 212.1,149 212.49,149.39 212.49,149.57 212.31,149.75 212.13,149.75 211.74,149.36 211.56,149.36 211.37,149.54 211.37,149.72 211.77,150.12 211.77,150.3 211.54,150.53 211.36,150.53 210.96,150.13 210.78,150.13 210.52,150.4 210.52,150.58 210.92,150.98 210.92,151.18 210.55,151.54 210.55,151.66 210.63,151.74 210.63,151.92 210.43,152.12 210.25,152.12 210.07,151.94 209.89,151.94 209.71,152.12 209.71,152.3 209.89,152.48 209.89,152.66 209.71,152.84 209.53,152.84 208.91,152.22 208.73,152.22 208.55,152.4 208.55,152.58 209.17,153.2 209.17,153.38 207.9,154.65 207.9,158.5 v2(207.51,158.9)
  BOTTOM w0.102: v2(217.1,141.49) 217,141.6 UV1.N8 ; v2(207.51,158.9) UV7.H11
MAB0_5: length 33.8
  TOP w0.102: v2(204.72,160.43) 205.98,160.43 UV7.H10
  IN1 w0.102: 207.31,147.21 207.31,146.9 207.66,146.55 209.41,146.55 210.74,145.21 212.02,145.21 215.34,141.9 215.34,141.55 v2(215.69,141.2)
  IN1 w0.127: 207.31,147.21 207.31,148.14 202.75,152.7 202.75,157.37 204.38,158.99 204.38,160.08 v2(204.72,160.43)
  BOTTOM w0.102: UV7.H10 205.98,160.43 v2(204.72,160.43) ; UV1.N9 216.31,140.8 215.91,141.2 v2(215.69,141.2)
MAB0_6: length 31.7
  TOP w0.102: UV7.H5 207.11,163.27 v2(207.55,162.83)
  IN4 w0.102: 217.17,147.04 217.17,146.24 217.62,145.79 217.62,145.52 219.97,143.17 219.97,141.76 v2(220.63,141.1) ; v2(207.55,162.83) 208.03,163.31 208.58,163.31 208.71,163.18 208.71,162.72 208.95,162.48 211.02,162.48
  IN4 w0.127: 217.17,147.04 217.09,147.12 217.09,148.48 214.9,150.67 214.9,151.4 213.03,153.28 213.03,154.91 213.11,155 213.11,160.03 212.47,160.67 212.47,161.04 211.02,162.48
  BOTTOM w0.102: v2(220.63,141.1) 220.35,141.1 UV1.U9 ; v2(207.55,162.83) 207.11,163.27 UV7.H5
MAB0_7: length 31.5
  TOP w0.102: v2(206.71,163.7) UV7.H4
  IN4 w0.102: v2(219.46,141.52) 219.11,141.86 219.11,143.1 218.83,143.38 217.83,143.38 217.71,143.5 217.71,143.89 216.8,144.81 216.62,144.81 216.07,145.35 216.07,146.84 215.82,147.09 ; 211.56,154.57 211.56,155.16 211.9,155.49 211.9,159.87 209.98,161.79 207.68,161.79 206.9,162.56 206.9,163.5 v2(206.71,163.7)
  IN4 w0.127: 215.82,147.09 215.82,147.95 213.63,150.15 213.63,150.87 211.56,152.93 211.56,154.57
  BOTTOM w0.102: v2(206.71,163.7) UV7.H4 ; UV1.U8 219.54,141.6 v2(219.46,141.52)
MAB0_8: length 30.9
  TOP w0.127: UV7.J5 206.31,162.98 v2(206.51,162.78)
  IN4 w0.102: 215.36,147.21 215.36,147.03 215.73,146.66 215.73,145.29 216.87,144.15 217.16,144.15 217.51,143.81 217.51,143.22 217.71,143.02 217.71,142.56 218.14,142.13 218.53,142.13 218.91,141.74 218.91,141.43 v2(219.45,140.89) ; v2(206.51,162.78) 206.51,162.54 207.65,161.4 209.57,161.4 211.11,159.87 211.11,154.57
  IN4 w0.127: 215.36,147.21 215.36,147.76 213.17,149.96 213.17,150.68 211.11,152.74 211.11,154.57
  BOTTOM w0.102: v2(206.51,162.78) 206.31,162.98 UV7.J5 ; UV1.T8 218.85,141.49 v2(219.45,140.89)
MAB1_0: length 33.4
  TOP w0.102: UV9.K4 v2(226.91,163.7)
  IN4 w0.102: v2(223.14,141.32) 222.81,140.98 221.66,140.98 221.44,141.2 221.44,141.75 221.44,141.75 221.44,143.22 224.47,146.25 224.47,147.21 ; v2(226.91,163.7) 226.84,163.7 226.42,164.11 224.39,164.11 224.09,163.81 224.09,163.54 223.86,163.32 223.35,163.32 222.92,162.89 222.92,162.63 221.73,161.44 221.73,156.64 222.12,156.25 222.12,154.66 222.2,154.57
  IN4 w0.127: 224.47,147.21 224.47,152.31 222.2,154.57
  BOTTOM w0.102: UV9.K4 v2(226.91,163.7) ; UV1.Y9 222.62,140.8 v2(223.14,141.32)
MAB1_1: length 28.8
  TOP w0.102: v2(226.51,162.75) UV9.K5
  IN4 w0.102: 224.65,154.57 224.55,154.67 224.55,155.82 224.09,156.28 224.09,159.19 223.63,159.65 223.63,160.65 225.13,162.15 226.27,162.15 226.51,162.39 v2(226.51,162.75) ; 226.2,147.21 226.2,147.05 225.55,146.4 225.55,145.15 224.9,144.5 224.47,144.5 223.67,143.7 223.67,143.4 223.44,143.17 222.77,143.17 222.69,143.09 222.69,141.99 222.06,141.36 v2(221.82,141.36)
  IN4 w0.127: 226.2,147.21 226.2,153.02 224.65,154.57
  BOTTOM w0.102: UV1.W9 221.25,140.8 v2(221.82,141.36) ; v2(226.51,162.75) UV9.K5
MAB1_2: length 25
  TOP w0.102: v2(226.11,158.9) UV9.K11
  IN1 w0.102: v2(225.33,141.91) 225.11,141.7 224.14,141.7 223.91,141.93 223.91,144.06 224.7,144.85 224.7,146.28
  IN1 w0.127: 224.7,146.28 224.7,147.01 224.82,147.14 225.18,147.14 225.31,147.27 225.31,147.52 225.18,147.65 224.82,147.65 224.7,147.78 224.7,148.03 224.82,148.16 225.18,148.16 225.31,148.28 225.31,148.54 225.18,148.66 224.82,148.66 224.7,148.79 224.7,149.05 224.82,149.17 225.18,149.17 225.31,149.3 225.31,149.55 225.18,149.68 224.82,149.68 224.7,149.81 224.7,153.15 224.95,153.41 225.89,153.41 226.26,153.78 226.26,154.77 226.14,154.89 226.14,156.56 226.49,156.91 226.49,158.51 v2(226.11,158.9)
  BOTTOM w0.102: v2(225.33,141.91) 225.01,141.6 UV1.AC8 ; v2(226.11,158.9) UV9.K11
MAB1_3: length 28.3
  TOP w0.102: UV9.K10 226.51,160.02 226.8,160.31 v2(227.73,160.31)
  IN1 w0.127: v2(225.26,141.18) 225.9,141.82 225.9,143.97 227.07,145.14 227.07,145.97 226.68,146.37 226.68,148.69 226.8,148.81 227.67,148.81 227.8,148.94 227.8,149.19 227.67,149.32 226.8,149.32 226.68,149.45 226.68,149.7 226.8,149.83 227.67,149.83 227.8,149.96 227.8,154.51 228.57,155.28 228.57,159.47 v2(227.73,160.31)
  BOTTOM w0.102: v2(227.73,160.31) 226.77,160.31 226.51,160.05 UV9.K10 ; UV1.AC9 224.88,140.8 v2(225.26,141.18)
MAB1_4: length 24.6
  TOP w0.102: v2(227.71,158.9) UV9.H11
  IN1 w0.127: v2(224.29,142.66) 225.03,143.4 225.03,144.34 225.76,145.08 225.76,150 225.64,150.13 225.28,150.13 225.15,150.25 225.15,150.57 225.28,150.7 225.64,150.7 225.76,150.82 225.76,151.1 225.64,151.23 225.28,151.23 225.15,151.36 225.15,151.64 225.28,151.76 226.28,151.76 226.41,151.89 226.41,152.23 226.28,152.36 225.28,152.36 225.15,152.49 225.15,152.82 225.28,152.95 226.75,152.95 226.88,153.08 226.88,153.96 226.88,153.96 226.88,154.76 227.52,155.4 227.52,155.77 227.83,156.08 227.84,156.08 228.11,156.36 228.11,158.49 v2(227.71,158.9)
  BOTTOM w0.102: v2(224.29,142.66) 224.02,142.4 UV1.AA7 ; v2(227.71,158.9) UV9.H11
MAB1_5: length 24.7
  TOP w0.102: v2(227.74,159.68) 228.11,159.31 UV9.H10
  IN1 w0.127: v2(224.3,142.08) 225.47,143.25 225.47,144.46 225.99,144.98 225.99,146.35 226.22,146.58 226.22,150.16 226.35,150.29 227.21,150.29 227.34,150.41 227.34,150.67 227.21,150.79 226.35,150.79 226.22,150.92 226.22,151.17 226.35,151.3 227.21,151.3 227.34,151.43 227.34,151.68 227.21,151.81 227,151.81 226.87,151.94 226.87,152.23 227,152.36 227.15,152.36 227.34,152.55 227.34,154.42 227.34,154.43 227.34,154.79 227.73,155.18 228.09,155.18 228.34,155.43 228.34,159.08 v2(227.74,159.68)
  BOTTOM w0.102: v2(224.3,142.08) 223.82,141.6 UV1.AA8 ; v2(227.74,159.68) 228.11,159.31 UV9.H10
MAB1_6: length 28.7
  TOP w0.102: v2(228.51,163.7) UV9.H5
  IN4 w0.102: v2(228.51,163.7) 228.51,162.47 227.83,161.8 226.64,161.8 225.34,160.5 225.34,159.41 224.57,158.64 224.57,156.74 225.33,155.98 225.33,155.25 225.71,154.86
  IN4 w0.127: 225.71,154.86 226.86,153.72 226.86,153.2 226.65,152.99 226.65,146.98 225.83,146.15 225.83,145.12 224.99,144.29 224.56,144.29 223.88,143.62 223.88,142.77 v2(223.09,141.98)
  BOTTOM w0.102: v2(223.09,141.98) 222.71,141.6 UV1.Y8 ; v2(228.51,163.7) UV9.H5
MAB1_7: length 28.1
  TOP w0.102: UV9.H4 v2(227.71,164.5)
  IN1 w0.102: 223.5,145.13 223.5,141.76 224.18,141.09 v2(224.31,141.09) ; 224.55,155.17 224.55,158.02 225.31,158.78 225.31,160.41 227.29,162.4 227.29,163.9 227.71,164.32 v2(227.71,164.5)
  IN1 w0.127: 224.55,155.17 223.78,154.4 223.78,151.8 222.96,150.97 222.96,147.01 223.67,146.3 223.67,145.3 223.5,145.13
  BOTTOM w0.102: v2(224.31,141.09) 224.02,140.8 UV1.AA9 ; UV9.H4 v2(227.71,164.5)
MAB1_8: length 30.1
  TOP w0.102: v2(227.69,162.92) 227.31,163.3 UV9.J5
  IN4 w0.102: 224.93,147.21 224.93,146.32 223.24,144.63 223.17,144.63 221.64,143.09 221.64,142.48 v2(221.98,142.14) ; v2(227.69,162.92) 227.29,163.31 226.75,163.31 226.69,163.37 226.24,163.37 226.15,163.28 224.62,163.28 223.69,162.35 223.42,162.35 222.94,161.87 222.94,159.63 222.51,159.19 222.51,157.76 222.92,157.35 222.92,154.57
  IN4 w0.127: 222.92,154.57 222.92,154.5 224.93,152.5 224.93,147.21
  BOTTOM w0.102: UV9.J5 227.31,163.3 v2(227.69,162.92) ; UV1.W8 221.44,141.6 v2(221.98,142.14)
MASK_BASE_LEDS#: length 76.8
  TOP w0.102: v2(328.96,165.52) 328.72,165.76 328.36,165.76 Q83.2 Q83.5 ; Q74.2 v2(329.42,159.4) ; v2(326.12,214.77) 326.12,214.74 325.46,214.08 322.37,214.08 v1(321.79,213.51) v2(320.91,212.63) ; v2(323.17,168.02) 322.99,167.84 Q100.2
  IN3 w0.127: v2(328.96,165.52) 328.42,164.97 328.42,160.4 v2(329.42,159.4) ; v2(320.91,212.63) 320.57,212.28 320.57,209.88 318.97,208.28 318.97,204.7 320.67,203 320.67,198.87 321,198.54 321,191.57 321.5,191.07 321.5,190.03 321.71,189.81 321.71,188.54 319.9,186.73 319.9,183.39 320.95,182.34 320.95,181.4 320.35,180.81 320.35,176.14 323.67,172.82 323.67,170.57 323.67,170.57 323.67,170.08 322.72,169.12 322.72,168.48 v2(323.17,168.02)
  IN4 w0.102: v2(328.96,165.52) 328.95,165.52 326.93,167.54 325.04,167.54 324.56,168.02 v2(323.17,168.02)
  BOTTOM w0.102: v2(320.91,212.63) U58.4 ; 326.82,214.9 326.25,214.9 v2(326.12,214.77)
MASK_SATA_LED#: length 160.7
  TOP w0.102: U46.B9 272.77,52.62 272.09,52.62 v2(272.03,52.57) ; v2(329.48,160.68) 330.03,161.23 330.63,161.23 331.18,160.67 332.85,160.67 333.23,160.29 333.23,159.73 332.9,159.4 Q74.5
  BOTTOM w0.102: v2(272.03,52.57) 272.4,52.93 272.82,52.93 v1(273.33,53.44) 274.28,54.39 275.08,54.39 275.2,54.28 275.7,54.28 276.79,55.37 278.28,55.37 281.12,58.22 281.12,65.39 278.96,67.55 278.96,93.43 283.89,98.36 286.78,98.36 287.89,99.47 307.95,99.47 314.98,106.5 314.98,118.43 318.28,121.73 324.98,121.73 325.36,122.11 325.36,142.23 326.45,143.32 326.45,150.6 329.99,154.14 329.99,155.78 328.84,156.93 328.84,160.04 v2(329.48,160.68)
MB_MBSS_GC: length 187.4
  TOP w0.102: v2(180.15,143.04) v1(180.15,143.73)
  TOP w0.254: PR809.2 241.54,75.13 v2(241.91,75.5) ; PR836.2 160.18,177.37 160.37,177.18 v4(160.37,176.99) ; v2(218.64,105.09) 218.93,104.8 218.93,100.76 224.44,95.25 229.13,95.25 231.34,93.04 231.34,91.67 230.32,90.65 230.32,89.51 231.54,88.29 231.54,85.67 233,84.21 235.85,84.21 236.51,83.55 236.51,83.25 236.93,82.83 v2(237.35,82.83) PD803.1 237.35,80.9 237.75,80.49 239.31,80.49 239.89,81.06 PQ808.5
  IN2 w0.254: v2(167.06,142.05) 167.11,142.05 167.17,142 169.57,142 170.99,143.42 172.74,143.42 173,143.17 180.02,143.17 v2(180.15,143.04)
  IN3 w0.254: v2(218.64,105.09) 218.61,105.12 207.67,105.12 206.92,105.87 196.59,105.87 195.84,105.12 183.21,105.12 182.58,105.74 182.58,108.02 181.08,109.52 181.08,111.49 177,115.58 177,120.81 178.52,122.34 178.52,127.19 177.95,127.76 177.95,130.61 178.94,131.6 178.94,134.83 178.29,135.48 178.29,140.75 179.45,141.9 179.45,142.34 v2(180.15,143.04)
  IN4 w0.254: v4(160.37,176.99) 160.42,176.94 161,176.94 161.5,176.44 161.5,175.87 161.08,175.45 161.08,172.43 161.97,171.54 161.97,165.16 163.8,163.33 163.8,161.48 165.38,159.91 165.38,143.43 166.76,142.05 v2(167.06,142.05)
  BOTTOM w0.254: v2(241.91,75.5) 242.21,75.81 242.21,77.85 241.63,78.43 238.43,78.43 237.35,79.51 v2(237.35,82.83)
MB_MBSS_GC_C2: length 2.3
  TOP w0.203: PU808.21 161.6,176.35 v1(161.25,176.69) 161.1,176.85 PR836.1
MCARD_MISC_PWREN: length 166.8
  TOP w0.102: v2(264.33,48.71) 264.69,48.36 U46.B53 ; v2(288.73,180.34) 288.73,176.9 287.83,176 287.83,172.06 287.27,171.5 285.62,171.5 v1(284.86,172.26) v2(284.07,173.05)
  IN1 w0.102: v2(280.73,144.96) 280.73,146.88 280.51,147.09 280.51,147.61 280.16,147.97 278.63,147.97 278.34,148.26 278.34,155.49 277.99,155.84 277.99,166.73 278.82,167.56 278.82,169 280.65,170.83 283.51,170.83 284.09,171.41 284.09,173.02 v2(284.07,173.05)
  IN3 w0.127: v2(264.33,48.71) 264.77,49.14 264.77,49.56 265.02,49.81 265.29,49.81 266.12,50.65 266.12,54.29 266.71,54.88 270.41,54.88 270.84,55.3 270.84,57.07 271.37,57.61 271.37,63.35 271.09,63.63 271.09,67.84 v2(271.89,68.64)
  IN4 w0.102: v2(271.89,68.64) 271.36,69.18 271.36,71.8 272.35,72.79 272.35,74.82 270.76,76.41 270.76,90.9 272.71,92.85 272.71,93.78 275.71,96.78 275.71,97.24 v2(275.9,97.43)
  BOTTOM w0.102: v2(275.9,97.43) 276.33,97.87 276.33,104.71 273.94,107.1 273.11,107.93 273.11,117.08 273.58,117.55 273.58,122.69 275.99,125.1 275.99,127.52 277.66,129.18 277.66,132.26 277.4,132.51 277.4,132.54 277.12,132.82 277.12,143.26 279.32,145.45 280.4,145.45 280.73,145.12 v2(280.73,144.96) ; v2(288.73,180.34) 288.73,181.47 R733.1 286.94,182.37 285.52,182.37 285.12,181.97 U100.5
MCARD_PCIE#_SATA: length 3.8
  TOP w0.102: R727.1 R747.2 316.67,126.23 316.49,126.05 v1(316.49,125.77) 316.49,125.23 317.07,124.66 Q88.1
MCARD_PCIE_SATA#: length 356.1
  TOP w0.089: 196.49,68.68 197.58,68.68 v2(197.76,68.51)
  TOP w0.102: Q88.2 315.98,122.76 314.22,124.52 299.86,124.52 299.14,125.23 294.62,125.23 294.23,124.84 293.68,124.84 293.45,125.07 293.45,125.88 291.09,128.24 287.54,128.24 287.05,128.73 284.58,128.73 284.3,128.45 283.95,128.45 282.73,127.23 v2(276.47,127.23) ; RH226.1 193.44,66.06 196.06,68.68 196.49,68.68 ; v2(273.71,72.61) 273.4,72.91 267.19,72.91 267.17,72.94 266.87,72.94 266.48,73.33 266.48,78.85 268.56,80.94 269.36,80.94 270.16,81.74 v1(270.16,82.21) RH16.1 269.06,84.98 v2(268.99,84.9) ; U46.B3 272.46,49.64 v2(272.1,49.99)
  IN1 w0.102: v2(276.47,127.23) 276.45,127.2 276.4,127.2 272.74,123.55 272.74,120.23 272.24,119.73 272.24,105.13 273.1,104.27 273.1,95.07 269.88,91.85 269.88,85.75 269.2,85.08 269.16,85.08 v2(268.99,84.9)
  IN2 w0.127: v2(268.99,84.9) 268.99,84.89 268.99,84.87 268.74,84.62 266.48,84.62 265.94,85.15 262.47,85.15 v2(262.21,85.41)
  IN3 w0.089: 193.24,73.13 195.59,70.78 195.59,70.07 196.79,68.86 197.38,68.86 197.73,68.51 197.73,68.51 197.74,68.5 197.74,68.51 v2(197.76,68.51)
  IN3 w0.127: v2(262.21,85.41) 262.09,85.41 261.4,84.72 261.4,68.28 257.93,64.81 257.93,56.07 257.68,55.81 257.68,53.72 258.14,53.26 258.14,48.66 258.38,48.41 258.4,48.41 260.97,45.84 260.97,42.83 262.05,41.75 262.05,31.73 247.75,17.43 226.7,17.43 225.78,18.36 225.78,19.64 221.88,23.54 221.88,24.05 219.24,26.68 215.79,26.68 214.74,27.73 214.74,32.18 211.04,35.88 201.19,35.88 200.4,36.66 197.84,36.66 195.45,39.05 195.45,41.87 194.57,42.75 194.57,44.63 182.35,56.85 182.35,68.54 183.87,70.05 185.8,70.05 188.91,73.16 193.2,73.16 193.24,73.13 ; v2(273.71,72.61) 275.09,71.22 275.09,64.06 275.84,63.31 275.84,61.68 274.37,60.2 274.37,59.27 273.43,58.34 273.43,50.83 272.59,49.99 v2(272.1,49.99)
  BOTTOM w0.089: 196.88,68.29 196.88,68.37 197.14,68.63 197.63,68.63 v2(197.76,68.51) 198.03,68.51 198.58,69.06 UH1.AN2
  BOTTOM w0.102: RH224.2 194.05,66.44 195.02,67.41 195.49,67.41 196.12,68.05 196.63,68.05 196.88,68.29
MCARD_WWAN_PWREN: length 203.6
  TOP w0.102: U46.B42 264.12,53.14 264.16,53.18 v2(264.26,53.18) ; v2(325.95,198.55) R726.1 325.24,198.64 325.24,199.43 325.2,199.47 U101.5
  IN1 w0.102: v2(323.13,168.72) 323.13,168.66 324.18,167.61 324.18,161.94 323.2,160.96 323.2,159.03 322.82,158.64 322.82,158.12 322.93,158 322.93,147.73 318.02,142.82 318.02,141.85 313.02,136.85 312.46,136.85 311.56,135.96 311.56,111.65 313.3,109.91 v2(313.3,107.19)
  IN3 w0.127: v2(323.13,168.72) 323.13,169.18 323.93,169.97 323.93,172.92 320.67,176.18 320.67,180.59 321.25,181.17 321.25,182.61 320.15,183.71 320.15,186.6 321.97,188.42 321.97,190.08 321.75,190.3 321.75,191.2 321.25,191.69 321.25,192.28 325.4,196.42 325.4,197.99 v2(325.95,198.55)
  BOTTOM w0.102: v2(313.3,107.19) 313.3,105.93 307.9,100.52 294.98,100.52 294.55,100.09 289.85,100.09 288.87,101.07 287.58,101.07 286.7,100.18 286.7,99.41 285.88,98.59 283.8,98.59 278.73,93.53 278.73,63.32 279.9,62.15 279.9,57.68 278.47,56.25 275.39,56.25 275.35,56.29 274.25,56.29 273.66,55.7 273.66,54.6 272.28,53.23 v1(267.32,53.23) 265.84,53.23 265.49,53.58 264.65,53.58 v2(264.26,53.18)
MDC_RST_DIS#: length 102.7
  TOP w0.102: U46.A49 264.44,46.67 263.89,46.13 v2(262.55,46.13) v1(261.75,46.13)
  IN3 w0.127: v2(264.47,136.11) 263.98,135.61 263.98,130.07 263.81,129.91 263.81,120.63 264.54,119.91 264.54,96.98 263.44,95.88 263.44,77.04 262.35,75.96 262.35,66.48 259.48,63.61 259.48,58.97 259.1,58.59 259.1,52.38 259.75,51.74 259.75,48.64 261.81,46.57 262.11,46.57 v2(262.55,46.13)
  BOTTOM w0.102: R752.2 261.8,133.98 Q44.2 262.77,134.87 263.05,135.15 263.05,135.72 263.52,136.19 264.38,136.19 v2(264.47,136.11)
MDC_SDIN: length 3.8
  BOTTOM w0.102: JMDC1.9 260.61,136.6 v2(261.04,137.03) 261.48,137.46 261.48,137.76 RH362.2
ME_FWP: length 86.6
  TOP w0.102: U46.A8 273.98,52.39 274.04,52.33 275.15,52.33 v2(275.64,52.82) 276.45,52.01 R793.1
  IN2 w0.127: v2(256.22,59.5) 255.92,59.5 255.17,60.25 247.15,60.25 242.61,55.71 240.05,55.71 238.14,53.81 231.03,53.81 227.48,57.37 223.1,57.37 v2(222.89,57.16) ; v2(256.13,63.77) 262.66,63.77 265.83,66.94 272.75,66.94 277.55,62.14 278.06,62.14 280.01,60.2 280.01,56.4 278.89,55.28 278.89,54.1 277.6,52.82 v2(275.64,52.82)
  BOTTOM w0.102: v2(256.13,63.77) 256.15,63.77 256.78,63.14 v1(256.78,61.35) 256.78,60.06 v2(256.22,59.5) ; RH45.1 221.17,58.24 222.25,57.16 v2(222.89,57.16)
ME_RESET#: length 34
  TOP w0.102: v2(201.66,45.99) 201.86,46.19 v1(202.55,46.19) 204.06,46.19 RH93.2
  IN1 w0.102: v2(188.18,64.7) 188.32,64.7 188.9,64.12 191.36,64.12 192.77,62.71 192.77,61.1 191.51,59.84 191.51,55.17 194,52.68 194.55,52.68 195.06,52.17 196.99,52.17 198.1,51.06 199.43,49.73 199.43,48.22 v2(201.66,45.99)
  BOTTOM w0.102: v2(188.18,64.7) 188.1,64.7 187.73,65.06 RH70.1 188.52,65.57 188.71,65.76 188.89,65.76 189.38,65.27
ME_SUS_PWR_ACK: length 170.9
  TOP w0.102: v2(293.63,113.44) 293.4,113.66 U51.A8 ; v2(202.9,52.77) 202.9,53.08 202.06,53.92 201.47,53.92 199.37,56.02 199.37,56.46 RH75.2 199.6,56.5 199.73,56.37 199.73,56.07 200.01,55.79 200.47,55.79 200.69,56.02 201.91,56.02 RH107.1
  IN2 w0.127: v2(293.63,113.44) 292.58,113.44 291.88,114.14 290.54,114.14 290.31,114.37 287.21,114.37 285.63,112.79 285.12,112.79 284.78,112.45 282.09,112.45 281.72,112.81 281.72,112.82 281.46,113.08 279.75,113.08 278.91,112.24 277.1,112.24 276.87,112.47 276.87,113.47 276.49,113.86 274.74,113.86 274.56,113.68 262.2,113.68 260.79,112.27 260.79,112.26 v2(260.74,112.2) ; v2(202.9,52.77) 202.9,48.86 204.33,47.43 205.72,47.43 207.83,49.54 210.47,49.54 212.29,51.36 214.59,51.36 215.63,52.4 216.61,52.4 218.36,54.15 218.36,55.11 218.69,55.45 219.48,55.45 220.43,54.5 223.07,54.5 224.69,56.11 225.25,56.11 226,56.86 227.27,56.86 231.03,53.1 245.35,53.1 248.28,56.03 248.99,56.03 250.6,57.65 251.16,57.65 251.34,57.47 253.23,57.47 254.8,59.03 v2(255.75,59.03)
  BOTTOM w0.102: v2(260.74,112.2) 259.21,112.2 257.25,110.24 257.25,110.21 255.38,108.34 255.38,98.06 254.74,97.42 254.74,96.51 255.18,96.08 255.18,91.53 255.89,90.82 v1(255.89,65.04) 255.89,64.19 254.71,63 254.71,60.08 v2(255.75,59.03)
ME_SUS_PWR_ACK_R: length 8.9
  TOP w0.102: RH91.1 RH107.2 203.45,57.33 203.45,57.82 v2(203.79,58.17)
  BOTTOM w0.089: 204.66,60.51 204.66,60.72 205.09,61.15 205.09,61.77 205.34,62.02 205.34,62.28 205.53,62.47 205.93,62.47 UH1.J4
  BOTTOM w0.102: v2(203.79,58.17) v1(203.79,58.69) 203.79,59.1 204.66,59.97 204.66,60.51
MEC_XTAL1: length 8.3
  TOP w0.102: U51.A61 289.72,107.74 290.04,107.42 290.04,107.42 291.22,106.24 291.4,106.24 v1(291.5,106.14) 292.67,104.97 C743.1 293.01,104 293.01,102.9 292.87,102.76 Y6.1
MEC_XTAL2: length 4.6
  TOP w0.102: Y6.2 293.55,102.76 293.37,102.94 293.37,103.76 293.53,103.92 C741.1 293.53,105.02 R1068.2
MEC_XTAL2_R: length 3.3
  TOP w0.102: R1068.1 291.07,106.95 v1(290.79,107.23) 290.22,107.8 U51.A62
MEM_SMBCLK: length 33.5
  IN1 w0.089: 200.38,64.38 200.39,64.39 200.39,64.4 201,65.01 203.61,65.01 204.08,65.49 204.26,65.49 205.01,66.24 205.23,66.24 206.07,65.4 v2(206.1,65.4)
  IN1 w0.102: v2(186.16,62.5) 186.16,62.73 186.42,62.98 186.42,63.59 189.15,66.32 189.55,66.32 195.1,60.77 195.69,60.77 196.18,61.26 197.47,61.26 199.69,63.49 199.69,63.69 200.38,64.38
  BOTTOM w0.089: v2(206.1,65.4) 206.1,65.44 206.22,65.56 UH1.R10
  BOTTOM w0.102: QH4.6 189.11,61.21 189.22,61.21 189.51,60.92 188.83,60.24 v1(188.5,60.24) 188.43,60.24 v2(186.16,62.5)
MEM_SMBDATA: length 29.1
  TOP w0.089: v1(206.28,65.9) 206.28,66.64 v2(206.1,66.82)
  IN1 w0.089: v2(206.1,66.82) 205.39,66.82 205.03,66.45 204.92,66.45 204.17,65.7 204,65.7 203.52,65.23 200.91,65.23 200.24,64.55 200.23,64.55 200.22,64.54
  IN1 w0.102: 200.22,64.54 199.46,63.79 199.46,63.58 197.37,61.49 196.09,61.49 195.59,61 195.2,61 189.65,66.55 189.06,66.55 186.98,64.48 v2(186.62,64.48)
  BOTTOM w0.089: v2(206.1,66.82) 205.95,66.97 UH1.U11
  BOTTOM w0.102: v2(186.62,64.48) 186.64,64.48 RH169.2 187.54,64.5 187.66,64.5 QH4.3
MIC1_L: length 13.1
  TOP w0.102: v2(341.94,166.24) 341.48,166.7 U74.19
  BOTTOM w0.102: v2(341.94,166.24) 341.58,166.61 341.58,167.06 342.12,167.6 v1(342.88,167.6) 343.9,167.6 345.55,165.95 345.55,163.72 345.89,163.39 346.48,163.39 346.6,163.51 347.66,163.51 348.16,163 C195.1
MIC1_L_C: length 1.3
  BOTTOM w0.102: C195.2 v1(349.73,164.4)
MIC1_R: length 9.2
  TOP w0.102: U74.20 v2(341.98,166.89)
  BOTTOM w0.102: C196.1 345.93,163.02 345.22,163.73 v1(345.22,164.88) 345.22,165.96 343.97,167.21 342.3,167.21 v2(341.98,166.89)
MIC1_R_C: length 0.7
  BOTTOM w0.102: 346.62,165.37 v1(346.15,165.84)
MIIC_SCL: length 12.5
  TOP w0.102: R113.2 R102.1 174.05,145.62 174.05,146.35 174.58,146.89 174.58,147.75 173.16,149.17 171.93,149.17 171.42,148.67 170.07,148.67 169.91,148.83 U26.6 169.91,151.27 169.59,151.59 v1(169.59,151.71)
MIIC_SCL0: length 8.5
  TOP w0.102: U27.48 173.42,141.52 v1(172.04,142.9) 172.04,145.54 R105.1 ; R105.1 R106.2 ; R105.1 R102.2
MIIC_SDA: length 11.5
  TOP w0.102: R112.2 174.93,144.49 R103.1 174.28,145.81 174.28,146.26 174.81,146.79 174.81,147.85 173.46,149.19 173.46,150.36 172.53,151.29 v1(172.04,151.29) 171.31,151.29 171.18,151.17 171.18,149.79
MIIC_SDA0: length 13.8
  TOP w0.102: v2(174.48,148.78) v1(175.2,148.06) 175.2,146.84 174.93,146.56 R103.2 175.23,146.08 175.8,146.65 R108.2 R107.1 ; v2(173.58,142.62) 173.34,142.38 173.34,142.02 173.82,141.54 U27.47
  IN3 w0.127: v2(173.58,142.62) 173.91,142.95 173.91,146.08 174.58,146.75 174.58,148.68 v2(174.48,148.78)
MINI1CLK_REQ#: length 373
  TOP w0.102: v2(334.72,158.67) 335.05,158.34 335.05,154.57 332.25,151.78 327.33,151.78 326.54,152.56 v2(321.55,152.56)
  IN1 w0.102: v2(334.72,158.67) 335.14,159.09 335.14,161 336.62,162.48 336.62,167.31 338.23,168.92 338.23,174.61 338.49,174.87 338.49,176.86 340.88,179.24 340.88,181.27 342.21,182.6 342.21,186.07 343.28,187.13 348.09,187.13 349.02,188.06 349.02,205.14 v2(349.8,205.92)
  IN2 w0.127: v2(210.66,41.45) 210.66,40.93 212.76,38.84 222.61,38.84 223.34,39.56 232.49,39.56 234.54,37.5 242.04,37.5 245.74,33.81 247.38,33.81 247.69,34.12 255.04,34.12 256.09,35.18 259.84,35.18 261.58,36.92 265.69,36.92 266.62,37.85 269.21,37.85 269.4,38.04 272.61,38.04 273.06,38.48 273.9,38.48 275.1,39.69 275.1,40.59 276.39,41.87 276.39,43.52 v2(275.99,43.92) ; v2(349.8,205.92) 347.98,205.92 347.38,206.53 336.99,206.53 335.24,208.28 329.88,208.28 v2(328.55,209.61) ; v2(199.33,62.29) 199.33,62.15 198.58,61.4 198.58,59.75 197.37,58.53 195.61,58.53 194.1,57.02 192.96,57.02 192.4,56.46 192.4,53.98 192.91,53.47 192.91,51.78 194.99,49.69 196.31,49.69 v2(196.71,50.09)
  IN4 w0.102: v2(287.82,57.67) 288.27,58.13 288.27,60.2 280.27,68.2 280.27,90.74 288.23,98.7 306.34,98.7 314.24,106.61 314.24,113.55 313.79,114.01 313.13,114.01 312.61,114.53 312.61,132.78 311.64,133.74 311.64,138.58 312.61,139.55 312.61,145.43 319.74,152.56 v2(321.55,152.56)
  BOTTOM w0.089: 199.74,63.15 199.91,63.32 199.91,64.39 201.11,65.59 UH1.AB1
  BOTTOM w0.102: v2(210.66,41.45) 210.59,41.53 210.59,44.56 209.14,46.01 209.14,47.08 208.72,47.5 208.72,48.09 208.68,48.13 208.68,48.16 208.3,48.55 207.75,48.55 207.61,48.41 206.12,48.41 205.47,47.77 203.59,47.77 202.87,48.49 198.28,48.49 196.71,50.06 v2(196.71,50.09) ; RH122.1 198.68,61.5 199.33,62.15 v2(199.33,62.29) 199.33,62.73 199.73,63.13 199.73,63.14 199.74,63.15 ; JMINI1.7 v2(328.55,209.61) ; v2(275.99,43.92) 278.37,43.92 278.7,44.25 278.7,48.55 v1(283.98,53.84) v2(287.82,57.67)
MINI2CLK_REQ#: length 288.7
  TOP w0.102: v2(199.87,62.59) 199.7,62.76 199.2,62.76 198.88,62.44 198.88,62.28 RPH9.2 ; v2(274.26,174.38) 275.01,174.38 275.19,174.56 v1(275.19,175.2) 275.19,176.86 275.46,177.12 275.46,180.64 271.81,184.29 266.02,184.29 261.43,188.89 255.77,188.89 253.53,186.64 253.53,185.64 v2(253.45,185.56)
  IN4 w0.102: v2(199.87,62.59) 199.75,62.71 199.16,62.71 198.36,61.91 198.36,59.7 197.21,58.56 197.21,57.92 194.76,55.47 194.76,52.97 196.22,51.51 196.22,51.26 198.14,49.34 198.14,48.79 199.53,47.41 201.82,47.41 214.36,34.87 214.36,30.64 217.48,27.52 231.57,27.52 234.76,24.33 239.38,24.33 240.78,25.73 243.16,25.73 243.79,25.1 247.39,25.1 250.67,28.38 252.18,28.38 260.12,36.32 260.12,44.54 260.92,45.34 260.92,53 260.98,53.06 260.98,55.85 260.74,56.1 260.74,59.71 261.12,60.09 261.12,65.75 260.36,66.51 260.36,71.15 260.36,71.15 260.36,71.55 260.36,71.55 260.36,78.07 260.65,78.36 260.65,92.02 264.08,95.45 264.08,95.46 264.32,95.7 264.32,95.7 264.93,96.3 264.93,96.75 267.15,98.97 267.15,99.55 267.86,100.26 267.86,101.55 268.71,102.4 268.71,112.69 269.52,113.49 269.52,118.13 268.7,118.94 268.7,129.84 268.45,130.1 268.45,138.79 268.04,139.2 268.04,145.35 268.7,146.02 268.7,149.75 269.07,150.11 269.07,166.5 268.14,167.42 268.14,169.37 269.2,170.42 270.52,170.42 274.26,174.17 v2(274.26,174.38)
  BOTTOM w0.089: UH1.AA2 202.09,65.49 201.93,65.49 201.92,65.49 201.91,65.49 201.68,65.25 201.61,65.18 201.01,65.18 200.5,64.67
  BOTTOM w0.102: 200.5,64.67 200.21,64.38 200.21,62.93 v2(199.87,62.59) ; JMINI2.7 v2(253.45,185.56)
MINI3CLK_REQ#: length 277
  TOP w0.089: 202.96,63.23 202.64,62.91 202.64,62.54
  TOP w0.102: RPH8.3 200.15,60.05 200.46,60.05 200.94,60.53 201.37,60.53 201.82,60.99 201.82,61.72 202.64,62.54 ; v2(296.66,182.89) 296.66,179.34 297.24,178.76 v1(297.24,176.19) v2(297.24,175.18) ; 202.96,63.23 v2(203.2,63.23)
  IN4 w0.089: v2(203.2,63.23) 203.2,63.48 202.36,64.33 201.48,64.33 200.4,63.25 200.4,62.48
  IN4 w0.102: 200.4,62.48 200.4,62.19 199.03,60.82 199.03,58.84 196.73,56.54 196.73,54.61 196.97,54.37 196.97,53.25 201.14,49.09 203.22,49.09 205.4,46.91 208.46,46.91 209.07,46.3 211.45,46.3 211.72,46.57 217.22,46.57 219.38,48.73 225.58,48.73 226.75,49.9 237.74,49.9 238.23,49.42 239.27,49.42 240.01,48.68 240.01,45.41 243.4,42.01 243.81,42.01 246.26,39.56 252.71,39.56 253.26,40.1 256.09,40.1 258.36,42.38 258.36,45.36 259.24,46.24 259.24,53.77 259.29,53.82 259.29,54.39 259.29,54.99 259.05,55.23 259.05,60.88 259.41,61.24 259.41,62.35 258.66,63.1 258.66,78.34 257.92,79.07 257.92,91.73 262.44,96.25 262.44,96.63 265.36,99.55 265.36,100.29 266.04,100.96 266.04,102.79 267.32,104.08 267.32,110.04 267.74,110.46 267.74,114.66 268.05,114.97 268.05,117.82 267.74,118.14 267.74,129.41 267.48,129.66 267.48,138.39 267.07,138.8 267.07,145.75 267.74,146.42 267.74,150.23 268.11,150.6 268.11,166 267.05,167.06 267.05,172.82 267.93,173.7 267.93,174.89 271.08,178.04 275.51,178.04 275.78,177.77 278.25,177.77 278.35,177.88 290.61,177.88 291.35,177.14 292.23,177.14 292.61,176.76 294.32,176.76 294.94,176.14 296.29,176.14 v2(297.24,175.18)
  BOTTOM w0.089: UH1.T3 203.61,64.18 203.61,63.72 203.4,63.5 203.2,63.3 v2(203.2,63.23)
  BOTTOM w0.102: JMINI3.7 v2(296.66,182.89)
MMICLK_REQ#: length 166.5
  TOP w0.102: U38.17 247.34,45.44 v2(247.25,45.35) ; v2(193.47,63.32) 193.49,63.3 193.49,63.28 193.19,62.98 v1(193.19,62.75) 193.19,62.61 194.21,61.59 194.95,61.59 195.23,61.87 195.23,62.49 RH22.1
  IN1 w0.102: v2(247.25,45.35) 246.02,45.35 244.74,44.07 244.74,43.34 243.15,41.76 243.15,40.52 243.34,40.33 243.34,31.66 244.29,30.71 245.17,30.71 245.87,30.01 245.87,26.09 244.66,24.88 242.72,24.88 v2(242.67,24.83)
  IN2 w0.089: v2(198.43,66.13) 198.43,65.73 198.08,65.38 197.86,65.38 197.68,65.2
  IN2 w0.127: v2(193.47,63.32) 193.51,63.28 194.37,63.28 194.98,63.89 196.38,63.89 197.68,65.2 ; v2(259.04,26.86) 256.1,26.86 253.77,24.52 242.92,24.52 242.67,24.78 v2(242.67,24.83)
  IN4 w0.102: v2(193.47,63.32) 192.67,63.32 191.93,62.59 191.28,62.59 190.28,61.58 190.28,61.21 189.68,60.62 189.31,60.62 188.92,60.22 188.92,59.74 190.18,58.48 190.18,50.56 197.43,43.31 197.43,42.41 199.27,40.58 200.72,40.58 201.53,39.76 201.53,38.69 203.2,37.03 203.2,34.94 215.57,22.56 231.51,22.56 233.23,20.84 245.32,20.84 245.83,21.35 254.74,21.35 259.04,25.64 v2(259.04,26.86)
  BOTTOM w0.089: 199.24,66.2 199.84,66.81 200.07,66.81 200.31,67.05 200.61,67.05 200.94,67.38 UH1.AF3
  BOTTOM w0.102: 198.43,66.13 198.43,65.52 198.05,65.14 198.05,64.88 196.68,63.51 196.26,63.51 RH133.2 ; 198.43,66.13 198.43,66.14 199.06,66.14 199.12,66.2 199.24,66.2 ; 198.43,66.13 v2(198.43,66.13)
MOD_MD: length 13.7
  TOP w0.102: v3(231.35,45.43) 231.63,45.43 233,44.06 JSATA2.11
  BOTTOM w0.102: JSATA2.11 235,44.18 233.99,44.18 232.44,45.74 Q123.4 230.63,44.83 230.45,44.64 Q76.3 228.17,44.64 R513.2
MOD_SATA_PCIE#_DET: length 51.8
  TOP w0.102: U46.A42 262.16,51.89 v2(261.98,51.71)
  IN1 w0.102: v2(263.95,42.9) 264.05,43 264.05,45.57 262.52,47.1 262.52,48.27 262.73,48.49 262.73,50.93 261.98,51.68 v2(261.98,51.71)
  IN2 w0.127: v2(263.95,42.9) 262.66,44.2 262.66,44.59 262.21,45.03 261.6,45.03 261.2,45.44 256.73,45.44 255.38,46.79 246.33,46.79 244.13,44.59 239.31,44.59 238.49,45.41 JSATA2.31
  BOTTOM w0.102: JSATA2.31 236.63,46.15 235.9,46.88 230.3,46.88 229.98,47.19 Q123.2 R1183.2 229.35,49.03 v1(229.05,48.73)
MODC_EN: length 227.7
  TOP w0.102: v2(216.96,41.76) 216.96,44.64 222.39,50.06 v2(222.39,50.62) ; U46.B7 272.18,51.64 v2(272.09,51.72)
  IN2 w0.127: v2(276.78,176.3) 276.78,176.33 275.11,178 266.31,178 266.05,177.74 v2(266.05,177.71) ; v2(222.39,50.62) 225.1,53.34 228.66,53.34 229.69,52.31 244.97,52.31 245.47,51.82 248.42,51.82 249.39,52.78 254.28,52.78 257.78,56.29 258.65,56.29 260.6,54.34 263.32,54.34 264.05,53.61 264.1,53.61 264.11,53.6 264.71,53.6 264.72,53.59 266.54,53.59 268.21,51.93 270.09,51.93 270.72,51.3 271.67,51.3 v2(272.09,51.72)
  IN3 w0.127: v2(266.05,177.71) 266.74,177.02 266.74,176.09 266.64,176 266.64,173.01 266.76,172.89 266.76,166.01 267.78,164.99 267.78,150.83 267.15,150.2 267.15,146.3 271.05,142.4 271.05,141.52 271.67,140.9 271.67,137.82 271.1,137.25 271.1,129.66 271.61,129.15 271.61,125.92 270.81,125.13 270.81,119.72 271.66,118.88 271.66,105.25 274.72,102.19 274.72,94.39 275.83,93.28 275.83,75.47 273.29,72.93 273.29,72.37 274.2,71.46 274.2,64.95 273.33,64.07 273.33,62.7 273.05,62.43 273.05,52.44 272.33,51.72 v2(272.09,51.72) ; v2(220.96,37.35) 219.34,37.35 216.96,39.73 v2(216.96,41.76)
  BOTTOM w0.102: v2(222.39,50.62) v1(221.53,50.62) ; Q78.2 279.46,177.57 279.1,177.93 278.14,177.93 276.78,176.57 v2(276.78,176.3) ; U105.5 R512.1 v2(220.96,37.35)
MODC_EN#: length 191.8
  IN1 w0.102: v2(274.02,170.42) 274.02,170.26 273.19,169.43 273.19,168.08 273.72,167.55 273.72,153.61 272.88,152.77 272.88,148.12 273.63,147.37 273.63,146.21 276.35,143.5 276.35,137.15 276.61,136.88 276.61,132.77 277.1,132.28 277.1,127.26 273.21,123.37 273.21,120 272.76,119.55 272.76,104.93 273.33,104.37 273.33,94.29 270.66,91.63 270.66,78.97 267.41,75.72 267.41,74.75 268.19,73.96 268.19,72.55 263.39,67.75 263.39,67.44 258.84,62.89 258.84,61.83 257.15,60.13 255.73,60.13 255.18,59.59 251.2,59.59 250.75,59.14 249.74,59.14 249.5,59.38 248.04,59.38 246.91,58.26 245.31,58.26 236.15,49.1 234.59,49.1 233.2,47.7 232.69,47.7 231.86,46.88 228.25,46.88 227.99,46.61 227.99,46.61 222.16,40.78 v2(219.25,40.78)
  IN2 w0.127: v2(228.43,43.25) 227.38,43.25 226.41,42.28 220.68,42.28 219.25,40.85 v2(219.25,40.78)
  BOTTOM w0.102: v2(228.43,43.25) 228.53,43.34 Q76.2 ; v2(274.02,170.42) 274.53,170.93 277.24,170.93 278.21,171.91 278.21,175.73 278.05,175.89 Q78.1 ; v2(219.25,40.78) 218.74,40.27 218.6,40.27 R509.2 217.25,40.32 v1(217.18,40.4)
MODULE_BATT_PRES#: length 506.8
  TOP w0.102: v2(239.58,57.01) 239.35,57.24 PR2.2 PR5.2 ; v2(272.11,55.38) 272.13,55.38 272.38,55.64 U46.B15
  TOP w0.254: PR749.1 85.02,170.07 84.25,169.29 47.08,169.29 44.33,172.04 44.33,173.55 44.73,173.94 45.26,173.94 45.5,174.18 45.5,180.29 46.06,180.85 48.33,180.85 48.84,181.36 50.03,181.36 50.51,181.84 ; v2(73.57,182.11) 73.52,182.11 72.51,181.1 71.88,181.1 71.06,180.29 59.58,180.29 59.46,180.42 56.32,180.42 55.51,181.23 51.12,181.23 50.51,181.84 ; PU802.1 50.51,181.84 ; PQ808.1 240.54,82.75 241.04,82.24 241.04,80.47 v2(240.89,80.31) ; PR871.2 169.68,176.24 170.33,176.24 171.84,177.75 v2(171.84,178.12)
  IN2 w0.127: v2(279.48,59.23) 279.22,59.5 279.22,60.59 278.33,61.48 278.31,61.48 277.93,61.86 277.27,61.86 277.26,61.87 277.25,61.87 276.84,62.28 275.24,62.28 274.76,62.76 273.72,62.76 273.21,63.27 271.66,63.27 271.41,63.03 268.96,63.03 267.96,62.03 266.13,62.03 266.05,61.95 265.28,61.95 265.19,62.04 260.93,62.04 259.72,63.25 254.06,63.25 253.74,62.93 245.79,62.93 245.02,62.15 242.77,62.15 240.76,60.15 240.76,57.92 239.86,57.01 v2(239.58,57.01)
  IN3 w0.127: v2(172.08,168.34) 173.02,169.28 174.94,169.28 175.42,168.8 176.31,168.8 176.79,169.28 177.82,169.28 178.37,168.73 180.14,168.73 182.04,166.84 186.29,166.84 186.9,167.45 187.92,167.45 188.9,168.43 193.68,168.43 194.57,167.53 196.39,167.53 197.29,168.44 220.67,168.44 224.94,172.71 232.37,172.71 232.8,173.14 239.83,173.14 239.87,173.1 246.88,173.1 247.12,172.86 252.45,172.86 254.74,170.56 254.74,165.25 255.46,164.54 255.46,158.6 256.88,157.17 256.88,136.06 255.81,134.98 255.81,131.93 257.7,130.03 257.7,114.28 255.02,111.6 255.02,104.18 248.36,97.51 246.38,97.51 243.73,94.86 243.73,87.97 242.96,87.2 240.55,84.79 240.55,80.75 240.89,80.41 v2(240.89,80.31) 241.13,80.07 241.13,74.71 238.5,72.08 238.5,70.92 237.43,69.85 v2(236.62,69.85) ; v2(73.57,182.11) 74.22,182.11 75.5,180.83 75.5,179.24 78.07,176.67 81.79,176.67 85.97,172.49 85.97,171.83 90.05,167.75 94.52,167.75 95.04,168.27 96.64,168.27 96.83,168.08 97.87,168.08 98.12,168.33 101.79,168.33 102.6,167.51 108.9,167.51 111.39,165.03 111.39,163.86 111.93,163.31 111.93,161.47 112.37,161.04 114.81,161.04 115.92,162.14 120.64,162.14 121.17,162.67 137.56,162.67 137.71,162.82 140.41,162.82 140.54,162.69 140.98,162.25 146.78,162.25 148.94,164.41 153.76,164.41 156.54,167.19 156.54,167.97 155.95,168.56 155.95,169.21 156.65,169.91 156.65,170.45 158.91,172.71 159.73,172.71 160.44,173.41 162.37,175.35 167.04,175.35 167.94,176.25 170.04,176.25 171.84,178.05 v2(171.84,178.12)
  IN4 w0.102: v2(236.62,69.85) 236.62,69.57 239.94,66.26 239.94,60.68 240.9,59.72 240.9,58.39 239.58,57.07 v2(239.58,57.01) ; v2(171.84,178.12) 170.56,176.83 170.56,169.86 v2(172.08,168.34)
  BOTTOM w0.102: v2(279.48,59.23) 279.38,59.23 277.71,57.56 274.19,57.56 v1(272.97,56.34) 272.11,55.47 v2(272.11,55.38)
MODULE_BATT_PRES#_C2: length 5.7
  TOP w0.102: v1(169.38,175.21) 169.38,175.09 168.72,174.43 167.88,174.43 PR871.1
  TOP w0.203: PU808.11 166.15,173.62 PR871.1
MODULE_ON: length 391.5
  TOP w0.102: v2(265.54,55.93) 265.53,55.93 265.16,56.3 265.16,56.88 265.19,56.91 U46.B32
  TOP w0.254: PR867.2 168.37,175.91 171.06,178.6 174.21,178.6 174.48,178.32 174.48,176.3 176.11,174.68 v2(176.55,174.68) ; v2(71.31,181.42) 70.58,180.7 59.72,180.7 59.61,180.8 56.5,180.8 55.69,181.61 51.72,181.61 51.16,182.17 PU802.2 51.16,184.99 50.76,185.39 50.25,185.39 49.67,185.98 48.89,185.98 v1(48.89,185.99) 48.62,186.26 PU803.2
  IN3 w0.127: v2(71.31,181.42) 71.31,177.95 74.6,174.66 81.31,174.66 83.39,172.59 83.39,170.52 86.82,167.09 88.43,167.09 89.73,165.79 101.59,165.79 101.89,165.49 108.76,165.49 109.51,164.74 109.51,161.3 111.29,159.51 115.61,159.51 116.07,159.97 117.83,159.97 118.03,160.17 123.36,160.17 123.82,159.71 127.4,159.71 128.37,160.68 135.04,160.68 135.31,160.95 138.46,160.95 138.81,161.29 139.76,161.29 140.37,160.68 147.36,160.68 148.39,161.71 155.24,161.71 156.31,162.78 156.7,162.78 158.77,164.84 158.77,169.64 159.13,170 165.38,170 166.12,170.75 166.12,171.09 169.25,174.22 176.1,174.22 v2(176.55,174.68) 176.67,174.79 178.01,174.79 178.49,174.31 179.44,174.31 179.6,174.47 183.08,174.47 183.35,174.21 187.86,174.21 188.04,174.38 192.05,174.38 193.25,175.59 193.81,175.59 194.43,174.97 200.07,174.97 200.41,174.62 213.96,174.62 214.07,174.74 217.93,174.74 219.63,176.44 221.43,178.24 225.06,178.24 225.06,178.24 225.27,178.24 225.27,178.24 225.53,178.24 225.97,177.8 233.21,177.8 234.87,177.8 237.63,180.56 247.71,180.56 248.18,180.08 251.58,180.08 252.14,179.52 259.19,179.52 262,176.71 262.58,176.71 263.37,175.91 263.37,174.15 263.56,173.96 263.56,150.99 264.49,150.06 264.49,145.98 266.68,143.78 266.68,142.27 267.89,141.06 267.89,139.42 268.42,138.88 268.42,128 268.18,127.76 268.18,125.76 268.78,125.15 268.78,118.88 269.57,118.09 269.57,100.96 269.4,100.8 269.4,98.4 271.63,96.17 271.63,92.89 270.3,91.56 270.3,76.29 268.38,74.37 268.38,73.49 266.63,71.73 266.63,65.54 265.12,64.04 265.12,61.72 264.6,61.2 264.6,57.2 265.12,56.68 265.12,56.35 v2(265.54,55.93)
MODULE_ON_C2: length 3.7
  TOP w0.203: PR867.1 v1(166.37,174.85) 166.37,174.33 166.06,174.02 PU808.12
MSATA_PRX_WANTX_N4_RP: length 2.7
  TOP w0.102: C393.2 323.99,134.33 323.99,134.07 323.88,133.97 323.58,133.97 323.3,133.69 323.3,133.49 323.11,133.3 U7.12
MSATA_PRX_WANTX_N4_RP_C: length 92.7
  TOP w0.102: C393.1 323.66,135.57 323.93,135.57 324.08,135.72 324.08,136.34 323.8,136.62 v2(323.79,136.62)
  IN4 w0.114: v2(338.84,209.48) 338.5,209.13 338.5,204.06 336.18,201.75 336.18,194.3 334.54,192.65 334.54,184.75 335.8,183.49 335.8,176.75 334.88,175.83 334.88,169.43 334.6,169.15 334.6,167.83 334.35,167.58 334.35,167.2 331.13,163.98 331.13,158.95 324.37,152.18 324.37,149.37 319.21,144.22 319.21,135.93 320.05,135.09 323.4,135.09 324.15,135.84 324.15,136.26 323.79,136.61 v2(323.79,136.62)
  BOTTOM w0.102: JMINI1.25 338.95,210.23 338.66,209.93 338.66,209.67 v2(338.84,209.48)
MSATA_PRX_WANTX_P4_RP: length 2.7
  TOP w0.102: U7.11 323.61,133.3 323.51,133.4 323.51,133.61 323.67,133.76 323.97,133.76 324.2,133.99 324.2,134.34 C394.2
MSATA_PRX_WANTX_P4_RP_C: length 92.7
  TOP w0.102: C394.1 324.29,135.95 324.29,136.53 v2(324.38,136.62)
  IN4 w0.114: v2(324.38,136.62) 324.38,136.55 324.38,136.54 324.38,135.74 323.5,134.86 319.95,134.86 318.98,135.83 318.98,144.31 324.14,149.47 324.14,152.28 330.9,159.04 330.9,164.08 334.12,167.3 334.12,167.67 334.37,167.92 334.37,169.25 334.65,169.53 334.65,175.93 335.57,176.85 335.57,183.39 334.31,184.66 334.31,192.75 335.96,194.39 335.96,201.84 338.27,204.15 338.27,209.45 v2(338.24,209.48)
  BOTTOM w0.102: v2(338.24,209.48) 338.44,209.68 338.44,209.9 338.15,210.19 JMINI1.23
MSATA_PTX_WANRX_N4_RP: length 2.7
  TOP w0.102: C410.2 321.33,134.31 321.33,134.14 321.49,133.97 321.74,133.97 321.97,133.75 321.97,133.47 322.11,133.33 U7.14
MSATA_PTX_WANRX_N4_RP_C: length 91.4
  TOP w0.102: C410.1 321.47,135.93 321.47,136.56 v2(321.53,136.62)
  IN4 w0.114: v2(341.45,209.44) 341.46,209.42 341.46,208.05 341.35,207.94 340.6,207.94 340.34,207.68 340.34,207.17 340.6,206.91 341.35,206.91 341.46,206.79 341.46,206.45 341.35,206.34 340.63,206.34 340.37,206.08 340.37,205.57 340.63,205.31 341.35,205.31 341.46,205.19 341.46,203.55 336.81,198.89 336.81,193.83 336.06,193.09 336.06,184.88 336.43,184.52 336.43,176.48 335.52,175.57 335.52,169.17 335.24,168.89 335.24,167.54 335.09,167.39 335.09,167.04 331.76,163.72 331.76,158.64 325.33,152.21 325.33,149.39 319.87,143.93 319.87,136.33 320.4,135.8 321.19,135.8 321.5,136.11 321.5,136.58 v2(321.53,136.62)
  BOTTOM w0.102: JMINI1.31 341.35,210.23 341.63,209.96 341.63,209.62 v2(341.45,209.44)
