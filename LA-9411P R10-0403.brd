# Allegro board LA-9411P R10-0403.brd (continued)
## Nets (continued)
DDR_B_DQS2: JCPU1.AP6 JDIMM2.47
DDR_B_DQS3: JCPU1.AK3 JDIMM2.64
DDR_B_DQS4: JCPU1.M3 JDIMM2.137
DDR_B_DQS5: JCPU1.H8 JDIMM2.154
DDR_B_DQS6: JCPU1.C9 JDIMM2.171
DDR_B_DQS7: JCPU1.C15 JDIMM2.188
DDR_B_DQS#0: JCPU1.AP18 JDIMM2.10
DDR_B_DQS#1: JCPU1.AP11 JDIMM2.27
DDR_B_DQS#2: JCPU1.AP5 JDIMM2.45
DDR_B_DQS#3: JCPU1.AJ3 JDIMM2.62
DDR_B_DQS#4: JCPU1.L3 JDIMM2.135
DDR_B_DQS#5: JCPU1.H9 JDIMM2.152
DDR_B_DQS#6: JCPU1.C8 JDIMM2.169
DDR_B_DQS#7: JCPU1.C14 JDIMM2.186
DDR_B_MA0: JCPU1.R8 JDIMM2.98
DDR_B_MA1: JCPU1.Y5 JDIMM2.97
DDR_B_MA2: JCPU1.Y10 JDIMM2.96
DDR_B_MA3: JCPU1.AA5 JDIMM2.95
DDR_B_MA4: JCPU1.Y7 JDIMM2.92
DDR_B_MA5: JCPU1.AA6 JDIMM2.91
DDR_B_MA6: JCPU1.Y6 JDIMM2.90
DDR_B_MA7: JCPU1.AA7 JDIMM2.86
DDR_B_MA8: JCPU1.Y8 JDIMM2.89
DDR_B_MA9: JCPU1.AA10 JDIMM2.85
DDR_B_MA10: JCPU1.R9 JDIMM2.107
DDR_B_MA11: JCPU1.Y9 JDIMM2.84
DDR_B_MA12: JCPU1.AF7 JDIMM2.83
DDR_B_MA13: JCPU1.P9 JDIMM2.119
DDR_B_MA14: JCPU1.AA8 JDIMM2.80
DDR_B_MA15: JCPU1.AG7 JDIMM2.78
DDR_B_RAS#: JCPU1.R6 JDIMM2.110
DDR_B_WE#: JCPU1.P6 JDIMM2.113
DDR_CKE0_DIMMA: JCPU1.AD9 JDIMM1.73
DDR_CKE1_DIMMA: JCPU1.AC9 JDIMM1.74
DDR_CKE2_DIMMB: JCPU1.AF10 JDIMM2.73
DDR_CKE3_DIMMB: JCPU1.AG10 JDIMM2.74
DDR_CS0_DIMMA#: JCPU1.M7 JDIMM1.114
DDR_CS1_DIMMA#: JCPU1.L9 JDIMM1.121
DDR_CS2_DIMMB#: JCPU1.P4 JDIMM2.114
DDR_CS3_DIMMB#: JCPU1.R2 JDIMM2.121
DDR_HVREF_RST_PCH: CD45.1 QD6.2 QD6.5 QD7.2 QD9.2 RC104.2 RH170.2 UH1.N8
DDR_XDP_SMBCLK_R1: JXDP1.53 RC26.2
DDR_XDP_SMBDAT_R1: JXDP1.51 RC25.2
DDR_XDP_WAN_SMBCLK: JDIMM1.202 JDIMM2.202 QH4.1 R502.2 RC26.1 RH31.1 U27.13 U88.4
DDR_XDP_WAN_SMBCLK_R2: JXDP2.53 RH31.2
DDR_XDP_WAN_SMBDAT: JDIMM1.200 JDIMM2.200 QH4.4 R501.2 RC25.1 RH30.1 U27.14 U88.6
DDR_XDP_WAN_SMBDAT_R2: JXDP2.51 RH30.2
DE_A: R554.2 R1686.1 U7.7
DE_B: R550.2 R1685.1 U7.8
DEFAULT_OVRDE: PR856.1 U46.A16
DEFAULT_OVRDE_C2: PR856.2 PU808.7
DEVICE_DET#: JSATA2.8 R1070.2 R1125.2
DEVICE_DET_R#: R1070.1 U51.B1
DGPU_HOLD_RST#: RV33.2 UH1.A12 UV14.1
DGPU_PEX_RST: D71.1 RV18.1 RV29.2 UV14.4
DGPU_PEX_RST_R: RV18.2 UV1.AA30
DGPU_PWR_EN: PC679.1 PR600.1 PR681.1 PR688.1 PR696.2 U103.5
DGPU_PWR_EN#: QV5.3 QV6.2 RH328.2 RV82.2 UH1.C12
DGPU_PWR_EN#_Q: PQ610.2 PR697.1 QV2.2 QV5.1 QV6.1 QV11.2 RV81.1
DGPU_PWROK: PR629.1 RH215.1 U46.A56 UH1.C14
DH_1.35V: PQ201.4 PU200.17
DIMM1_SA0: JDIMM1.197 RD6.2
DIMM1_SA1: JDIMM1.201 RD7.2
DIMM2_SA0: JDIMM2.197 RD11.1
DIMM2_SA1: JDIMM2.201 RD12.1
DIS_BAT_PROCHOT#: PR812.1 U46.B51
DISP_ON: D64.1 D69.1 JLVDS1.9 R1138.1
DK_AC_OFF: PD817.3 PU800.25
DK_AC_OFF_EN: PR857.1 PU800.22
DK_CSS_GC: PR709.2 PU800.11
DK_PWRBAR: PR832.2 PU800.33
DL_1.35V: PQ203.4 PU200.15
DMI_CRX_PTX_N0: JCPU1.D21 UH1.BD21
DMI_CRX_PTX_N1: JCPU1.C21 UH1.BE20
DMI_CRX_PTX_N2: JCPU1.B21 UH1.BD17
DMI_CRX_PTX_N3: JCPU1.A21 UH1.BE18
DMI_CRX_PTX_P0: JCPU1.D20 UH1.BB21
DMI_CRX_PTX_P1: JCPU1.C20 UH1.BC20
DMI_CRX_PTX_P2: JCPU1.B20 UH1.BB17
DMI_CRX_PTX_P3: JCPU1.A20 UH1.BC18
DMI_CTX_PRX_N0: JCPU1.D18 UH1.AW22
DMI_CTX_PRX_N1: JCPU1.C17 UH1.AR20
DMI_CTX_PRX_N2: JCPU1.B17 UH1.AP17
DMI_CTX_PRX_N3: JCPU1.A17 UH1.AV20
DMI_CTX_PRX_P0: JCPU1.D17 UH1.AY22
DMI_CTX_PRX_P1: JCPU1.C18 UH1.AP20
DMI_CTX_PRX_P2: JCPU1.B18 UH1.AR17
DMI_CTX_PRX_P3: JCPU1.A18 UH1.AW20
DMI_IREF: RH98.1 UH1.BE16
DMI_RCOMP: RH100.2 UH1.AY17
DMIC0: C1207.1 D8.3 JCAM1.7 U74.4
DMIC_CLK: C989.1 C1206.1 D8.2 JCAM1.5 LE3.2
DMIC_CLK_L: LE3.1 U74.2
DOCK_AC_OFF: JDOCK1.2 PD817.1 PR844.1
DOCK_AC_OFF_EC: PR857.2 PR858.1 U46.A63
DOCK_DCIN_IS+: JDOCK1.134 PQ703.6
DOCK_DCIN_IS-: JDOCK1.136 PQ703.4
DOCK_DET#: D32.2 PQ817.2 PR886.2 PR887.2 PU809.2 R755.1 U46.B41
DOCK_DET_R#: D32.1 JDOCK1.142 JDOCK1.144
DOCK_HP_DET: Q106.2 R1081.2 U46.A7
DOCK_LOM_ACTLED_YEL#: JDOCK1.100 U32.19
DOCK_LOM_SPD10LED_GRN#: JDOCK1.3 U32.40
DOCK_LOM_SPD100LED_ORG#: JDOCK1.4 U32.20
DOCK_LOM_TRD0+: JDOCK1.104 U32.36
DOCK_LOM_TRD0-: JDOCK1.106 U32.35
DOCK_LOM_TRD1+: JDOCK1.110 U32.32
DOCK_LOM_TRD1-: JDOCK1.112 U32.31
DOCK_LOM_TRD2+: JDOCK1.122 U32.27
DOCK_LOM_TRD2-: JDOCK1.124 U32.26
DOCK_LOM_TRD3+: JDOCK1.128 U32.23
DOCK_LOM_TRD3-: JDOCK1.130 U32.22
DOCK_MIC_DET: Q106.5 R1082.2 U46.B8
DOCK_POR_RST#: C737.1 JDOCK1.140 R881.2 U51.A21
DOCK_PSID: JDOCK1.135 PU1.1
DOCK_PWR_BTN#: C733.1 JDOCK1.139 R825.2
DOCK_PWR_SW#: C734.1 R819.2 R825.1 U51.A63
DOCK_SMB_ALERT#: JDOCK1.133 PD819.2 PQ7.3 PR852.2 R762.2 U46.A51
DOCK_SMB_ALERT#_C2: PR852.1 PU808.18
DOCK_SMB_CLK: JDOCK1.127 R841.2 U51.B4
DOCK_SMB_DAT: JDOCK1.129 R838.2 U51.A3
DOCKED: U32.13 U46.A38
DP_HDMI_HPD: R1154.2 T130.1(TP-1) U46.B4
DPC_CA_DET: JDOCK1.6 Q5.2 R492.2 U20.1 U20.4 U21.2
DPC_CA_DET#: Q5.1 R415.2 U20.10 U20.13 U21.4
DPC_CPU_LANE_N0: C680.1 JCPU1.T34
DPC_CPU_LANE_N0_C: C680.2 RE18.2
DPC_CPU_LANE_N1: C684.1 JCPU1.U35
DPC_CPU_LANE_N1_C: C684.2 RE20.2
DPC_CPU_LANE_N2: C686.1 JCPU1.U32
DPC_CPU_LANE_N2_C: C686.2 RE22.2
DPC_CPU_LANE_N3: C694.1 JCPU1.U33
DPC_CPU_LANE_N3_C: C694.2 RE24.2
DPC_CPU_LANE_P0: C691.1 JCPU1.U34
DPC_CPU_LANE_P0_C: C691.2 RE17.2
DPC_CPU_LANE_P1: C682.1 JCPU1.V35
DPC_CPU_LANE_P1_C: C682.2 RE19.2
DPC_CPU_LANE_P2: C693.1 JCPU1.T32
DPC_CPU_LANE_P2_C: C693.2 RE21.2
DPC_CPU_LANE_P3: C688.1 JCPU1.V33
DPC_CPU_LANE_P3_C: C688.2 RE23.2
DPC_DOCK_AUX: JDOCK1.34 U20.3 U20.11
DPC_DOCK_AUX#: JDOCK1.36 U20.6 U20.8
DPC_DOCK_LANE_N0: JDOCK1.12 RE18.1
DPC_DOCK_LANE_N1: JDOCK1.18 RE20.1
DPC_DOCK_LANE_N2: JDOCK1.24 RE22.1
DPC_DOCK_LANE_N3: JDOCK1.30 RE24.1
DPC_DOCK_LANE_P0: JDOCK1.10 RE17.1
DPC_DOCK_LANE_P1: JDOCK1.16 RE19.1
DPC_DOCK_LANE_P2: JDOCK1.22 RE21.1
DPC_DOCK_LANE_P3: JDOCK1.28 RE23.1
DPC_PCH_DOCK_AUX: C357.2 UH1.K45
DPC_PCH_DOCK_AUX#: C360.2 UH1.K43
DPC_PCH_DOCK_AUX#_C: C360.1 U20.5
DPC_PCH_DOCK_AUX_C: C357.1 U20.2
DPC_PCH_DOCK_HPD: C696.1 JDOCK1.40 R758.1 UH1.K38
DPD_CA_DET: JDOCK1.5 Q6.2 R491.2 U23.1 U23.4 U24.2
DPD_CA_DET#: Q6.1 R416.2 U23.10 U23.13 U24.4
DPD_CPU_LANE_N0: C679.2 JCPU1.P29
DPD_CPU_LANE_N0_C: C679.1 RE8.2
DPD_CPU_LANE_N1: C683.2 JCPU1.N28
DPD_CPU_LANE_N1_C: C683.1 RE10.2
DPD_CPU_LANE_N2: C685.2 JCPU1.P31
DPD_CPU_LANE_N2_C: C685.1 RE14.2
DPD_CPU_LANE_N3: C689.2 JCPU1.N30
DPD_CPU_LANE_N3_C: C689.1 RE16.2
DPD_CPU_LANE_P0: C690.2 JCPU1.R29
DPD_CPU_LANE_P0_C: C690.1 RE7.2
DPD_CPU_LANE_P1: C681.2 JCPU1.P28
DPD_CPU_LANE_P1_C: C681.1 RE9.2
DPD_CPU_LANE_P2: C692.2 JCPU1.R31
DPD_CPU_LANE_P2_C: C692.1 RE13.2
DPD_CPU_LANE_P3: C687.2 JCPU1.P30
DPD_CPU_LANE_P3_C: C687.1 RE15.2
DPD_DOCK_AUX: JDOCK1.33 U23.3 U23.11
DPD_DOCK_AUX#: JDOCK1.35 U23.6 U23.8
DPD_DOCK_LANE_N0: JDOCK1.11 RE8.1
DPD_DOCK_LANE_N1: JDOCK1.17 RE10.1
DPD_DOCK_LANE_N2: JDOCK1.23 RE14.1
DPD_DOCK_LANE_N3: JDOCK1.29 RE16.1
DPD_DOCK_LANE_P0: JDOCK1.9 RE7.1
DPD_DOCK_LANE_P1: JDOCK1.15 RE9.1
DPD_DOCK_LANE_P2: JDOCK1.21 RE13.1
DPD_DOCK_LANE_P3: JDOCK1.27 RE15.1
DPD_PCH_DOCK_AUX: C367.2 UH1.J44
DPD_PCH_DOCK_AUX#: C368.2 UH1.J42
DPD_PCH_DOCK_AUX#_C: C368.1 U23.5
DPD_PCH_DOCK_AUX_C: C367.1 U23.2
DPD_PCH_DOCK_HPD: C695.1 JDOCK1.39 R757.1 UH1.H39
DPRSLPVR_R: PR616.2 PU600.39
DQA0_0: UV1.C37 UV5.N11
DQA0_1: UV1.C35 UV5.T13
DQA0_2: UV1.A35 UV5.N13
DQA0_3: UV1.E34 UV5.M11
DQA0_4: UV1.G32 UV5.M13
DQA0_5: UV1.D33 UV5.U11
DQA0_6: UV1.F32 UV5.T11
DQA0_7: UV1.E32 UV5.U13
DQA0_8: UV1.D31 UV4.F4
DQA0_9: UV1.F30 UV4.E4
DQA0_10: UV1.C30 UV4.F2
DQA0_11: UV1.A30 UV4.E2
DQA0_12: UV1.F28 UV4.B2
DQA0_13: UV1.C28 UV4.B4
DQA0_14: UV1.A28 UV4.A2
DQA0_15: UV1.E28 UV4.A4
DQA0_16: UV1.D27 UV4.M11
DQA0_17: UV1.F26 UV4.M13
DQA0_18: UV1.C26 UV4.N13
DQA0_19: UV1.A26 UV4.N11
DQA0_20: UV1.F24 UV4.T13
DQA0_21: UV1.C24 UV4.U13
DQA0_22: UV1.A24 UV4.U11
DQA0_23: UV1.E24 UV4.T11
DQA0_24: UV1.C22 UV5.A4
DQA0_25: UV1.A22 UV5.B4
DQA0_26: UV1.F22 UV5.B2
DQA0_27: UV1.D21 UV5.A2
DQA0_28: UV1.A20 UV5.E4
DQA0_29: UV1.F20 UV5.F4
DQA0_30: UV1.D19 UV5.E2
DQA0_31: UV1.E18 UV5.F2
DQA1_0: UV1.C18 UV6.F4
DQA1_1: UV1.A18 UV6.F2
DQA1_2: UV1.F18 UV6.E2
DQA1_3: UV1.D17 UV6.E4
DQA1_4: UV1.A16 UV6.B2
DQA1_5: UV1.F16 UV6.A2
DQA1_6: UV1.D15 UV6.B4
DQA1_7: UV1.E14 UV6.A4
DQA1_8: UV1.F14 UV3.N11
DQA1_9: UV1.D13 UV3.U11
DQA1_10: UV1.F12 UV3.T11
DQA1_11: UV1.A12 UV3.U13
DQA1_12: UV1.D11 UV3.T13
DQA1_13: UV1.F10 UV3.N13
DQA1_14: UV1.A10 UV3.M11
DQA1_15: UV1.C10 UV3.M13
DQA1_16: UV1.G13 UV3.B2
DQA1_17: UV1.H13 UV3.A4
DQA1_18: UV1.J13 UV3.B4
DQA1_19: UV1.H11 UV3.A2
DQA1_20: UV1.G10 UV3.E2
DQA1_21: UV1.G8 UV3.E4
DQA1_22: UV1.K9 UV3.F4
DQA1_23: UV1.K10 UV3.F2
DQA1_24: UV1.G9 UV6.T13
DQA1_25: UV1.A8 UV6.N11
DQA1_26: UV1.C8 UV6.M13
DQA1_27: UV1.E8 UV6.M11
DQA1_28: UV1.A6 UV6.N13
DQA1_29: UV1.C6 UV6.T11
DQA1_30: UV1.E6 UV6.U13
DQA1_31: UV1.A5 UV6.U11
DQB0_0: UV1.C5 UV7.T13
DQB0_1: UV1.C3 UV7.N13
DQB0_2: UV1.E3 UV7.M13
DQB0_3: UV1.E1 UV7.N11
DQB0_4: UV1.F1 UV7.M11
DQB0_5: UV1.F3 UV7.T11
DQB0_6: UV1.F5 UV7.U11
DQB0_7: UV1.G4 UV7.U13
DQB0_8: UV1.H5 UV8.E4
DQB0_9: UV1.H6 UV8.F4
DQB0_10: UV1.J4 UV8.F2
DQB0_11: UV1.K6 UV8.E2
DQB0_12: UV1.K5 UV8.A4
DQB0_13: UV1.L4 UV8.A2
DQB0_14: UV1.M6 UV8.B2
DQB0_15: UV1.M1 UV8.B4
DQB0_16: UV1.M3 UV8.M11
DQB0_17: UV1.M5 UV8.M13
DQB0_18: UV1.N4 UV8.N13
DQB0_19: UV1.P6 UV8.N11
DQB0_20: UV1.P5 UV8.T13
DQB0_21: UV1.R4 UV8.U13
DQB0_22: UV1.T6 UV8.U11
DQB0_23: UV1.T1 UV8.T11
DQB0_24: UV1.U4 UV7.A4
DQB0_25: UV1.V6 UV7.B4
DQB0_26: UV1.V1 UV7.B2
DQB0_27: UV1.V3 UV7.A2
DQB0_28: UV1.Y6 UV7.E4
DQB0_29: UV1.Y1 UV7.F4
DQB0_30: UV1.Y3 UV7.E2
DQB0_31: UV1.Y5 UV7.F2
DQB1_0: UV1.AA4 UV10.F4
DQB1_1: UV1.AB6 UV10.F2
DQB1_2: UV1.AB1 UV10.E2
DQB1_3: UV1.AB3 UV10.E4
DQB1_4: UV1.AD6 UV10.A2
DQB1_5: UV1.AD1 UV10.B2
DQB1_6: UV1.AD3 UV10.B4
DQB1_7: UV1.AD5 UV10.A4
DQB1_8: UV1.AF1 UV9.N11
DQB1_9: UV1.AF3 UV9.U11
DQB1_10: UV1.AF6 UV9.T11
DQB1_11: UV1.AG4 UV9.U13
DQB1_12: UV1.AH5 UV9.T13
DQB1_13: UV1.AH6 UV9.N13
DQB1_14: UV1.AJ4 UV9.M11
DQB1_15: UV1.AK3 UV9.M13
DQB1_16: UV1.AF8 UV9.B4
DQB1_17: UV1.AF9 UV9.A4
DQB1_18: UV1.AG8 UV9.A2
DQB1_19: UV1.AG7 UV9.B2
DQB1_20: UV1.AK9 UV9.E2
DQB1_21: UV1.AL7 UV9.F4
DQB1_22: UV1.AM8 UV9.F2
DQB1_23: UV1.AM7 UV9.E4
DQB1_24: UV1.AK1 UV10.N11
DQB1_25: UV1.AL4 UV10.M11
DQB1_26: UV1.AM6 UV10.M13
DQB1_27: UV1.AM1 UV10.N13
DQB1_28: UV1.AN4 UV10.T11
DQB1_29: UV1.AP3 UV10.U13
DQB1_30: UV1.AP1 UV10.T13
DQB1_31: UV1.AP5 UV10.U11
DRAM_RST#: RV177.2 RV179.1 UV3.J2 UV4.J2 UV5.J2 UV6.J2 UV7.J2 UV8.J2 UV9.J2 UV10.J2
DRAM_RST#_R: RV178.2 RV180.2 UV1.AH11
DSCHRG_MOSFET_GC: PR893.2 PU800.29
DSWODVREN: RH67.1 RH81.2 UH1.C8
DVPDATA_0: T109.1(TP-1) UV1.AU1
DVPDATA_1: T110.1(TP-1) UV1.AU3
DVPDATA_2: T111.1(TP-1) UV1.AW3
DYN_TUR_CURRNT_SET#: PQ709.2 R1171.2 U51.A35
DYN_TURB_PWR_ALRT#: R796.2 U46.A46
EC5048_TX: JDEG2.9 JMINI2.17 R806.1 R849.2 U46.B2
EC_32KHZ_ECE5048: U46.B35 U51.B62
EC_WAKE#: RH196.1 RH216.1 U51.B23 UH1.R11
ECE5048_PWRGD: U50.1 U51.A34
EDCA0_0: UV1.C34 UV5.R13
EDCA0_1: UV1.D29 UV4.C2
EDCA0_2: UV1.D25 UV4.R13
EDCA0_3: UV1.E20 UV5.C2
EDCA1_0: UV1.E16 UV6.C2
EDCA1_1: UV1.E12 UV3.R13
EDCA1_2: UV1.J10 UV3.C2
EDCA1_3: UV1.D7 UV6.R13
EDCB0_0: UV1.F6 UV7.R13
EDCB0_1: UV1.K3 UV8.C2
EDCB0_2: UV1.P3 UV8.R13
EDCB0_3: UV1.V5 UV7.C2
EDCB1_0: UV1.AB5 UV10.C2
EDCB1_1: UV1.AH1 UV9.R13
EDCB1_2: UV1.AJ9 UV9.C2
EDCB1_3: UV1.AM5 UV10.R13
EDID_SELECT#: T121.1(TP-1) U46.B61
EDP_COMP: JCPU1.E24 RC73.2
EDP_CPU_AUX: C104.2 JCPU1.N27 R110.2
EDP_CPU_AUX#: C105.2 JCPU1.M27 R111.1
EDP_CPU_AUX#_C: C105.1 U27.3
EDP_CPU_AUX_C: C104.1 U27.4
EDP_CPU_LANE_N0: C101.2 JCPU1.P35
EDP_CPU_LANE_N0_C: C101.1 U27.8
EDP_CPU_LANE_N1: C118.2 JCPU1.N34
EDP_CPU_LANE_N1_C: C118.1 U27.10
EDP_CPU_LANE_P0: C100.2 JCPU1.R35
EDP_CPU_LANE_P0_C: C100.1 U27.7
EDP_CPU_LANE_P1: C103.2 JCPU1.P34
EDP_CPU_LANE_P1_C: C103.1 U27.9
EDP_HPD#: JCPU1.P27 QC3.1 RC74.1
EMBCLK_REQ#: JSATA2.26 RPH9.1 UH1.Y3
EN_1.5VSP: PC406.1 PR403.2 PR404.1 PR406.2 PU400.5
EN_1.8VSP: PC675.1 PR688.2 PR690.1 PU603.5
EN_+1.05VSP: PC307.1 PR303.2 PR308.2 PU300.3
EN_DK_PWRBAR: PR866.2 PR874.1 PU800.17
EN_DOCK_PWR_BAR: PR866.1 U46.B37
EN_I2S_NB_CODEC#: U46.B36 U74.48
EN_INVPWR: Q22.2 R882.2 U51.A25
EN_LCDPWR: D65.1 D73.1 R517.2 U104.3
EN_PCIE: PC665.1 PR681.2 PR682.1 PU602.5
ENVDD_PCH: RH118.2 U46.B38 U55.2 UH1.G36
ERC1: PC815.1 PU800.3
ERC2: PC817.1 PU800.13
ERC3: PC816.1 PU800.12
ESATA_USB_PWR_EN#: R769.2 U46.B44 U91.4 U93.4
EXPCLK_REQ#: JEXP1.27 RPH9.4 UH1.V3
EXPRCRD_CPPE#: CE11.1 JEXP1.28 U41.10
EXPRCRD_STBY_R#: R717.2 R734.2 U41.1
EXT_MIC: C1211.1 D82.3 JHP1.4 R58.2
FAN1_PWM: JFAN1.3 R38.2 U51.A24
FAN1_TACH_FB: JFAN1.2 R30.2 U51.B22
FB: PC523.1 PR532.1 PR533.2 PR537.2 PR543.2 PU500.8
FB2/VSEN: PC517.1 PR529.2 PR531.2 PU500.9
FB_+1.05VSP: PR306.2 PR307.2 PU300.4
FB_PCIE: PC668.2 PR683.2 PR684.1 PU602.6
FC_G6: JCPU1.G6 RC68.1 RC69.2
FDI_CSYNC: RC2.2 UH1.AL39
FDI_CSYNC_R: JCPU1.H29 RC2.1
FDI_CTX_PRX_N0: JCPU1.P33 UH1.AJ35
FDI_CTX_PRX_N1: JCPU1.N32 UH1.AL35
FDI_CTX_PRX_P0: JCPU1.R33 UH1.AJ36
FDI_CTX_PRX_P1: JCPU1.P32 UH1.AL36
FDI_INT: RC3.2 UH1.AL40
FDI_INT_R: JCPU1.J29 RC3.1
FDI_IREF: RH96.2 UH1.AT45
FDI_RCOMP: RH99.2 UH1.AR44
FFS_INT2: Q29.2 U88.9 UH1.AN4
FFS_INT2_Q: JSATA1.18 Q29.3 R506.2
FFS_PCH_INT: RH106.2 UH1.M15
FWP#: R872.2 R879.2 U51.B65
GENLK_CLK: RV95.2 UV1.AD29
GENLK_VSYNC: RV96.2 UV1.AC29
GFX_CLK_REQ#: QH3.1 RH128.1 RV52.1 UH1.AF6
GFX_CLK_REQ#_R: RV52.2 UV1.AN13
GFX_MEM_VTT_EN: QV2.1 RV67.2 RV80.1 RV85.1
GFX_MEM_VTT_ON: R1583.2 T137.1(TP-1) U46.A2
GPIO_PSID_SELECT: PU1.6 U46.A6
GPIOE4: T136.1(TP-1) U46.B45
GPU_7_BLON: RV113.2 UV1.AK17
GPU_DAC_RESET: RV69.1 UV1.AB34
GPU_GPIO1: T123.1(TP-1) UV1.AH18
GPU_GPIO2: T124.1(TP-1) UV1.AN16
GPU_GPIO6: RV64.2 UV1.AJ17
GPU_GPIO10: RV40.2 UV1.AJ16
GPU_GPIO11: T125.1(TP-1) UV1.AK16
GPU_GPIO12: RV2.2 UV1.AL16
GPU_GPIO13: T127.1(TP-1) UV1.AM16
GPU_GPIO14: T128.1(TP-1) UV1.AM14
GPU_GPIO15: RV38.2 UV1.AM13
GPU_GPIO16: RV37.2 UV1.AK14
GPU_GPIO19: T129.1(TP-1) UV1.AN14
GPU_GPIO20: RV39.2 UV1.AL13
GPU_GPIO21: RV102.2 UV1.AJ14
GPU_GPIO29: T126.1(TP-1) UV1.AG32
GPU_GPIO30: T138.1(TP-1) UV1.AG33
GPU_HOT#: CV358.1 PR633.2 QV8.1 RV76.2 RV103.2 UV1.AH17
GPU_JTAG_TCK: RV88.2 UV1.AK23
GPU_JTAG_TDI: RV86.2 UV1.AN23
GPU_JTAG_TDO: RV141.2 UV1.AM24
GPU_JTAG_TMS: RV87.2 UV1.AL24
GPU_JTAG_TRSTB: RV97.2 UV1.AM23
GPU_PANEL_ON: RV62.1 UV1.AJ27
GPU_PSI#: PR631.1 RV79.2 UV1.AH20
GPU_PWM: RV63.1 UV1.AK27
GPU_PWR_LEVEL: RV76.1 U46.A52
GPU_ROMCSB: T120.1(TP-1) UV1.AK13
GPU_ROMSI: T119.1(TP-1) UV1.AH15
GPU_ROMSO: T118.1(TP-1) UV1.AJ13
GPU_SMBCLK: R822.2 U51.B49
GPU_SMBDAT: R829.2 U51.B48
GPU_THERMAL_INT: RV53.1 UV1.AG30
GPU_VDD_SENSE: PR650.1 UV1.AF28
GPU_VGA_B: RV71.1 UV1.AF37
GPU_VGA_DDCCLK: RV74.1 UV1.AJ30
GPU_VGA_DDCDAT: RV75.1 UV1.AJ31
GPU_VGA_G: RV70.1 UV1.AE36
GPU_VGA_HSYNC: RV72.1 UV1.AC36
GPU_VGA_R: RV54.1 UV1.AD39
GPU_VGA_VSYNC: RV73.1 UV1.AC38
GPU_VID0: PR610.2 PR611.1 PR628.2 PU600.32
GPU_VID1: PR608.1 PR609.2 PR625.2 PU600.33
GPU_VID2: PR605.2 PR606.1 PR621.2 PU600.34
GPU_VID3: PR603.2 PR604.1 PR618.2 PU600.35
GPU_VID4: PR601.2 PR602.1 PR617.2 PU600.36
GPU_VID_0: PR628.1 RV2.1
GPU_VID_1: PR625.1 RV37.1
GPU_VID_2: PR621.1 RV38.1
GPU_VID_3: PR618.1 RV39.1
GPU_VID_4: PR617.1 RV40.1
GPU_VSS_SENSE: PR657.1 UV1.AH29
GREEN_CRT: JBTB1.19 U6.25
GREEN_DOCK: JDOCK1.59 U6.24
H_CATERR#: JCPU1.AN32 RC28.2
H_CPU_RSVD: JCPU1.G26 RC82.1
H_CPU_SVIDALRT#: JCPU1.AM28 RC88.1
H_CPU_TESTLO: JCPU1.W34 RC80.1
H_CPUPWRGD: RC20.1 RC33.1 UH1.AV3
H_CPUPWRGD_XDP: JXDP1.39 RC20.2
H_PM_SYNC: JCPU1.AT28 T74.1(TP-1) UH1.AY3
H_PROCHOT#: PC510.1 PQ805.3 PR524.1 PR527.2 PR724.2 Q47.1 QV8.3 R1180.2 RC29.2 RC30.1
H_PROCHOT#_R: JCPU1.AM30 RC30.2
H_THERMTRIP#: Q4.3 RC27.2 RC31.1
H_THERMTRIP#_R: JCPU1.AM35 RC31.2
HDD_DET#: JSATA1.12 RH11.1 RH36.1 UH1.AT1
HDD_FALL_INT: R503.2 RH106.1 U88.11
HDMI_BUF: R79.2 R81.1 U19.14
HDMI_CEC: JHDMI1.13 R73.2
HDMI_EQ: R80.2 R82.1 U19.17
HDMI_HPD_SINK: R84.1 U19.28
HDMI_HPD_SINK_R: JHDMI1.19 R84.2
HDMI_ISET: R85.2 R87.1 U19.34
HDMI_PRE: R86.2 R88.1 U19.16
HDMI_SCL_SINK: JHDMI1.15 R69.2 U19.32
HDMI_SDA_SINK: JHDMI1.16 R70.2 U19.33
HDMIB_PCH_HPD: R75.1 U19.3 UH1.K40
HOST_DEB_TX: JDEG2.8 R853.1
HOST_DEBUG_RX: R855.2 U51.B46
HOST_DEBUG_TX: C595.1 JMINI2.16 R848.2 R853.2 U51.B44
HSYNC: RH94.2 UH1.N42
HSYNC_BUF: JBTB1.5 U6.20
HSYNC_DOCK: JDOCK1.65 U6.19
HW_GPS_DISABLE2#: JMINI1.51 R749.2 R798.2 U46.B34
I2S_BCLK: R1668.2 U74.16
I2S_DO: R1097.2 U74.17
I2S_MCLK: R1654.2 U74.15
ICLK_IREF: RH163.1 UH1.AM45
IMON: PC500.2 PR521.1 PU500.4
IMVP_PWRGD: PR519.1 PR522.1 U46.A62
IMVP_VR_ON: PR511.1 U46.B66
INT_SPK_L+: C973.1 L113.1 U74.40
INT_SPK_L-: C974.1 L114.1 U74.41
INT_SPK_R+: C975.1 L115.1 U74.44
INT_SPK_R-: C976.1 L116.1 U74.43
INT_SPKL_L+: JSPK1.1 L113.2
INT_SPKL_L-: JSPK1.2 L114.2
INT_SPKR_R+: JSPK1.3 L115.2
INT_SPKR_R-: JSPK1.4 L116.2
INTRUDER#: RH43.2 UH1.A8
IRQ_SERIRQ: RH168.2 U39.27 U46.B21 U51.A28 UH1.AL11
ISEN1: PC539.2 PR553.2 PR555.1 PR557.1 PU500.12
ISEN1_VGA: PC616.1 PR652.2 PR656.1 PU600.11
ISEN2: PC540.2 PR538.2 PR546.1 PR547.1 PU500.11
ISEN2_VGA: PC615.1 PR623.2 PR626.1 PU600.10
ISEN3: PC544.2 PR510.1 PR516.2 PR518.2 PU500.10
ISUMN: PC528.1 PC539.1 PC540.1 PC544.1 PC547.1 PH501.1 PR515.1 PR535.2 PR544.2 PR545.1 PR548.1 PR549.1 PR556.2
ISUMP: PC528.2 PC529.2 PC538.2 PR514.1 PR536.1 PR549.2 PR551.2 PR552.1 PR558.1 PU500.15
JAPS1_4: JAPS1.4 R17.2 R23.2
JAPS1_7: JAPS1.7 R24.2
JETWAY_14M: RH161.2 UH1.F39
JETWAY_CLK14M: CH80.1 RH161.1 U39.13
JTAG_CLK: JDEG2.4 RPH2.3 U51.B56
JTAG_RST#: C735.1 JTAG1.1 R836.1 R920.2 U51.A57
JTAG_TDI: JDEG2.2 RPH2.1 U51.A51
JTAG_TDO: JDEG2.5 RPH2.4 U51.B55
JTAG_TMS: JDEG2.3 RPH2.2 U51.A53
KB_DET#: JKB1.1 RH212.1 UH1.U12
LAN_ACTLED_YEL#: Q325.1 U32.17
LAN_ACTLED_YEL#_Q: Q325.6 R1166.1
LAN_DISABLE#_R: R549.2 R555.2 R557.1 U31.3 U46.B47
LAN_SMBCLK: R551.1 RH174.2 UH1.U8
LAN_SMBCLK_R: R551.2 U31.28
LAN_SMBDATA: R552.1 RH175.2 UH1.R7
LAN_SMBDATA_R: R552.2 U31.31
LAN_TEST_EN: R561.1 U31.30
LAN_TX0+: R25.1 U31.13
LAN_TX0+R: R25.2 U32.2
LAN_TX0-: R45.1 U31.14
LAN_TX0-R: R45.2 U32.3
LAN_TX1+: R46.1 U31.17
LAN_TX1+R: R46.2 U32.6
LAN_TX1-: R47.1 U31.18
LAN_TX1-R: R47.2 U32.7
LAN_TX2+: R48.1 U31.20
LAN_TX2+R: R48.2 U32.9
LAN_TX2-: R49.1 U31.21
LAN_TX2-R: R49.2 U32.10
LAN_TX3+: R50.1 U31.23
LAN_TX3+R: R50.2 U32.11
LAN_TX3-: R53.1 U31.24
LAN_TX3-R: R53.2 U32.12
LANCLK_REQ#: R1187.1 RH20.1 RH125.2 UH1.AF1
LANCLK_REQ#_R: R1187.2 U31.48
LANWAKE#: R559.1 R566.1 RH196.2 U51.B27
LANWAKE#_R: R558.2 R559.2 U31.2
LAT_ON_SW#: R870.2 U51.B63
LCD_CBL_DET#: JLVDS1.40 RPH6.4 UH1.G17
LCD_EDID_CLK: JLVDS1.35 R113.1 R160.2 U27.46
LCD_EDID_DATA: JLVDS1.34 R112.1 R159.2 U27.45
LCD_ENVDD_CVT: R115.1 U27.20 U55.1
LCD_SMBCLK: R418.2 U51.B5
LCD_SMBDAT: R420.2 U51.A4
LCD_TST: JLVDS1.36 R767.2 U46.A36
LCD_VCC_TEST_EN: D73.2 U46.A40
LED_10_GRN#: Q326.3 U32.41
LED_10_GRN#_Q: Q326.1 R1653.1
LED_100_ORG#: Q325.4 U32.18
LED_100_ORG#_Q: Q325.3 R1167.1
LED_SATA_DIAG_OUT#: D62.1 U46.A10
LED_WWAN_OUT#: JMINI1.42 Q77.3 R719.1
LG_3V: PQ103.4 PU100.11
LG_5V: PQ104.4 PU100.15
LG_+1.05VSP: PQ303.4 PU300.6
LGATE1: PQ511.4 PQ512.4 PU500.21
LGATE1_VGA: PQ606.4 PQ607.4 PU600.23
LGATE2: PQ507.4 PQ508.4 PU500.24
LGATE2_VGA: PQ602.4 PQ603.4 PU600.26
LGATE3: PQ503.4 PQ504.4 PU501.5
LID_CL#: R807.1 U1.3 U58.2
LID_CL_SIO#: C716.1 R805.2 R807.2 T141.1(TP-1) U46.B54
LOM_ACTLED_YEL#: U31.26 U32.15
LOM_SPD10LED_GRN#: U15.2 U31.25 U32.42
LOM_SPD100LED_ORG#: U15.1 U31.27 U32.16
LOOPBACK: R560.2 R1684.1 U7.13
LPC_LAD0: JMINI3.16 U39.26 U46.A27 U51.A30 UH1.A20
LPC_LAD1: JMINI3.14 U39.23 U46.A26 U51.B32 UH1.C20
LPC_LAD2: JMINI3.12 U39.20 U46.B26 U51.A31 UH1.A18
LPC_LAD3: JMINI3.10 U39.17 U46.B25 U51.B33 UH1.C18
LPC_LDRQ0#: T87.1(TP-1) UH1.D21
LPC_LDRQ1#: U46.A22 UH1.G20
LPC_LFRAME#: JMINI3.8 U39.22 U46.A21 U51.B31 UH1.B21
LX_PCIE: PL603.1 PR680.1 PU602.1 PU602.2 PU602.3
M_CLK_DDR0: JCPU1.V4 JDIMM1.101
M_CLK_DDR1: JCPU1.V3 JDIMM1.102
M_CLK_DDR2: JCPU1.AA4 JDIMM2.101
M_CLK_DDR3: JCPU1.AA3 JDIMM2.102
M_CLK_DDR#0: JCPU1.U4 JDIMM1.103
M_CLK_DDR#1: JCPU1.U3 JDIMM1.104
M_CLK_DDR#2: JCPU1.Y4 JDIMM2.103
M_CLK_DDR#3: JCPU1.Y3 JDIMM2.104
M_ODT0: JCPU1.M8 JDIMM1.116
M_ODT1: JCPU1.L7 JDIMM1.120
M_ODT2: JCPU1.R4 JDIMM2.116
M_ODT3: JCPU1.R3 JDIMM2.120
MAA0_0: UV1.G24 UV4.H4 UV5.K4
MAA0_1: UV1.J23 UV4.H5 UV5.K5
MAA0_2: UV1.H24 UV4.H11 UV5.K11
MAA0_3: UV1.J24 UV4.H10 UV5.K10
MAA0_4: UV1.H26 UV4.K11 UV5.H11
MAA0_5: UV1.J26 UV4.K10 UV5.H10
MAA0_6: UV1.H21 UV4.K5 UV5.H5
MAA0_7: UV1.G21 UV4.K4 UV5.H4
MAA0_8: UV1.H23 UV4.J5 UV5.J5
MAA1_0: UV1.H19 UV3.K4 UV6.H4
MAA1_1: UV1.H20 UV3.K5 UV6.H5
MAA1_2: UV1.L13 UV3.K11 UV6.H11
MAA1_3: UV1.G16 UV3.K10 UV6.H10
MAA1_4: UV1.J16 UV3.H11 UV6.K11
MAA1_5: UV1.H16 UV3.H10 UV6.K10
MAA1_6: UV1.J17 UV3.H5 UV6.K5
MAA1_7: UV1.H17 UV3.H4 UV6.K4
MAA1_8: UV1.J19 UV3.J5 UV6.J5
MAB0_0: UV1.P8 UV7.K4 UV8.H4
MAB0_1: UV1.T9 UV7.K5 UV8.H5
MAB0_2: UV1.P9 UV7.K11 UV8.H11
MAB0_3: UV1.N7 UV7.K10 UV8.H10
MAB0_4: UV1.N8 UV7.H11 UV8.K11
MAB0_5: UV1.N9 UV7.H10 UV8.K10
MAB0_6: UV1.U9 UV7.H5 UV8.K5
MAB0_7: UV1.U8 UV7.H4 UV8.K4
MAB0_8: UV1.T8 UV7.J5 UV8.J5
MAB1_0: UV1.Y9 UV9.K4 UV10.H4
MAB1_1: UV1.W9 UV9.K5 UV10.H5
MAB1_2: UV1.AC8 UV9.K11 UV10.H11
MAB1_3: UV1.AC9 UV9.K10 UV10.H10
MAB1_4: UV1.AA7 UV9.H11 UV10.K11
MAB1_5: UV1.AA8 UV9.H10 UV10.K10
MAB1_6: UV1.Y8 UV9.H5 UV10.K5
MAB1_7: UV1.AA9 UV9.H4 UV10.K4
MAB1_8: UV1.W8 UV9.J5 UV10.J5
MASK_BASE_LEDS#: Q74.2 Q83.2 Q83.5 Q84.2 Q100.2 U58.4
MASK_SATA_LED#: Q74.5 U46.B9
MB_MBSS_GC: PD803.1 PQ808.5 PR809.2 PR836.2
MB_MBSS_GC_C2: PR836.1 PU808.21
MCARD_MISC_PWREN: R733.1 U46.B53 U100.5
MCARD_PCIE#_SATA: Q88.1 R727.1 R747.2
MCARD_PCIE_SATA#: Q88.2 RH16.1 RH224.2 RH226.1 U46.B3 UH1.AN2
MCARD_WWAN_PWREN: R726.1 U46.B42 U101.5
MDC_RST_DIS#: Q44.2 R752.2 U46.A49
MDC_SDIN: JMDC1.9 RH362.2
ME_FWP: R793.1 RH45.1 U46.A8
ME_RESET#: RH70.1 RH93.2 UC3.2
ME_SUS_PWR_ACK: RH75.2 RH107.1 U51.A8
ME_SUS_PWR_ACK_R: RH91.1 RH107.2 UH1.J4
MEC_XTAL1: C743.1 U51.A61 Y6.1
MEC_XTAL2: C741.1 R1068.2 Y6.2
MEC_XTAL2_R: R1068.1 U51.A62
MEM_SMBCLK: QH4.6 RH167.2 UH1.R10
MEM_SMBDATA: QH4.3 RH169.2 UH1.U11
MIC1_L: C195.1 U74.19
MIC1_L_C: C195.2 R198.1
MIC1_R: C196.1 U74.20
MIC1_R_C: C196.2 R199.1
MIIC_SCL: R102.1 R113.2 U26.6
MIIC_SCL0: R102.2 R105.1 R106.2 U27.48
MIIC_SDA: R103.1 R112.2 U26.5
MIIC_SDA0: R103.2 R107.1 R108.2 U27.47
MINI1CLK_REQ#: JMINI1.7 RH122.1 UH1.AB1
MINI2CLK_REQ#: JMINI2.7 RPH9.2 UH1.AA2
MINI3CLK_REQ#: JMINI3.7 RPH8.3 UH1.T3
MMICLK_REQ#: RH22.1 RH133.2 U38.17 UH1.AF3
MOD_MD: JSATA2.11 Q76.3 Q123.4 R513.2
MOD_SATA_PCIE#_DET: JSATA2.31 Q123.2 R1183.2 U46.A42
MODC_EN: Q78.2 R512.1 U46.B7 U105.5
MODC_EN#: Q76.2 Q78.1 R509.2
MODULE_BATT_PRES#: PQ808.1 PR2.2 PR5.2 PR749.1 PR871.2 PU802.1 U46.B15
MODULE_BATT_PRES#_C2: PR871.1 PU808.11
MODULE_ON: PR867.2 PU802.2 PU803.2 U46.B32
MODULE_ON_C2: PR867.1 PU808.12
MSATA_PRX_WANTX_N4_RP: C393.2 U7.12
MSATA_PRX_WANTX_N4_RP_C: C393.1 JMINI1.25
MSATA_PRX_WANTX_P4_RP: C394.2 U7.11
MSATA_PRX_WANTX_P4_RP_C: C394.1 JMINI1.23
MSATA_PTX_WANRX_N4_RP: C410.2 U7.14
MSATA_PTX_WANRX_N4_RP_C: C410.1 JMINI1.31
MSATA_PTX_WANRX_P4_RP: C403.2 U7.15
MSATA_PTX_WANRX_P4_RP_C: C403.1 JMINI1.33
MSCLK: JDEG2.6 JMINI2.19 R847.2 U51.B43
MSDATA: JDEG2.7 JMINI2.14 R706.2 R850.2 R869.2 U51.A40
MULTIO_0: R1700.2 R1701.1 U38.18
NB_LAN_TX0+: JLOM1.1 T156.24
NB_LAN_TX0-: JLOM1.2 T156.23
NB_LAN_TX1+: JLOM1.3 T156.20
NB_LAN_TX1-: JLOM1.6 T156.19
NB_LAN_TX2+: JLOM1.4 T156.18
NB_LAN_TX2-: JLOM1.5 T156.17
NB_LAN_TX3+: JLOM1.7 T156.14
NB_LAN_TX3-: JLOM1.8 T156.13
NB_PSID: PJPDC1.5 PL4.2
NB_PSID_TS5A63157: PR11.1 PR12.2 PU1.3
NTC: PH500.1 PR528.1 PU500.6
OZ_LDO_EN: R894.2 U38.14
OZ_PE_REXT: R677.2 U38.4
P1_SW: PL503.3 PR552.2 PR553.1
P2_SW: PL502.3 PR536.2 PR538.1
P3_SW: PL501.3 PR510.2 PR514.2
P33ALW: PR868.1 PU800.18
P33ALW2: PR862.2 PU800.9
PANEL_BKEN_CVT: R1139.1 U27.44 U54.1
PANEL_BKEN_EC: D69.2 U46.A35
PANEL_BKEN_PCH: U54.2 UH1.K36
PANEL_HDD_LED: JLVDS1.8 Q81.3
PB_PBSS_GC: PR841.2 PR889.2 PR891.2
PB_PBSS_GC_C2: PR841.1 PU808.20
PBAT_PRES#: PD7.1 PQ812.1 PR6.2 PR9.2 PR865.2 PU804.1 U46.B40
PBAT_PRES#_C2: PR865.1 PU808.13
PBAT_SMBCLK: PR7.2 R820.2 U51.A56
PBAT_SMBDAT: PR8.2 R818.2 U51.B59
PCH_ALW_ON: PR21.1 R880.2 U51.A23 U103.3
PCH_AZ_BITCLK: RH64.2 RH65.2 UH1.B25
PCH_AZ_CODEC_BITCLK: CH9.1 R1076.1 RH65.1 U74.6
PCH_AZ_CODEC_RST#: R39.1 RH63.1 U74.11
PCH_AZ_CODEC_SDIN0: R1096.1 UH1.L22
PCH_AZ_CODEC_SDOUT: R1077.1 RH59.1 U74.5
PCH_AZ_CODEC_SYNC: RH61.1 U74.10
PCH_AZ_MDC_BITCLK: CH8.1 JMDC1.12 R753.2 RH64.1
PCH_AZ_MDC_RST1#: JMDC1.11 Q44.3 R751.1
PCH_AZ_MDC_RST#: Q44.1 RH62.1
PCH_AZ_MDC_SDIN1: RH362.1 UH1.K22
PCH_AZ_MDC_SDOUT: JMDC1.3 R754.2 RH58.1
PCH_AZ_MDC_SYNC: JMDC1.7 RH60.1
PCH_AZ_RST#: RH62.2 RH63.2 UH1.C24
PCH_AZ_SDIN0_R: R1096.2 U74.8
PCH_AZ_SDOUT: RH35.2 RH45.2 RH58.2 RH59.2 UH1.A24
PCH_AZ_SYNC: RH41.2 RH60.2 RH61.2 UH1.A22
PCH_BATLOW#: RH112.2 UH1.K7
PCH_CL_CLK1: JMINI2.45 UH1.AF11
PCH_CL_DATA1: JMINI2.47 UH1.AF10
PCH_CL_RST1#: R707.1 UH1.AF7
PCH_CLK_BIASREF: RH165.1 UH1.AN44
PCH_CRT_BLU: RH115.2 U6.5 UH1.T45
PCH_CRT_DDC_CLK: RH88.2 U6.10 UH1.M43
PCH_CRT_DDC_DAT: RH89.2 U6.9 UH1.M45
PCH_CRT_GRN: RH116.2 U6.2 UH1.U44
PCH_CRT_HSYNC: RH94.1 U6.6
PCH_CRT_RED: RH117.2 U6.1 UH1.V45
PCH_CRT_VSYNC: RH95.1 U6.7
PCH_DDPB_CTRLCLK: RH255.2 U19.38 UH1.R40
PCH_DDPB_CTRLDATA: RH256.2 U19.39 UH1.R39
PCH_DDPC_CTRLCLK: R1539.2 U20.12 UH1.R35
PCH_DDPC_CTRLDATA: R1530.2 U20.9 UH1.R36
PCH_DDPD_CTRLCLK: R1066.2 U23.12 UH1.N40
PCH_DDPD_CTRLDATA: R1062.2 U23.9 UH1.N38
PCH_DPWROK: R802.1 RH79.1 RH120.2 UH1.L13
PCH_GPIO3: RPH6.3 UH1.F17
PCH_GPIO06: RH257.2 UH1.A14
PCH_GPIO07: RH203.1 UH1.G15
PCH_GPIO22: R1670.1 RH198.1 RH248.1 UH1.BB4
PCH_GPIO24: RH213.1 UH1.Y10
PCH_GPIO33: RH40.2 UH1.B17
PCH_GPIO34: RH258.1 UH1.AN6
PCH_GPIO35: RH25.1 RH205.1 UH1.AP1
PCH_GPIO36: RH12.1 RH228.1 RH230.1 UH1.AT3
PCH_GPIO37: RH14.1 RH229.2 RH231.1 UH1.AK1
PCH_GPIO49: RH19.1 RH225.1 RH227.1 UH1.AK3
PCH_GPIO55: RH76.1 UH1.AL6
PCH_GPIO69: RH254.1 UH1.D13
PCH_GPIO70: RH207.1 UH1.G13
PCH_GPIO71: RH208.1 UH1.H15
PCH_INTVRMEN: RH5.2 RH18.1 UH1.G10
PCH_JTAG_RST: RH32.2 UH1.AB6
PCH_JTAG_RST_R: JXDP2.54 RH32.1
PCH_JTAG_TCK: JXDP2.57 RH47.1 UH1.AB3
PCH_JTAG_TDI: JXDP2.56 RH50.2 RH55.1 UH1.AE2
PCH_JTAG_TDO: JXDP2.52 RH52.2 RH56.1 UH1.AD3
PCH_JTAG_TMS: JXDP2.58 RH48.2 RH54.1 UH1.AD1
PCH_PCIE_IREF: RH188.2 UH1.BE30
PCH_PCIE_RCOMP: RH192.2 UH1.BD29
PCH_PCIE_WAKE#: RH78.2 RH92.2 U51.A44 UH1.K3
PCH_PLTRST#: QH2.2 RH109.2 RH110.2 RH111.2 RH113.2 RH114.2 UC2.2 UH1.Y11 UH3.1 UH3.2
PCH_PLTRST#_BUF: RC60.2 RC64.1 RC67.1 UC2.4
PCH_PLTRST#_EC: JMINI3.17 JMINI3.22 Q85.2 R703.1 R704.2 U39.16 U41.6 U46.B22 U51.B30 UH3.4
PCH_PWRBTN#_XDP: JXDP2.41 RH28.2
PCH_PWROK: RH103.2 UH1.F10
PCH_RI#: RPH8.2 UH1.N4
PCH_RSMRST#: R892.2 R1623.1 U9.1 U51.B47
PCH_RSMRST#_Q: R1623.2 R1624.1 R1636.2 R1655.2 RH26.1 RH105.1
PCH_RSMRST#_R: RH79.2 RH105.2 UH1.J2
PCH_RTCRST#: CH7.2 CMOS1.2 JAPS1.9 RH44.2 UH1.D9
PCH_RTCX1: RH38.2 RH39.1 UH1.B5
PCH_RTCX1_R: CH4.2 RH38.1 YH1.1
PCH_RTCX2: CH5.2 RH39.2 UH1.B4 YH1.2
PCH_SATA_MOD_EN#: QH2.3 U51.B36
PCH_SMB_ALERT#: RH166.2 UH1.N7
PCH_SPI_CLK: JSPI1.8 RH181.2 UH1.AJ11
PCH_SPI_CS0#: JSPI1.10 RH182.2 UH1.AJ7
PCH_SPI_CS1#: JSPI1.2 RH177.2 UH1.AL7
PCH_SPI_DIN: JSPI1.6 RH179.2 UH1.AH3
PCH_SPI_DO: JSPI1.4 RH178.2 UH1.AH1
PCH_SPI_DO2: JSPI1.12 RH183.2 UH1.AJ4
PCH_SPI_DO3: JSPI1.14 RH184.2 UH1.AJ2
PCH_TD_IREF: RH176.1 UH1.AY43
PCH_THRMTRIP#_R: CH17.1 RH206.2 UH1.AV1
PCH_TP25: RH53.2 UH1.F8
PCI_5048: RH158.1 UH1.D44
PCI_DOCK: RH162.1 UH1.B42
PCI_LOOPBACKOUT: RH164.1 UH1.A40
PCI_MEC: RH160.1 UH1.E44
PCI_PIRQA#: RPH4.1 UH1.H20
PCI_PIRQB#: RPH4.2 UH1.L20
PCI_PIRQC#: RPH4.3 UH1.K17
PCI_PIRQD#: RPH4.4 UH1.M20
PCI_TPM_TCM: RH155.2 UH1.C40
PCIE#_SATA: R747.1 R749.1 U7.17
PCIE_B+: PC660.1 PC680.1 PJP609.1 PU602.8 PU602.9 PU602.10
PCIE_PRX_EMBTX_N4: JSATA2.19 UH1.AT33
PCIE_PRX_EMBTX_P4: JSATA2.18 UH1.AR33
PCIE_PRX_EXPTX_N7: JEXP1.15 UH1.AT40
PCIE_PRX_EXPTX_P7: JEXP1.17 UH1.AT39
PCIE_PRX_GLANTX_N2: C459.2 UH1.AT31
PCIE_PRX_GLANTX_N2_C: C459.1 U31.39
PCIE_PRX_GLANTX_P2: C458.2 UH1.AR31
PCIE_PRX_GLANTX_P2_C: C458.1 U31.38
PCIE_PRX_MMITX_N8: C571.1 UH1.AN38
PCIE_PRX_MMITX_N8_C: C571.2 U38.8
PCIE_PRX_MMITX_P8: C569.1 UH1.AN39
PCIE_PRX_MMITX_P8_C: C569.2 U38.7
PCIE_PRX_WLANTX_N3: JMINI2.23 UH1.AW33
PCIE_PRX_WLANTX_P3: JMINI2.25 UH1.AY33
PCIE_PRX_WPANTX_N6: JMINI3.23 UH1.AY38
PCIE_PRX_WPANTX_P6: JMINI3.25 UH1.AW38
PCIE_PTX_EMBRX_N4: C408.2 UH1.BE36
PCIE_PTX_EMBRX_N4_C: C408.1 JSATA2.23
PCIE_PTX_EMBRX_P4: C409.2 UH1.BC36
PCIE_PTX_EMBRX_P4_C: C409.1 JSATA2.22
PCIE_PTX_EXPRX_N7: C647.1 UH1.BE40
PCIE_PTX_EXPRX_N7_C: C647.2 JEXP1.21
PCIE_PTX_EXPRX_P7: C648.1 UH1.BC40
PCIE_PTX_EXPRX_P7_C: C648.2 JEXP1.23
PCIE_PTX_GLANRX_N2: C461.1 UH1.BD33
PCIE_PTX_GLANRX_N2_C: C461.2 U31.42
PCIE_PTX_GLANRX_P2: C460.1 UH1.BB33
PCIE_PTX_GLANRX_P2_C: C460.2 U31.41
PCIE_PTX_MMIRX_N8: C568.1 UH1.BD42
PCIE_PTX_MMIRX_N8_C: C568.2 U38.5
PCIE_PTX_MMIRX_P8: C567.1 UH1.BD41
PCIE_PTX_MMIRX_P8_C: C567.2 U38.6
PCIE_PTX_WLANRX_N3: C596.1 UH1.BE34
PCIE_PTX_WLANRX_N3_C: C596.2 JMINI2.31
PCIE_PTX_WLANRX_P3: C598.1 UH1.BC34
PCIE_PTX_WLANRX_P3_C: C598.2 JMINI2.33
PCIE_PTX_WPANRX_N6: C617.1 UH1.BC38
PCIE_PTX_WPANRX_N6_C: C617.2 JMINI3.31
PCIE_PTX_WPANRX_P6: C618.1 UH1.BE38
PCIE_PTX_WPANRX_P6_C: C618.2 JMINI3.33
PCIE_SATA_PRX_WANTX_N4: C424.2 UH1.BD13
PCIE_SATA_PRX_WANTX_N4_C: C424.1 U7.4
PCIE_SATA_PRX_WANTX_P4: C422.2 UH1.BB13
PCIE_SATA_PRX_WANTX_P4_C: C422.1 U7.5
PCIE_SATA_PTX_WANRX_N4: C417.2 UH1.AV15
PCIE_SATA_PTX_WANRX_N4_C: C417.1 U7.2
PCIE_SATA_PTX_WANRX_P4: C416.2 UH1.AW15
PCIE_SATA_PTX_WANRX_P4_C: C416.1 U7.1
PCIE_VDDC_PWRGD: PR679.2 PU602.4
PCIE_WAKE#: JEXP1.14 JMINI1.1 JMINI2.1 JMINI3.1 JSATA2.27 R759.2 U38.16 U51.B38
PCIECLKRQ6#: RH197.1 UH1.AE4
PCLK_80H: JMINI3.19 RH159.1
PD#A: R3688.1 U90.5
PD#B: R3720.1 U92.5
PD#C: R3755.1 U94.5
PD#D: R3775.1 U95.5
PECI_EC: JCPU1.AR27 R952.2
PECI_EC_R: C290.1 R952.1 U51.A48
PEG_B_CLKRQ#: RPH8.4 UH1.U4
PEG_COMP: JCPU1.E23 RC1.2
PEG_CRX_GTX_C_N0: CV2.1 UV1.Y32
PEG_CRX_GTX_C_N1: CV3.1 UV1.W32
PEG_CRX_GTX_C_N2: CV6.1 UV1.U32
PEG_CRX_GTX_C_N3: CV8.1 UV1.U29
PEG_CRX_GTX_C_N4: CV10.1 UV1.T32
PEG_CRX_GTX_C_N5: CV12.1 UV1.T29
PEG_CRX_GTX_C_N6: CV15.1 UV1.P32
PEG_CRX_GTX_C_N7: CV17.1 UV1.P29
PEG_CRX_GTX_C_P0: CV1.1 UV1.Y33
PEG_CRX_GTX_C_P1: CV4.1 UV1.W33
PEG_CRX_GTX_C_P2: CV5.1 UV1.U33
PEG_CRX_GTX_C_P3: CV7.1 UV1.U30
PEG_CRX_GTX_C_P4: CV9.1 UV1.T33
PEG_CRX_GTX_C_P5: CV11.1 UV1.T30
PEG_CRX_GTX_C_P6: CV14.1 UV1.P33
PEG_CRX_GTX_C_P7: CV16.1 UV1.P30
PEG_CRX_GTX_N0: CV2.2 JCPU1.M29
PEG_CRX_GTX_N1: CV3.2 JCPU1.K28
PEG_CRX_GTX_N2: CV6.2 JCPU1.M31
PEG_CRX_GTX_N3: CV8.2 JCPU1.L30
PEG_CRX_GTX_N4: CV10.2 JCPU1.M33
PEG_CRX_GTX_N5: CV12.2 JCPU1.L32
PEG_CRX_GTX_N6: CV15.2 JCPU1.M35
PEG_CRX_GTX_N7: CV17.2 JCPU1.L34
PEG_CRX_GTX_P0: CV1.2 JCPU1.L29
PEG_CRX_GTX_P1: CV4.2 JCPU1.L28
PEG_CRX_GTX_P2: CV5.2 JCPU1.L31
PEG_CRX_GTX_P3: CV7.2 JCPU1.K30
PEG_CRX_GTX_P4: CV9.2 JCPU1.L33
PEG_CRX_GTX_P5: CV11.2 JCPU1.K32
PEG_CRX_GTX_P6: CV14.2 JCPU1.L35
PEG_CRX_GTX_P7: CV16.2 JCPU1.K34
PEG_CTX_GRX_C_N0: CC2.2 JCPU1.H35
PEG_CTX_GRX_C_N1: CC4.2 JCPU1.H34
PEG_CTX_GRX_C_N2: CC6.2 JCPU1.J33
PEG_CTX_GRX_C_N3: CC8.2 JCPU1.H32
PEG_CTX_GRX_C_N4: CC10.2 JCPU1.J31
PEG_CTX_GRX_C_N5: CC12.2 JCPU1.G30
PEG_CTX_GRX_C_N6: CC14.2 JCPU1.C33
PEG_CTX_GRX_C_N7: CC16.2 JCPU1.B32
PEG_CTX_GRX_C_P0: CC1.2 JCPU1.J35
PEG_CTX_GRX_C_P1: CC3.2 JCPU1.G34
PEG_CTX_GRX_C_P2: CC5.2 JCPU1.H33
PEG_CTX_GRX_C_P3: CC7.2 JCPU1.G32
PEG_CTX_GRX_C_P4: CC9.2 JCPU1.H31
PEG_CTX_GRX_C_P5: CC11.2 JCPU1.H30
PEG_CTX_GRX_C_P6: CC13.2 JCPU1.B33
PEG_CTX_GRX_C_P7: CC15.2 JCPU1.A32
PEG_CTX_GRX_N0: CC2.1 UV1.Y37
PEG_CTX_GRX_N1: CC4.1 UV1.W36
PEG_CTX_GRX_N2: CC6.1 UV1.V37
PEG_CTX_GRX_N3: CC8.1 UV1.U36
PEG_CTX_GRX_N4: CC10.1 UV1.T37
PEG_CTX_GRX_N5: CC12.1 UV1.R36
PEG_CTX_GRX_N6: CC14.1 UV1.P37
PEG_CTX_GRX_N7: CC16.1 UV1.N36
PEG_CTX_GRX_P0: CC1.1 UV1.AA38
PEG_CTX_GRX_P1: CC3.1 UV1.Y35
PEG_CTX_GRX_P2: CC5.1 UV1.W38
PEG_CTX_GRX_P3: CC7.1 UV1.V35
PEG_CTX_GRX_P4: CC9.1 UV1.U38
PEG_CTX_GRX_P5: CC11.1 UV1.T35
PEG_CTX_GRX_P6: CC13.1 UV1.R38
PEG_CTX_GRX_P7: CC15.1 UV1.P35
PHASE1: PC542.2 PC543.1 PL503.4 PQ509.1 PQ509.2 PQ509.3 PQ510.1 PQ510.2 PQ510.3 PQ511.5 PQ512.5 PU500.20
PHASE1_VGA: PC623.2 PL601.4 PQ604.1 PQ604.2 PQ604.3 PQ605.1 PQ605.2 PQ605.3 PQ606.5 PQ607.5 PR653.1 PU600.21
PHASE2: PC522.2 PC524.1 PL502.4 PQ505.1 PQ505.2 PQ505.3 PQ506.1 PQ506.2 PQ506.3 PQ507.5 PQ508.5 PU500.25
PHASE2_VGA: PC605.2 PL600.4 PQ600.1 PQ600.2 PQ600.3 PQ601.1 PQ601.2 PQ601.3 PQ602.5 PQ603.5 PR622.1 PU600.28
PHASE3: PC501.2 PC508.1 PL501.4 PQ501.1 PQ501.2 PQ501.3 PQ502.1 PQ502.2 PQ502.3 PQ503.5 PQ504.5 PU501.8
PLTRST_EMB#: JSATA2.28 RH113.1
PLTRST_GPU#: RH114.1 UV14.2
PLTRST_LAN#: RH111.1 U31.36
PLTRST_MMI#: RH110.1 U38.15
PLTRST_USH#: JUSH1.6 RH109.1
PM_APWROK: RH87.1 U51.A9 UH2.2
PM_APWROK_R: RH87.2 UH1.AB7 UH2.4
PM_DRAM_PWRGD: RC4.2 RC12.2 RC13.2 RH104.1
PM_DRAM_PWRGD_CPU: JCPU1.AC10 QC5.3 RC10.1
PM_DRAM_PWRGD_R: RH104.2 UH1.H3
PM_LANPHY_ENABLE: R555.1 RH217.1 UH1.K13
POWER_SW#_MB: C721.1 D23.3 JAPS1.11 R811.2 SW1.2 SW1.4
POWER_SW_IN#: C722.1 R810.2 R811.1 U51.B67
PROCHOT#_EC: Q47.2 R812.2 R1179.2 R1180.1 U51.A46
PROCHOT_AD_POTC: PQ707.3 PQ707.6 PR724.1 PR845.2 PR879.2
PROCHOT_AD_POTC_C2: PQ910.2 PR845.1 PR880.2 PU808.19
PROCHOT_GATE: PR861.2 PU704.2 R761.2 U46.A50
PROCHOT_GATE_C2: PR861.1 PU808.14
PS2_CLK_TS: JKB1.2 JTP1.7
PS2_DAT_TS: JKB1.3 JTP1.6
PS_0: CV357.1 RV243.1 RV244.2 UV1.AM34
PS_1: CV342.1 RV237.2 RV238.1 UV1.AD31
PS_2: CV340.1 RV239.2 RV240.1 UV1.AG31
PS_3: CV341.1 RV241.2 RV242.1 UV1.AD33
PS_ID: PU1.4 U51.A55
PSATA_PRX_DTX_N0_C: C385.2 UH1.BC8
PSATA_PRX_DTX_P0_C: C386.2 UH1.BE8
PSATA_PTX_DRX_N0_C: C384.2 UH1.AW8
PSATA_PTX_DRX_P0_C: C383.2 UH1.AY8
PSID_DISABLE#: PR16.2 U46.A37
PWM3: PR523.2 PU500.22 PU501.3
PWR_SRC_ON: C297.2 Q21.3 R422.2 R423.1
PWRSHARE_EN#: Q48.1 R816.1 U48.4
PX_EN: RV48.2 UV1.AL21
RASA0#: UV1.K23 UV4.G3 UV5.L3
RASA1#: UV1.K19 UV3.L3 UV6.G3
RASB0#: UV1.T10 UV7.L3 UV8.G3
RASB1#: UV1.Y10 UV9.L3 UV10.G3
RED_CRT: JBTB1.23 U6.27
RED_DOCK: JDOCK1.53 U6.26
REGCTL_PNP10: L29.1 U31.7
REM_DIODE1_N: C8.1 C285.1 Q1.3 U51.B13
REM_DIODE1_P: C8.2 C285.2 Q1.1 Q1.2 U51.A13
REM_DIODE2_N: C9.2 C283.1 Q2.3 U51.B14
REM_DIODE2_P: C9.1 C283.2 Q2.1 Q2.2 U51.A14
REM_DIODE4_N: C16.1 C286.1 Q3.3 U51.A16
REM_DIODE4_P: C16.2 C286.2 Q3.1 Q3.2 U51.B17
RES_BIAS: R562.1 U31.12
RESERVED: R564.2 R1687.1 U7.16
RESET_OUT#: R843.2 RC69.1 RH27.1 RH85.1 RH103.1 U51.B39
RESET_OUT#_R: JXDP2.46 RH27.2
REXT: R563.2 R748.1 U7.9
REXTA: R3678.2 R3686.1 U90.7
REXTB: R3708.2 R3718.1 U92.7
REXTC: R3742.1 R3744.2 U94.7
REXTD: R3757.1 R3778.2 U95.7
RF_+1.05VSP: PR305.1 PU300.5
RING2: R54.1 R1146.1 U74.28
RING2_L: C1215.1 D81.2 JHP1.3 R54.2
RSMRST#: R1622.1 R1630.1 U8.3 U9.2
RSMRST#_XDP: JXDP2.39 RH26.2
RUN_ON: PR406.1 R717.1 R744.1 R786.2 U46.A11
RUN_ON_CPU1.5VS3: CC136.1 QC4.3 QC6.4 RC95.2 RC143.1
RUN_ON_CPU1.5VS3#: Q71.2 QC1.2 QC4.5 QC4.6 RC97.2
RUN_ON_EN: Q52.2 R735.2 R744.2 U101.3 U105.3
RUN_ON_ENABLE#: Q45.2 Q52.5 Q52.6 Q70.2 Q72.2 R909.2
RUNPWROK: Q45.1 R799.2 R840.1 RC7.2 U50.2 U51.B26
RUNPWROK_AND: QC5.1 RC6.2 RC9.1 RC10.2 RC15.2 RC16.1 UC1.4
RUNPWROK_R: QC5.2 RC5.2 RC7.1 RC103.1 RC104.1 UC1.1
S3_1.35V: PR208.2 PU200.7
S5_1.35V: PC215.1 PR206.2 PR210.2 PU200.8
SATA_ACT#: Q74.4 UH1.AP3
SATA_COMP: RH57.1 UH1.AY5
SATA_IREF: RH51.2 UH1.BD4
SATA_LED: JLED2.4 R934.2
SATA_ODD_PRX_DTX_N1: C405.1 JSATA2.5
SATA_ODD_PRX_DTX_N1_C: C405.2 UH1.BC10
SATA_ODD_PRX_DTX_P1: C404.1 JSATA2.6
SATA_ODD_PRX_DTX_P1_C: C404.2 UH1.BE10
SATA_ODD_PTX_DRX_N1: C406.1 JSATA2.3
SATA_ODD_PTX_DRX_N1_C: C406.2 UH1.AV10
SATA_ODD_PTX_DRX_P1: C407.1 JSATA2.2
SATA_ODD_PTX_DRX_P1_C: C407.2 UH1.AW10
SATA_PCIE_EN#: Q85.1 R724.1 U7.3
SATA_PRX_DKTX_N2: C698.2 JDOCK1.56
SATA_PRX_DKTX_N2_C: C698.1 UH1.BB9
SATA_PRX_DKTX_P2: C697.2 JDOCK1.54
SATA_PRX_DKTX_P2_C: C697.1 UH1.BD9
SATA_PRX_DTX_N0: C385.1 JSATA1.5
SATA_PRX_DTX_P0: C386.1 JSATA1.6
SATA_PTX_DKRX_N2: C700.1 JDOCK1.62
SATA_PTX_DKRX_N2_C: C700.2 UH1.AY13
SATA_PTX_DKRX_P2: C699.1 JDOCK1.60
SATA_PTX_DKRX_P2_C: C699.2 UH1.AW13
SATA_PTX_DRX_N0: C384.1 JSATA1.3
SATA_PTX_DRX_P0: C383.1 JSATA1.2
SB#: R153.2 R1626.2 U2.8
SCLK: PR504.1 PR508.2 PU500.1
SD_CD#: C802.2 JSD1.17 R493.1 U38.21
SD_CLK: CE759.1 JSD1.5 R676.2
SD_CLK_R: R676.1 U38.43
SD_CMD: JSD1.2 U38.45
SD_D0_RCLK_P_MMC_D0: JSD1.7 LE5.3 RE28.2
SD_D0_RCLKR_P: LE5.4 RE28.1 U38.30 U38.38
SD_D1_RCLK_N: JSD1.8 LE5.2 RE27.2
SD_D1_RCLKR_N: LE5.1 RE27.1 U38.29 U38.37
SD_D2: JSD1.9 RE30.2
SD_D2_R: RE30.1 U38.48
SD_D3: JSD1.1 RE29.2
SD_D3_R: RE29.1 U38.47
SD_UHS2_D0N: JSD1.12 LE4.2 RE25.2
SD_UHS2_D0N_R: LE4.1 RE25.1 U38.34
SD_UHS2_D0P: JSD1.11 LE4.3 RE26.2
SD_UHS2_D0P_R: LE4.4 RE26.1 U38.35
SD_UHS2_D1N: JSD1.15 LE2.3 RE4.2
SD_UHS2_D1N_R: LE2.4 RE4.1 U38.33
SD_UHS2_D1P: JSD1.16 LE2.2 RE3.2
SD_UHS2_D1P_R: LE2.1 RE3.1 U38.32
SD_WPI: JSD1.18 U38.20
SDA: PR500.1 PR505.2 PU500.31
SDOUT_TERM: C678.1 R754.1
SEL: Q59.1 R1614.1 U2.4
SIO_14M: RH157.2 UH1.F38
SIO_A20GATE: RH193.2 U51.A45 UH1.AN10
SIO_EXT_SCI#: RH195.1 RH204.1 U51.A33
SIO_EXT_SMI#: RH10.1 RPH1.2 U51.A6 UH1.M1
SIO_EXT_WAKE#: RH24.1 RPH9.3 U46.B49 UH1.Y1
SIO_PWRBTN#: RH108.1 U51.B58
SIO_PWRBTN#_R: RC21.1 RH28.1 RH108.2 UH1.K1
SIO_RCIN#: RH194.2 U51.A27 UH1.AT6
SIO_SLP_A#: JAPS1.6 PR303.1 R1615.1 U46.B63 UH1.F3 UH2.1
SIO_SLP_LAN#: RH80.2 U46.A5 U102.5 UH1.G5
SIO_SLP_S3#: JAPS1.2 PR403.1 PR607.1 R153.1 R734.1 R735.1 RC98.1 U46.B65 UH1.H1
SIO_SLP_S4#: JAPS1.5 PR206.1 R1608.1 T70.1(TP-1) U46.A61 UH1.C6
SIO_SLP_S5#: R23.1 T69.1(TP-1) U51.A18 UH1.Y7
SIO_SLP_SUS#: T73.1(TP-1) U46.B6 UH1.F1
SIO_SLP_WLAN#: R1633.1 U46.A14 UH1.D2
SL_BAT_PRES#: PR860.1 PU800.21
SLEEVE: Q327.3 R58.1 R1145.1 U74.29
SLICE_BAT_ON: PD803.2 PD812.2 PR850.2 PR853.1 PR888.1 PR890.2 PU801.2 PU803.1 PU807.1 R791.2 U46.A31
SLICE_BAT_ON_C2: PR853.2 PU808.6
SLICE_BAT_PRES#: JDOCK1.141 JDOCK1.143 PD820.1 PQ807.5 PQ827.2 PR26.1 PR851.1 PR860.2 PR882.1 PU801.1 PU805.1 PU809.1 R760.2 U46.B33
SLICE_BAT_PRES#_C2: PC814.1 PR851.2 PU808.5
SLICE_PERF_EN: PR881.2 PR883.1 PR884.2 PR885.2 U51.B37
SLP_ME_CSW_DEV#: RH222.1 RH223.1 U46.B58 UH1.AD11
SM_RCOMP0: JCPU1.AP3 RC58.1
SM_RCOMP1: JCPU1.AR3 RC61.1
SM_RCOMP2: JCPU1.AP2 RC63.1
SMART_DET#: JUSH1.10 RH211.2 UH1.AB11
SMB_SCK: R565.2 R1689.1 U7.18
SMB_SDA: R567.2 R1688.1 U7.19
SML1_SMBCLK: RH172.1 U51.B6 UH1.K6
SML1_SMBDATA: RH173.1 U51.A5 UH1.N11
SNUB_1.05V: PC309.1 PR304.2
SNUB_1.5VSP: PC407.1 PR401.2
SNUB_1.8VSP: PC676.1 PR686.1
SNUB_1.35V: PC212.1 PR202.2
SNUB_3V: PC116.1 PR109.2
SNUB_5V: PC119.1 PR112.2
SNUB_CHARGER: PC715.2 PR721.2
SNUB_GPU_P1: PC631.1 PR653.2
SNUB_GPU_P2: PC607.1 PR622.2
SNUB_PCIE: PC667.1 PR680.2
SOFT_START_GC: PR23.2 PU800.2
SP_TPM_LPC_EN: R772.2 R1669.1 U46.B56
SP_TPM_LPC_EN_R: R1667.2 R1669.2 R1670.2 U39.28
SPI_CLK32: RE2.1 RPH7.2 U53.6
SPI_CLK64: R899.1 RE1.1 U52.6
SPI_DIN32: R895.2 U53.2
SPI_DIN64: R8.2 U52.2
SPI_DO32: RPH7.3 U53.5
SPI_DO64: R901.1 U52.5
SPI_PCH_CLK: JSPI1.7 R899.2 RH181.1 RPH7.7
SPI_PCH_CS0#: JSPI1.9 R7.1 RH182.1
SPI_PCH_CS0#_R: R7.2 U52.1
SPI_PCH_CS1#: JSPI1.1 R936.1 RH177.1
SPI_PCH_CS1#_R: R936.2 U53.1
SPI_PCH_DIN: JSPI1.5 R8.1 R895.1 RH179.1
SPI_PCH_DO: JSPI1.3 R901.2 RH178.1 RPH7.6
SPI_PCH_DO2: JSPI1.11 R9.1 R3667.1 RH183.1
SPI_PCH_DO2_32: R3665.2 R3667.2 RH186.1 U53.3
SPI_PCH_DO2_64: R9.2 R3664.2 RH180.1 U52.3
SPI_PCH_DO3: JSPI1.13 R3669.2 RH184.1 RPH7.8
SPI_PCH_DO3_32: R3666.2 RPH7.1 U53.7
SPI_PCH_DO3_64: R3668.2 R3669.1 U52.7
SPI_WP#_SEL: RH180.2 RH186.2 U46.A12
SPKR: R1119.2 RH34.2 UH1.AL10
SPKR_MUTE_LED#: R988.1 U46.A57
SRTCRST#: CH6.2 ME1.2 RH42.2 UH1.B9
STSTART_DCBLOCK_GC: PR811.1 PU800.16
SUS_ON: PR210.1 R878.2 R1607.1 U46.B60
SUS_STAT#/LPCPD#: R1667.1 RH73.2 UH1.U7
SUSACK#: RH101.1 U46.A58
SUSACK#_R: RH91.2 RH101.2 UH1.R6
SUSCLK: T68.1(TP-1) UH1.Y6
SW1: PC111.2 PL102.1 PQ102.1 PQ102.2 PQ102.3 PQ104.5 PR112.1 PU100.18
SW2: PC112.1 PL101.2 PQ101.1 PQ101.2 PQ101.3 PQ103.5 PR109.1 PU100.8
SW_1.35V: PC206.1 PL201.2 PQ201.1 PQ201.2 PQ201.3 PQ203.5 PR202.1 PU200.16
SW_+1.05VSP: PC306.1 PL301.1 PQ301.1 PQ301.2 PQ301.3 PQ303.5 PR304.1 PU300.8
SW_LAN_TX0+: T156.1 U32.38
SW_LAN_TX0-: T156.2 U32.37
SW_LAN_TX1+: T156.5 U32.34
SW_LAN_TX1-: T156.6 U32.33
SW_LAN_TX2+: T156.7 U32.29
SW_LAN_TX2-: T156.8 U32.28
SW_LAN_TX3+: T156.11 U32.25
SW_LAN_TX3-: T156.12 U32.24
SYS_LED_MASK#: Q84.5 Q325.2 Q325.5 Q326.2 R775.2 U46.B48 U58.1
SYS_PWROK: RC24.1 RH85.2 RH102.1 U46.B57
SYS_PWROK_R: RH102.2 UH1.AD7
SYS_PWROK_XDP: JXDP1.47 RC11.2 RC24.2
SYS_RESET#: JAPS1.13 RH66.2 UC3.4 UH1.AM1
SYSPWR_PRES: R874.1 R876.1 U51.A59
SYSTEM_ID: C742.1 R871.2 U51.A10
TEMP_ALERT#: R738.2 RH171.2 UH1.H6
TEMP_ALERT#_R: R738.1 U46.B11
TESTA: R3679.2 R3687.1 U90.14
TESTB: R3709.2 R3719.1 U92.14
TESTC: R3746.2 R3749.1 U94.14
TESTD: R3761.1 R3771.2 U95.14
TESTEN: RV41.1 RV49.1 T139.1(TP-1) UV1.AD28
THERMATRIP2#: C18.1 Q4.1 R51.2 U51.B34
THERMATRIP3#: CV57.1 QV7.1 R52.1 U51.A2
THERMTRIP_VGA: RV47.1 RV77.1 RV104.2 UV1.AM17
THSEL_STRAP: R1069.1 U51.B29
TMDSB_CPU_CLK: C352.2 JCPU1.V31
TMDSB_CPU_CLK#: C353.2 JCPU1.U31
TMDSB_CPU_N0: C350.2 JCPU1.U29
TMDSB_CPU_N1: C346.2 JCPU1.T30
TMDSB_CPU_N2: C348.2 JCPU1.T28
TMDSB_CPU_P0: C351.2 JCPU1.V29
TMDSB_CPU_P1: C347.2 JCPU1.U30
TMDSB_CPU_P2: C349.2 JCPU1.U28
TMDSE_CON_CLK: CE5.1 JHDMI1.10 L1.2 R63.2
TMDSE_CON_CLK#: CE7.1 JHDMI1.12 L1.3 R62.2
TMDSE_CON_N0: CE16.1 JHDMI1.9 L2.3 R68.2
TMDSE_CON_N1: CE18.1 JHDMI1.6 L3.3 R74.2
TMDSE_CON_N2: CE14.1 JHDMI1.3 L4.3 R78.2
TMDSE_CON_P0: CE17.1 JHDMI1.7 L2.2 R64.2
TMDSE_CON_P1: CE13.1 JHDMI1.4 L3.2 R71.2
TMDSE_CON_P2: CE15.1 JHDMI1.1 L4.2 R77.2
TMDSE_CPU_CLK#_C: C353.1 U19.10
TMDSE_CPU_CLK_C: C352.1 U19.9
TMDSE_CPU_N0_C: C350.1 U19.2
TMDSE_CPU_N1_C: C346.1 U19.5
TMDSE_CPU_N2_C: C348.1 U19.7
TMDSE_CPU_P0_C: C351.1 U19.1
TMDSE_CPU_P1_C: C347.1 U19.4
TMDSE_CPU_P2_C: C349.1 U19.6
TMDSE_RP_CLK: L1.1 R63.1 U19.22
TMDSE_RP_CLK#: L1.4 R62.1 U19.21
TMDSE_RP_N0: L2.4 R68.1 U19.29
TMDSE_RP_N1: L3.4 R74.1 U19.26
TMDSE_RP_N2: L4.4 R78.1 U19.24
TMDSE_RP_P0: L2.1 R64.1 U19.30
TMDSE_RP_P1: L3.1 R71.1 U19.27
TMDSE_RP_P2: L4.1 R77.1 U19.25
TOUCH_SCREEN_PD#: T144.1(TP-1) U46.B55
TP_CLK: C749.1 D37.2 JTP1.2 R1164.2
TP_DATA: C750.1 D37.3 JTP1.3 R1163.2
TP_LAN_JTAG_TCK: R546.2 U31.35
TP_LAN_JTAG_TDI: T142.1(TP-1) U31.32
TP_LAN_JTAG_TDO: T143.1(TP-1) U31.34
TP_LAN_JTAG_TMS: R545.2 U31.33
TPM_ID0: RH199.2 UH1.AT7
TPM_ID1: RH200.2 UH1.AM3
TRIP_+1.05VSP: PR302.2 PU300.2
TS_FDO: RV84.1 RV111.2 UV1.AK32
UG_3V: PQ101.4 PU100.10
UG_5V: PQ102.4 PU100.16
UG_+1.05VSP: PQ301.4 PU300.9
UGATE1: PQ509.4 PQ510.4 PU500.19
UGATE1_VGA: PQ604.4 PQ605.4 PU600.20
UGATE2: PQ505.4 PQ506.4 PU500.26
UGATE2_VGA: PQ600.4 PQ601.4 PU600.29
UGATE3: PQ501.4 PQ502.4 PU501.1
UIM_CLK: C630.1 JMINI1.12 JSIM1.3
UIM_DATA: C629.1 JMINI1.10 JSIM1.7
UIM_RESET: C631.1 JMINI1.14 JSIM1.2
USB3RN1: C1531.1 R27.1 UH1.AR26
USB3RN1_C: C1531.2 U92.23
USB3RN1_CO: R22.1 R27.2
USB3RN1_D-: D78.5 D78.6 JUSB1.5 L95.2 R1605.2
USB3RN1_R: R3712.2 U92.8
USB3RN1_RP: L95.1 R22.2 R1605.1 R3712.1
USB3RN2: C1516.1 R10.1 UH1.AW26
USB3RN2_C: C1516.2 U90.23
USB3RN2_CO: R2.1 R10.2
USB3RN2_D-: D88.1 D88.10 JUSB2.5 L108.2 R3696.2
USB3RN2_R: R3680.2 U90.8
USB3RN2_RP: L108.1 R2.2 R3680.1 R3696.1
USB3RN3: JDOCK1.84 UH1.AW31
USB3RN5: C1555.1 R34.1 UH1.AW29
USB3RN5_C: C1555.2 U95.23
USB3RN5_CO: R32.1 R34.2
USB3RN5_D-: D91.1 D91.10 JUSB3.5 L111.2 R3722.2
USB3RN5_R: R3770.2 U95.8
USB3RN5_RP: L111.1 R32.2 R3722.1 R3770.1
USB3RN6: C1547.1 R18.1 UH1.AR29
USB3RN6_C: C1547.2 U94.23
USB3RN6_CO: R14.1 R18.2
USB3RN6_D-: D79.5 D79.6 JUSB4.5 L98.2 R1609.2
USB3RN6_R: R3753.2 U94.8
USB3RN6_RP: L98.1 R14.2 R1609.1 R3753.1
USB3RP1: C1532.1 R28.1 UH1.AP26
USB3RP1_C: C1532.2 U92.22
USB3RP1_CO: R26.1 R28.2
USB3RP1_D+: D78.4 D78.7 JUSB1.6 L95.3 R1604.2
USB3RP1_R: R3713.2 U92.9
USB3RP1_RP: L95.4 R26.2 R1604.1 R3713.1
USB3RP2: C1517.1 R11.1 UH1.AV26
USB3RP2_C: C1517.2 U90.22
USB3RP2_CO: R4.1 R11.2
USB3RP2_D+: D88.2 D88.9 JUSB2.6 L108.3 R3691.2
USB3RP2_R: R3681.2 U90.9
USB3RP2_RP: L108.4 R4.2 R3681.1 R3691.1
USB3RP3: JDOCK1.86 UH1.AY31
USB3RP5: C1556.1 R35.1 UH1.AV29
USB3RP5_C: C1556.2 U95.22
USB3RP5_CO: R33.1 R35.2
USB3RP5_D+: D91.2 D91.9 JUSB3.6 L111.3 R3721.2
USB3RP5_R: R3763.2 U95.9
USB3RP5_RP: L111.4 R33.2 R3721.1 R3763.1
USB3RP6: C1543.1 R19.1 UH1.AP29
USB3RP6_C: C1543.2 U94.22
USB3RP6_CO: R16.1 R19.2
USB3RP6_D+: D79.4 D79.7 JUSB4.6 L98.3 R1610.2
USB3RP6_R: R3756.2 U94.9
USB3RP6_RP: L98.4 R16.2 R1610.1 R3756.1
USB3T_N1: C1535.1 C1560.1 L96.1 R1606.1
USB3T_N2: C2.1 C1520.1 L109.1 R3698.1
USB3T_N5: C1551.1 C1563.1 L112.1 R3728.1
USB3T_N6: C414.2 C420.2 L97.1 R1612.1
USB3T_P1: C1536.1 C1561.1 L96.4 R1603.1
USB3T_P2: C3.1 C1521.1 L109.4 R3697.1
USB3T_P5: C1553.1 C1564.1 L112.4 R3727.1
USB3T_P6: C415.2 C421.2 L97.4 R1613.1
USB3TN1: C1533.1 R31.1 UH1.BE24
USB3TN1_C: C1533.2 U92.20
USB3TN1_CO: C1560.2 R31.2
USB3TN1_D-: D78.2 D78.9 JUSB1.8 L96.2 R1606.2
USB3TN1_RP: C1535.2 U92.11
USB3TN2: C1518.1 R12.1 UH1.BD25
USB3TN2_C: C1518.2 U90.20
USB3TN2_CO: C2.2 R12.2
USB3TN2_D-: D88.4 D88.7 JUSB2.8 L109.2 R3698.2
USB3TN2_RP: C1520.2 U90.11
USB3TN3: JDOCK1.90 UH1.BE32
USB3TN5: C1562.1 R37.1 UH1.BE26
USB3TN5_C: C1562.2 U95.20
USB3TN5_CO: C1563.2 R37.2
USB3TN5_D-: D91.4 D91.7 JUSB3.8 L112.2 R3728.2
USB3TN5_RP: C1551.2 U95.11
USB3TN6: C1546.1 R21.1 UH1.BD27
USB3TN6_C: C1546.2 U94.20
USB3TN6_CO: C420.1 R21.2
USB3TN6_D-: D79.2 D79.9 JUSB4.8 L97.2 R1612.2
USB3TN6_RP: C414.1 U94.11
USB3TP1: C1534.1 R29.1 UH1.BD23
USB3TP1_C: C1534.2 U92.19
USB3TP1_CO: C1561.2 R29.2
USB3TP1_D+: D78.1 D78.10 JUSB1.9 L96.3 R1603.2
USB3TP1_RP: C1536.2 U92.12
USB3TP2: C1519.1 R13.1 UH1.BC24
USB3TP2_C: C1519.2 U90.19
USB3TP2_CO: C3.2 R13.2
USB3TP2_D+: D88.5 D88.6 JUSB2.9 L109.3 R3697.2
USB3TP2_RP: C1521.2 U90.12
USB3TP3: JDOCK1.92 UH1.BC32
USB3TP5: C1554.1 R36.1 UH1.BC26
USB3TP5_C: C1554.2 U95.19
USB3TP5_CO: C1564.2 R36.2
USB3TP5_D+: D91.5 D91.6 JUSB3.9 L112.3 R3727.2
USB3TP5_RP: C1553.2 U95.12
USB3TP6: C1550.1 R20.1 UH1.BE28
USB3TP6_C: C1550.2 U94.19
USB3TP6_CO: C421.1 R20.2
USB3TP6_D+: D79.1 D79.10 JUSB4.9 L97.3 R1613.2
USB3TP6_RP: C415.1 U94.12
USB30_EN: Q123.5 Q123.6 R515.2
USB30_SMI#: Q123.3 R514.2 UH1.C22
USB_MCARD1_DET#: JMINI2.40 R739.1 UH1.A10
USB_OC0#: RH189.2 U48.5 U91.5
USB_OC0#_R: RH3.1 RH189.1 RPH3.4 UH1.P3
USB_OC1#: RH190.2 U93.5
USB_OC1#_R: RH4.1 RH190.1 RPH3.3 UH1.V1
USB_OC2#: RH6.1 RPH1.1 UH1.U2
USB_OC3#: RH7.1 RPH3.2 UH1.P1
USB_OC4#: RH191.2 U49.5
USB_OC4#_R: RH8.1 RH191.1 RPH3.1 UH1.M3
USB_OC5#: RH9.1 RPH1.4 UH1.T1
USB_OC6#: RH17.1 RPH1.3 UH1.N2
USB_PWR_SHR_EN#: Q59.2 R776.2 R806.2 R1626.1 U46.B10
USB_PWR_SHR_VBUS_EN: Q48.2 R778.2 U2.1 U46.B50
USB_SIDE_EN#: R768.2 U46.A33 U49.4
USBP0+: U2.6 UH1.D37
USBP0-: U2.7 UH1.B37
USBP0_D+: L51.4 R740.1 U2.3
USBP0_D-: L51.1 R736.1 U2.2
USBP0_R_D+: D72.2 JUSB1.3 L51.3 R740.2
USBP0_R_D-: D72.3 JUSB1.2 L51.2 R736.2
USBP1+: L107.4 R3690.1 UH1.C38
USBP1-: L107.1 R3689.1 UH1.A38
USBP1_D+: D89.3 JUSB2.3 L107.3 R3690.2
USBP1_D-: D89.2 JUSB2.2 L107.2 R3689.2
USBP2+: L110.4 R3710.1 UH1.C36
USBP2-: L110.1 R3711.1 UH1.A36
USBP2_D+: D90.2 JUSB3.3 L110.3 R3710.2
USBP2_D-: D90.3 JUSB3.2 L110.2 R3711.2
USBP3+: JDOCK1.72 UH1.C34
USBP3-: JDOCK1.74 UH1.A34
USBP4+: JMINI2.38 UH1.D33
USBP4-: JMINI2.36 UH1.B33
USBP5+: JMINI1.38 UH1.G31
USBP5-: JMINI1.36 UH1.F31
USBP6+: L99.4 R1672.2 UH1.L31
USBP6-: L99.1 R1673.2 UH1.K31
USBP6_R_D+: JDOCK1.66 L99.3 R1672.1
USBP6_R_D-: JDOCK1.68 L99.2 R1673.1
USBP7+: JUSH1.18 UH1.H29
USBP7-: JUSH1.19 UH1.G29
USBP8+: JMINI3.38 UH1.C32
USBP8-: JMINI3.36 UH1.A32
USBP9+: L90.1 R1151.1 UH1.C30
USBP9-: L90.4 R1150.1 UH1.A30
USBP9_D+: D74.2 JUSB4.3 L90.2 R1151.2
USBP9_D-: D74.3 JUSB4.2 L90.3 R1150.2
USBP10+: JEXP1.5 UH1.D29
USBP10-: JEXP1.3 UH1.B29
USBP12+: L10.1 R427.1 UH1.F26
USBP12-: L10.4 R428.1 UH1.G26
USBP12_D+: JCAM1.2 L10.2 R427.2
USBP12_D-: JCAM1.3 L10.3 R428.2
USBRBIAS: RH187.1 UH1.K24 UH1.K26
USH_DET#: JUSH1.1 RH202.1 UH1.F13
USH_PWR_ON: R518.2 R1620.1 U46.A18
USH_PWR_STATE#: JUSH1.5 R1640.1 U46.A34
USH_SMBCLK: JUSH1.16 R589.2 U51.A50
USH_SMBDAT: JUSH1.15 R585.2 U51.B53
V_SYS: PC716.2 PU700.7 R392.2
V_SYS_R: R392.1 U51.B61
VCI_IN3#: R1156.2 U51.B68
VCORE_VDDP: PC509.2 PR520.1 PR523.1 PU500.23
VCP: PR710.1 PR728.1 PU702.1 PU702.2 U51.A12
VCP_1: PR727.1 PR729.2 PU702.3
VCT_LAN_R1: R152.2 R556.2 U31.6
VGA_ID: R800.2 R803.1 U46.B59
VGA_THERMDN: C287.1 U51.A15 UV1.AG29
VGA_THERMDP: C287.2 U51.B16 UV1.AF29
VID0: PR612.2 PR613.1 PU600.31
VID6: PR615.2 PU600.37
VIDALERT_N: PR506.1 RC87.2 RC88.2
VIDSCLK: JCPU1.AM29 PR508.1
VIDSOUT: JCPU1.AL28 PR505.1 RC90.2
VLDOIN_1.35V: PJP201.2 PU200.19
VOL_DOWN#: JBTB1.10 R887.2 R1197.2
VOL_DOWN_LED: JBTB1.20 R954.2
VOL_DOWN_R#: R887.1 U51.B57
VOL_MUTE: JBTB1.12 R884.2 R1169.2
VOL_MUTE_WHITE_LED: JBTB1.16 R989.2
VOL_MUTE_YELLOW_LED#: JBTB1.6 R988.2
VOL_UP#: JBTB1.8 R888.2 R1118.2
VOL_UP_LED: JBTB1.24 R3672.2
VR_HOT#: PR524.2 PU500.5
VR_ON: PR511.2 PU500.2
VREFC1: CV208.2 CV326.1 RV110.1 RV139.2 UV4.J14
VREFC2: CV328.2 CV329.1 RV183.2 RV184.1 UV5.J14
VREFC3: CV349.1 CV350.2 RV193.2 RV194.1 UV3.J14
VREFC4: CV353.1 CV354.2 RV197.2 RV198.1 UV6.J14
VREFC5: CV21.2 CV22.1 RV5.1 RV6.2 UV8.J14
VREFC6: CV27.1 CV28.2 RV11.1 RV12.2 UV7.J14
VREFC7: CV33.1 CV34.2 RV17.1 RV19.2 UV9.J14
VREFC8: CV39.1 CV40.2 RV24.1 RV27.2 UV10.J14
VREFD1_1: CV207.1 CV322.2 RV109.2 RV128.1 UV4.A10
VREFD1_2: CV323.2 CV324.1 RV129.2 RV131.1 UV4.U10
VREFD2_1: CV325.2 CV327.1 RV140.2 RV181.1 UV5.A10
VREFD2_2: CV330.2 CV331.1 RV185.2 RV186.1 UV5.U10
VREFD3_1: CV209.2 CV210.1 RV119.2 RV120.1 UV3.A10
VREFD3_2: CV332.1 CV333.2 RV191.2 RV192.1 UV3.U10
VREFD4_1: CV351.1 CV352.2 RV195.2 RV196.1 UV6.A10
VREFD4_2: CV355.1 CV356.2 RV203.2 RV205.1 UV6.U10
VREFD5_1: CV13.1 CV18.2 RV1.2 RV65.1 UV8.A10
VREFD5_2: CV19.2 CV20.1 RV3.2 RV4.1 UV8.U10
VREFD6_1: CV23.1 CV24.2 RV7.1 RV8.2 UV7.A10
VREFD6_2: CV25.1 CV26.2 RV9.1 RV10.2 UV7.U10
VREFD7_1: CV29.1 CV30.2 RV13.1 RV14.2 UV9.A10
VREFD7_2: CV31.1 CV32.2 RV15.1 RV16.2 UV9.U10
VREFD8_1: CV35.1 CV36.2 RV20.1 RV21.2 UV10.A10
VREFD8_2: CV37.1 CV38.2 RV22.1 RV23.2 UV10.U10
VSB_N_001: PC6.2 PQ3.2 PR17.2 PR19.2
VSB_N_002: PC15.1 PQ5.2 PR21.2 PR24.2
VSB_N_003: PQ5.1 PR19.1
VSET_5075: C284.1 R407.1 U51.A17
VSUM+_VGA: PC626.1 PC627.1 PR619.2 PR647.1 PR648.1 PR651.2 PR655.1 PU600.15
VSUM-_VGA: PC615.2 PC616.2 PC626.2 PC627.2 PC632.1 PH601.2 PR624.2 PR654.2 PR655.2 PR659.2
VSYNC: RH95.2 UH1.N44
VSYNC_BUF: JBTB1.3 U6.18
VSYNC_DOCK: JDOCK1.67 U6.17
WCKA0_0: UV1.A32 UV4.D4 UV5.P4
WCKA0_1: UV1.D23 UV4.P4 UV5.D4
WCKA0B_0: UV1.C32 UV4.D5 UV5.P5
WCKA0B_1: UV1.E22 UV4.P5 UV5.D5
WCKA1_0: UV1.C14 UV3.P4 UV6.D4
WCKA1_1: UV1.E10 UV3.D4 UV6.P4
WCKA1B_0: UV1.A14 UV3.P5 UV6.D5
WCKA1B_1: UV1.D9 UV3.D5 UV6.P5
WCKB0_0: UV1.H3 UV7.P4 UV8.D4
WCKB0_1: UV1.T3 UV7.D4 UV8.P4
WCKB0B_0: UV1.H1 UV7.P5 UV8.D5
WCKB0B_1: UV1.T5 UV7.D5 UV8.P5
WCKB1_0: UV1.AE4 UV9.P4 UV10.D4
WCKB1_1: UV1.AK6 UV9.D4 UV10.P4
WCKB1B_0: UV1.AF5 UV9.P5 UV10.D5
WCKB1B_1: UV1.AK5 UV9.D5 UV10.P5
WEA0#: UV1.K26 UV4.L12 UV5.G12
WEA1#: UV1.L15 UV3.G12 UV6.L12
WEB0#: UV1.N10 UV7.G12 UV8.L12
WEB1#: UV1.AB11 UV9.G12 UV10.L12
WIGIG60GHZ_DIS#: D35.1 R694.1 U46.A1
WIGIG60GHZ_DIS#_R: D35.2 JMINI2.32 R694.2 R725.1
WIGIG_LED#: JMINI2.42 Q124.4 R705.1 R706.1
WIRELESS_LED#: Q77.1 Q89.1 Q100.3 Q124.3 Q124.6 R937.2 U46.A47
WIRELESS_ON#/OFF: JSF1.1 R771.2 U46.B13
WLAN_LAN_DISB#: U15.4 U46.A64
