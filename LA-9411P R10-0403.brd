# Allegro board LA-9411P R10-0403.brd (continued)
## Copper pours and planes (outline as drawn) (continued)
+3.3V_RUN on TOP (solid shape): 248.71,43.12 248.71,42.98 248.69,42.95 247.72,42.95 246.73,41.96 245.47,41.96 245.41,42.02 245.41,42.57 245.52,42.68 246.62,42.68 246.74,42.8 247.23,42.8 247.57,43.14 248.69,43.14
+3.3V_RUN on TOP (solid shape): 30.59,206.96 30.59,205.94 29.83,205.18 28.75,205.18 28.18,204.61 28.18,203.61 28.1,203.53 28.01,203.53 27.97,203.57 27.97,205.1 28.43,205.56 29,205.56 29.26,205.82 29.26,206.96 29.38,207.09 30.46,207.09
+3.3V_RUN on TOP (solid shape): 323.52,204.52 323.52,203.58 324.11,202.99 324.11,201.79 324.06,201.74 323.49,201.74 323.4,201.82 323.4,202.68 323.14,202.94 320.9,202.94 320.59,203.25 320.59,204.5 320.78,204.7 323.34,204.7
+3.3V_RUN on TOP (solid shape): 336.91,195.59 336.91,193.42 336.72,193.23 335.94,193.23 335.9,193.27 335.9,193.81 335.36,193.81 335.36,193.27 335.34,193.24 335,193.24 334.12,194.12 334.12,195.47 334.37,195.72 336.78,195.72
+3.3V_RUN on TOP (solid shape): 270.85,35.53 270.85,35.36 270.81,35.32 270.1,35.32 269.55,34.77 269.55,32.8 269.32,32.57 268.14,32.57 267.95,32.75 267.95,33.62 268.04,33.71 268.04,33.9 268.03,33.91 268.03,34.62 268.12,34.71 269.17,34.71 270.06,35.6 270.79,35.6
+3.3V_RUN on TOP (solid shape): 189.73,167.69 189.73,166.55 190.72,165.56 191.38,165.56 191.61,165.33 191.61,164.02 191.45,163.86 189.91,163.86 189.8,163.97 189.8,165 189.38,165.42 188.72,165.42 188.65,165.48 188.65,167.75 188.69,167.79 189.63,167.79
+3.3V_RUN on TOP (solid shape): 216.53,66.36 216.53,65.78 216.27,65.52 214.79,65.52 214.47,65.2 214.47,64.81 215.4,63.88 215.4,63.82 215.02,63.44 214.95,63.44 214.22,64.17 213.5,64.17 213.27,63.94 213.27,63.65 213.06,63.44 212.94,63.44 212.81,63.57 212.81,64.55 214.76,66.5 216.38,66.5
+3.3V_RUN on TOP (solid shape): 255.81,44.47 255.81,44.22 255.95,44.08 256.06,44.08 256.46,43.68 256.46,43.38 256.33,43.26 255.82,43.26 255.63,43.45 255.63,43.71 255.39,43.95 255.39,43.99 255.36,44.03 254.91,44.47 254.85,44.54 253.94,44.54 253.92,44.56 253.92,44.72 253.94,44.74 255.54,44.74
+3.3V_RUN on TOP (solid shape): 256.14,56.34 256.14,55.6 255.76,55.22 253.56,55.22 252.95,54.61 252.95,53.76 252.87,53.67 252.87,52.98 252.89,52.96 252.89,52.69 252.79,52.59 250.88,52.59 250.8,52.68 250.8,53.34 251.6,54.14 251.6,54.39 252.27,55.07 252.27,55.96 252.43,56.12 252.43,56.13 253.17,56.87 255.61,56.87
+3.3V_RUN on TOP (solid shape): 220.54,60.74 220.58,60.69 220.58,60.59 220.34,60.35 220.34,60.35 220.22,60.27 220.14,60.15 220.13,60.14 219.05,59.06 218.96,59.03 218.89,59.09 218.31,59.19 218.41,58.62 218.47,58.54 218.44,58.45 217.66,57.67 217.03,57.67 216.64,57.29 216.14,57.29 216.01,57.42 216.01,57.8 217.15,58.94 217.15,59.83 218.04,60.72 218.42,60.72 219.44,61.73 219.54,61.73
+3.3V_RUN on TOP (solid shape): 208.54,47.97 208.54,47.37 207.95,46.77 207.35,46.77 207.31,46.79 207.26,46.8 207.21,46.81 207.16,46.81 207.11,46.8 207.06,46.79 207.01,46.77 206.97,46.74 206.93,46.71 206.9,46.67 206.87,46.62 206.85,46.57 206.83,46.52 206.83,46.48 206.33,45.99 206.31,45.99 205.58,45.26 204.8,45.26 204.45,45.61 204.45,45.78 206.57,47.9 206.9,47.9 206.9,47.86 206.91,47.82 206.93,47.78 206.96,47.74 206.97,47.73 207.26,47.44 207.27,47.42 207.31,47.4 207.35,47.38 207.39,47.37 207.44,47.36 207.48,47.37 207.53,47.38 207.57,47.4 207.6,47.42 207.63,47.45 207.66,47.49 207.68,47.53 207.69,47.57 207.69,47.62 207.69,47.66 207.68,47.7 207.66,47.74 207.63,47.78 207.62,47.8 207.33,48.08 207.31,48.1 207.28,48.13 207.24,48.14 207.19,48.16 207.15,48.16 207.11,48.16 207.06,48.14 207.02,48.13 206.99,48.1 206.96,48.07 206.93,48.03 206.91,47.99 206.9,47.95 206.9,47.9 206.57,47.9 207.44,48.77 207.74,48.77
+3.3V_RUN on TOP (solid shape): outline of 106 points within 254.15,124.85 270.21,128.55
+3.3V_RUN on TOP (solid shape): outline of 243 points within 115.93,5.52 122.21,19.37
+3.3V_RUN on BOTTOM (solid shape): 127.74,100.65 127.74,99.64 127.43,99.33 126.41,99.33 126.28,99.45 126.28,101.04 126.41,101.17 127.23,101.17
+3.3V_RUN on BOTTOM (solid shape): 117.42,19.32 117.42,17.98 117.33,17.89 116.16,17.89 116,18.06 116,19.29 116.25,19.55 117.19,19.55
+3.3V_RUN on BOTTOM (solid shape): 346.12,175.58 346.12,174.35 346.11,174.33 345.92,174.33 345.75,174.5 345.05,174.5 344.93,174.62 344.93,175.48 345.11,175.65 346.05,175.65
+3.3V_RUN on BOTTOM (solid shape): 46.72,182.89 46.72,181.37 46.59,181.24 45.07,181.24 44.94,181.37 44.94,181.75 45.45,181.75 45.45,182.26 44.94,182.26 44.94,182.89 45.07,183.02 46.59,183.02
+3.3V_RUN on BOTTOM (solid shape): 204.9,71.01 204.9,70.79 204.76,70.65 204.76,70.32 204.55,70.12 203.39,70.12 203.14,70.36 203.14,70.54 203.32,70.71 203.75,70.71 204.06,71.02 204.44,71.02 204.55,71.13 204.77,71.13
+3.3V_RUN on BOTTOM (solid shape): 181.28,176.71 181.76,176.71 181.9,176.57 182.32,176.57 182.63,176.25 182.63,174.88 182.39,174.64 180.93,174.64 180.93,174.63 180.86,174.63 180.81,174.69 180.81,175.3 180.27,175.83 180.27,177.08 180.37,177.18 180.81,177.18
+3.3V_RUN on BOTTOM (solid shape): 178.28,166.15 178.28,165.88 178.18,165.77 176.54,165.77 176.47,165.84 175.41,165.84 175.33,165.92 175.33,166.03 175.4,166.1 176.37,166.1 176.5,166.22 176.5,166.22 176.64,166.36 176.68,166.4 178.02,166.4
+3.3V_RUN on BOTTOM (solid shape): 180.72,128.07 180.72,127.57 180.74,127.55 181.17,127.55 181.2,127.57 181.2,128.07 181.24,128.1 181.4,128.1 181.75,127.76 181.75,126.2 181.71,126.16 180.28,126.16 180.21,126.24 180.21,127.99 180.34,128.12 180.67,128.12
+3.3V_RUN on BOTTOM (solid shape): 334.96,171.28 334.96,168.85 334.52,168.4 332.86,168.4 332.65,168.62 332.65,169.84 332.8,169.99 333.08,169.99 333.17,169.98 333.26,169.99 333.47,169.99 334.05,170.57 334.05,171.13 334.24,171.33 334.92,171.33
+3.3V_RUN on BOTTOM (solid shape): 197.34,171.97 197.34,171.72 197.59,171.46 200.21,171.46 200.26,171.41 200.26,170.93 199.25,169.91 199.25,169.68 198.99,169.43 198.2,169.43 198.08,169.56 198.08,170.22 197.94,170.36 196.92,170.36 196.71,170.57 196.71,171.52 196.8,171.69 196.79,171.88 196.78,171.92 196.96,172.1 197.21,172.1
+3.3V_RUN on BOTTOM (solid shape): 190.48,63.77 191.37,63.77 191.63,63.51 191.63,63.33 191.6,63.32 191.39,63.03 191.54,62.7 191.58,62.63 191.55,62.55 191.24,62.24 190.99,62.24 190.79,62.44 190.79,62.46 190.72,62.58 190.62,62.67 190.62,62.67 189.59,63.69 189.59,64.02 189.72,64.15 190.1,64.15
+3.3V_RUN on BOTTOM (solid shape): 266.18,35.23 266.26,35.19 266.28,35.11 266.29,34.95 266.38,34.82 266.4,34.75 266.38,34.68 266.63,34.07 266.89,34.68 266.86,34.75 266.89,34.82 266.97,34.95 266.98,35.11 267.01,35.19 267.09,35.23 268.64,35.23 269.53,34.34 269.53,32.54 269.46,32.47 265.08,32.47 263.97,33.59 263.97,34.47 264.73,35.23
+3.3V_RUN on BOTTOM (solid shape): 186.33,64.27 186.43,64.18 186.55,64.13 186.57,64.13 186.67,64.02 186.67,63.51 186.04,62.88 186.04,62.83 186.01,62.82 185.81,62.44 186.12,62.14 186.14,62.14 189.21,59.07 189.75,59.07 190.16,58.99 190.4,59.34 190.4,59.36 190.74,59.7 190.74,60.46 191.26,60.98 191.29,60.97 191.58,60.98 191.77,61.2 191.84,61.27 191.94,61.24 191.96,61.22 192.08,61.14 192.23,61.11 192.25,61.11 192.39,60.97 192.39,60.65 192.28,60.54 192.28,60.5 191.9,60.12 191.97,60.05 190.23,58.31 188.83,58.31 185.33,61.81 185.33,63.56 186.04,64.27
+3.3V_RUN on BOTTOM (solid shape): outline of 395 points within 243.44,41.92 247.76,50.43
+3.3V_RUN on IN2 (solid shape): 183.36,177.06 183.78,176.64 183.78,175.77 183.37,175.36 181.52,175.36 180.43,174.27 179.62,174.27 179.19,173.84 178.89,173.84 178.62,174.1 178.62,174.89 180.86,177.13 183.36,177.13
+3.3V_RUN on IN2 (solid shape): 270.37,127.65 270.37,125.29 270.24,125.17 265.87,125.17 265.7,124.99 259.05,124.99 258.78,124.73 254.36,124.73 254.1,124.99 254.1,126.88 254.36,127.14 255.25,127.14 255.76,127.65 266.05,127.65 266.43,128.03 269.98,128.03
+3.3V_RUN on IN2 (solid shape): 120.14,47.74 120.14,38.21 119.5,37.58 119.5,31.97 119.48,31.95 119.57,31.86 119.57,19.33 118.19,17.96 116.61,17.96 116.04,18.53 116.04,20.98 117.28,22.22 117.28,24.51 117.59,24.87 117.28,25.22 117.28,27.27 117.22,27.33 117.22,45.66 116.58,46.29 116.58,49.15 117,49.57 118.31,49.57
+3.3V_RUN on IN2 (solid shape): outline of 151 points within 188.32,62.37 192.13,65.61
+3.3V_RUN on IN3 (solid shape): 270.45,36.82 270.45,36.55 270.28,36.37 270.28,34.72 270.15,34.45 270.26,34.18 270.28,34.17 270.28,34.12 270.26,34.1 270.15,33.85 270.26,33.59 270.28,33.57 270.28,33.51 270.26,33.5 270.16,33.24 270.28,32.99 270.28,32.71 269.82,32.26 268.91,32.26 268.66,32.5 268.66,35.38 268.7,35.46 268.79,35.48 269.24,35.83 268.79,36.17 268.7,36.19 268.66,36.27 268.66,37.08 268.94,37.36 269.91,37.36
+3.3V_RUN on IN4 (solid shape): outline of 103 points within 330.72,168.37 334.87,183.1
+3.3V_RUN on IN4 (solid shape): outline of 1156 points within 175.67,125.96 181.99,168.61
+3.3V_RUN on TOP: 338.15,188.38 338.26,188.49 338.54,188.49 338.54,187.93 339.02,187.93 339.02,188.49 339.68,188.49 339.72,188.46 339.72,183.78 338.25,182.31 335.36,182.31 334.84,181.79 332.8,181.79 332.52,182.07 332.52,183.17 334.62,185.27 337.73,185.27 338.15,185.69
+3.3V_RUN on IN3: 321.39,202.88 325.88,202.88 327.4,204.4 327.4,208.03 328.87,209.51 328.87,213.04 328.51,213.41 326.35,213.41 320.75,207.81 320.75,203.51
+3.3V_RUN on VCC: outline of 190 points within 17.13,42.81 256.65,218.52 ; 1 cut-out
+3.3V_RUN on VCC: 255.61,26.81 255.06,27.36 255.06,44.67 256.01,45.62 256.01,46.53 255.06,47.49 255.06,93.95 268.84,107.73 268.84,133.13 276.46,140.75 276.46,165.39 281.27,170.19 293.2,170.19 294.24,171.23 294.24,193.15 294.39,193.5 294.46,193.87 294.48,193.88 294.48,194.03 294.48,194.09 294.48,213.5 297.95,213.5 298.71,212.74 311.87,212.74 313.55,214.41 313.55,219.11 314.29,219.85 321.14,219.85 324.19,222.9 344.17,222.9 344.91,222.16 344.91,193.92 337.29,186.3 337.29,183.51 330.33,176.54 324.83,176.54 324.34,177.03 324.34,180.08 322.69,181.73 322.69,193.33 326.22,196.86 327.37,196.86 328.65,198.13 328.65,206.12 327.49,207.28 310.52,207.28 308.72,205.48 308.72,193.28 305.93,190.49 305.93,184.69 308.72,181.9 308.72,176.82 309.47,176.06 309.47,146.83 309.48,146.83 309.48,139.44 304.8,134.76 289.06,134.76 274.05,119.75 274.05,108.07 265.16,99.18 265.16,64.51 264.65,64 264.65,62.26 265.16,61.76 265.16,28.06 263.91,26.81
+3.3V_RUN_CARD on TOP (solid shape): 247.06,43.54 248.67,43.54 248.71,43.5 248.71,43.38 248.67,43.34 247.53,43.34 247.21,43.03 245.44,43.03 245.3,43.17 245.3,44.25 245.41,44.36 246.24,44.36
+3.3V_RUN_CARD on TOP (solid shape): 259.58,32.28 261.74,32.28 261.95,32.08 261.95,31.7 261.34,31.09 259.84,31.09 259.58,30.84 259.58,29.04 259.3,28.77 258.44,28.77 258.34,28.86 258.34,32.39 258.4,32.45 259.42,32.45
+3.3V_RUN_CARD on IN1 (solid shape): 246.55,43.85 246.55,42.93 246.52,42.85 246.45,42.82 246.08,42.47 246.45,42.11 246.52,42.08 246.55,42.01 246.55,41.24 245.26,39.94 245.26,39.55 244.85,39.14 244.85,38.47 244.85,38.47 244.83,38.34 244.85,38.22 244.85,38.21 244.85,37.17 244.82,37.1 244.74,37.07 244.36,36.72 244.74,36.36 244.82,36.33 244.85,36.26 244.85,32.92 244.72,32.4 245.25,32.33 245.32,32.36 245.39,32.33 245.85,31.86 245.85,31 245.73,30.87 245.62,30.87 245.35,31.14 244.83,31.14 243.82,32.14 243.82,40.45 243.85,40.49 244.3,40.94 244.3,41.17 244.3,41.18 244.32,41.29 244.3,41.4 244.3,41.4 244.3,42.3 245.17,43.17 245.17,43.89 245.42,44.14 246.26,44.14
+3.3V_RUN_CARD on IN2 (solid shape): outline of 102 points within 244.76,30.54 259.99,33.41
+3.3V_RUN_DVDD on BOTTOM (solid shape): outline of 176 points within 334.97,168.8 338.06,174.25
+3.3V_RUN_EDP on TOP (solid shape): 168.51,152.4 168.51,151.59 168.51,151.58 168.51,151.34 167.69,150.52 167.69,148.96 167.57,148.84 166.95,148.84 166.75,149.05 166.75,151.85 167.37,152.48 168.44,152.48
+3.3V_RUN_EDP on TOP (solid shape): 170.23,145.43 170.23,142.74 169.59,142.1 168.02,142.1 167.93,142.19 167.93,143.32 168,143.4 169.25,143.4 169.59,143.74 169.59,145.36 169.79,145.57 170.09,145.57
+3.3V_RUN_EDP on BOTTOM (solid shape): 171.05,143.28 171.05,142.02 170.91,141.88 168.25,141.88 167.8,142.33 167.8,143.17 168.05,143.42 170.23,143.42 170.24,143.43 170.9,143.43
+3.3V_RUN_EDP on BOTTOM (solid shape): 181.71,131.31 181.71,128.43 181.52,128.24 181.1,128.24 181.05,128.19 181.05,127.71 181.03,127.7 180.88,127.7 180.87,127.71 180.87,128.21 180.83,128.24 180.41,128.24 179.98,128.68 179.98,131.15 180.15,131.32 181.69,131.32
+3.3V_RUN_EDP on IN2 (solid shape): 168.94,129.36 168.94,127.33 168.89,127.28 167.78,127.28 167.41,127.65 167.41,129.15 167.76,129.5 168.8,129.5
+3.3V_RUN_EDP on IN2 (solid shape): 181.71,129.43 181.71,128.97 181.36,128.63 179.08,128.63 178.75,128.96 178.75,129.53 179.01,129.79 181.34,129.79
+3.3V_RUN_EDP on IN4 (solid shape): outline of 309 points within 167.64,128.41 169.86,152.49
+3.3V_RUN_FFS on BOTTOM (solid shape): 117.39,17.09 117.39,14.19 117.56,14.02 118.37,14.02 118.44,13.96 118.44,13.39 118.42,13.37 117.71,13.37 116.92,12.59 116.61,12.59 116.49,12.7 116.49,13.46 116.51,13.47 116.51,15.76 115.99,16.27 115.99,16.59 115.98,16.6 115.98,16.97 116.21,17.2 117.29,17.2
+3.3V_RUN_FFS on IN3 (solid shape): 117.65,13.5 117.65,11.16 118.05,10.76 118.85,10.76 118.85,10.77 121.14,10.77 121.51,10.4 121.51,9.65 121.2,9.35 116.34,9.35 115.53,10.16 115.53,10.96 116.33,10.96 116.33,10.91 116.34,10.86 116.35,10.8 116.37,10.76 116.4,10.71 116.44,10.67 116.48,10.64 116.53,10.61 116.58,10.59 116.63,10.58 116.68,10.58 116.74,10.58 116.79,10.59 116.84,10.61 116.88,10.64 116.93,10.67 116.96,10.71 116.99,10.76 117.02,10.8 117.03,10.86 117.04,10.91 117.04,10.96 117.03,11.01 117.02,11.06 116.99,11.11 116.96,11.16 116.93,11.2 116.88,11.23 116.84,11.26 116.79,11.28 116.74,11.29 116.68,11.29 116.63,11.29 116.58,11.28 116.53,11.26 116.48,11.23 116.44,11.2 116.4,11.16 116.37,11.11 116.35,11.06 116.34,11.01 116.33,10.96 115.53,10.96 115.53,11.23 116.05,11.75 116.05,13.87 117.28,13.87
+3.3V_RUN_GFX on TOP (solid shape): 247.09,141.1 247.09,140.19 246.73,139.84 246.73,139.13 246.65,139.05 245.06,139.05 244.65,139.46 244.14,139.46 243.93,139.67 243.93,140.55 244,140.64 244.11,140.61 244.66,140.65 244.51,141.18 244.47,141.2 244.47,141.28 246.9,141.28
+3.3V_RUN_HDD on TOP (solid shape): 115.04,49.29 115.04,47.95 115.62,47.95 115.62,47.83 115.04,47.83 115.04,46.37 114.79,46.11 112.63,46.11 112.5,46.24 112.5,49.42 112.63,49.54 114.79,49.54
+3.3V_RUN_HDD on BOTTOM (solid shape): 114.79,49.42 114.79,47.76 114.54,47.51 111.36,47.51 111.11,47.76 111.11,49.54 111.36,49.8 114.41,49.8
+3.3V_RUN_OZVCC on TOP (solid shape): 250.6,53.23 250.6,52.65 250.73,52.51 250.73,51.84 250.16,51.27 250.16,49.39 250.07,49.3 250.07,48.98 250.43,48.63 250.43,47.49 250.4,47.46 250.25,47.46 250.2,47.51 250.2,48.4 250.15,48.45 250.15,48.46 250.07,48.53 250.07,48.54 250.03,48.58 250.03,48.6 249.69,48.94 249.69,49.26 249.54,49.42 249.54,51.02 249.6,51.22 249.54,51.42 249.54,53.3 249.72,53.48 250.35,53.48
+3.3V_RUN_TPM on TOP (solid shape): 298.34,132.11 298.34,130.37 297.58,129.6 297.58,128.32 297.39,128.13 296.77,128.13 296.59,128.31 296.59,129.64 296.92,129.97 297.56,129.97 297.96,130.38 297.96,132.05 298.09,132.18 298.27,132.18
+3.3V_RUN_TPM on TOP (solid shape): 297.21,124.66 297.21,123.72 297.18,123.69 296.62,123.69 296.62,123.13 296.43,123.13 296.43,123.69 295.66,123.69 295.38,123.96 295.38,124.85 295.49,124.96 296.29,124.96 296.3,124.97 296.91,124.97
+3.3V_RUN_TPM on TOP (solid shape): 295.09,132.11 295.09,130.19 294.33,129.43 294.33,128.14 294.29,128.1 292.68,128.1 292.63,128.16 292.63,129.5 292.71,129.58 293.75,129.58 294.71,130.54 294.71,132.08 294.83,132.19 295,132.19
+3.3V_RUN_TPM on TOP (solid shape): 295.87,139.84 295.87,138.86 295.32,138.31 295.32,138.3 295.09,138.07 295.09,136.46 294.94,136.31 294.81,136.31 294.71,136.41 294.71,137.83 294.72,137.85 294.72,138.95 295.02,139.24 295.02,139.95 295.07,140 295.7,140
+3.3V_RUN_TPM on TOP (solid shape): 298.87,140.88 298.87,138.92 298.33,138.38 298.33,136.45 298.22,136.33 298.03,136.33 297.96,136.4 297.96,138.07 297.7,138.34 297.7,139 297.91,139.22 297.91,140.86 298.01,140.95 298.8,140.95
+3.3V_RUN_TPM on IN4 (solid shape): outline of 621 points within 292.54,123.86 298.71,139.46
+3.3V_SUS on TOP (solid shape): 265.06,84.01 266.51,84.01 266.8,83.72 266.8,83.18 266.92,83.06 268.09,83.06 268.25,82.91 268.25,81.06 267.91,80.73 267.03,80.73 266.87,80.89 266.87,82.42 266.64,82.65 264.89,82.65 264.63,82.92 263.39,82.92 263.23,83.08 263.23,84.16 263.32,84.25 264.82,84.25
+3.3V_SUS on BOTTOM (solid shape): 269.91,94.44 269.91,93.18 269.69,92.95 268.41,92.95 268.3,93.06 268.3,93.54 268.91,94.15 268.91,94.55 268.96,94.6 269.76,94.6
+3.3V_SUS on BOTTOM (solid shape): 271.08,101.1 271.08,100.59 270.7,100.22 269.8,100.22 269.61,100.03 269.61,99.67 269.53,99.59 268.71,99.59 268.55,99.75 268.55,100.13 269.69,101.27 270.91,101.27
+3.3V_SUS on IN2 (solid shape): 271.02,101.09 271.02,100.62 270.61,100.21 269.42,100.21 269.13,100.51 269.13,101.17 269.5,101.54 270.57,101.54
+3.3V_SUS on IN2 (solid shape): 244.35,106.94 244.35,104.98 244.21,104.84 243.42,104.84 243.17,105.09 243.17,107 243.33,107.16 244.13,107.16
+3.3V_SUS on IN3 (solid shape): 243.98,106.98 243.98,105.21 243.88,105.1 242.92,105.1 242.83,105.19 242.83,106.9 243.06,107.14 243.83,107.14
+3.3V_SUS on IN3 (solid shape): 175.75,162.18 175.75,162.17 175.75,161.18 175.58,161.01 173.86,161.01 173.63,161.24 173.63,162.07 173.83,162.28 175.66,162.28
+3.3V_SUS on TOP: 172.9,164.68 174.13,164.68 174.24,164.56 174.24,164.56 174.35,164.46 174.35,162.63 174.62,162.36 174.62,161.3 174.62,161.3 174.62,161.14 174.54,161.06 173.43,161.06 173.24,161.25 173.24,161.85 172.84,162.25 172.84,164.61
+3.3V_SUS on IN1: 269.53,93.89 267.69,93.89 267.4,93.61 267.4,93.2 263.88,89.67 263.88,82.67 264.08,82.46 265.6,82.46 266.02,82.88 266.02,84.51 264.97,85.56 264.97,86.41 266.75,88.18 266.75,90.6 268.72,92.57 269.48,92.57 269.66,92.74 269.66,93.77
+3.3V_WLAN on TOP (solid shape): 271.39,190.08 271.39,189.09 271.41,189.07 271.33,188.99 270.42,188.99 270.34,189.06 269.32,189.06 269.27,189.12 269.27,190 269.07,190.21 269.07,190.59 269.26,190.78 270.7,190.78
+3.3V_WLAN on BOTTOM (solid shape): outline of 346 points within 250.11,175.94 284.04,190.83
+3VALWP on TOP (solid shape): 132.76,14.5 132.76,14.04 132.77,14.02 136.38,14.02 136.4,14.04 136.42,14.04 136.42,14.06 136.44,14.08 136.44,14.5 136.5,14.55 136.86,14.55 136.89,14.53 136.89,14.08 136.92,14.05 136.92,14.04 136.93,14.04 136.95,14.03 137.21,14.03 137.22,14.02 137.63,14.02 137.65,14.05 137.65,14.52 137.69,14.55 138.03,14.55 138.1,14.49 138.1,14.05 138.11,14.05 138.14,14.01 138.38,14.01 138.39,14.01 138.87,14.01 139.11,13.77 139.11,12.69 138.9,12.47 137.08,12.47 136.9,12.29 136.9,11.58 136.51,11.19 134.98,11.19 134.48,10.68 134.48,8.39 134.35,8.27 130.28,8.27 130.03,8.52 130.03,13.7 130.35,14.02 131.03,14.02 131.05,14.04 131.09,14.04 131.09,14.07 131.11,14.1 131.11,14.52 131.15,14.55 131.52,14.55 131.55,14.52 131.55,14.07 131.61,14.02 132.27,14.02 132.3,14.06 132.3,14.5 132.37,14.57 132.69,14.57
+3VALWP on BOTTOM (solid shape): outline of 89 points within 129.14,4.46 136.25,12.2
+5V_ALW on TOP (solid shape): 241.22,12.52 241.22,11.7 241.09,11.57 240.77,11.57 239.76,10.55 239.76,9.79 239.5,9.79 239.5,10.81 240.01,11.32 240.01,12.52 240.08,12.59 241.16,12.59
+5V_ALW on TOP (solid shape): 327.45,170.56 327.45,169.29 327.9,168.85 328.47,168.85 328.66,169.04 329.42,169.04 329.8,168.66 329.8,167.51 329.67,167.39 328.47,167.39 327.2,168.66 327.2,170.56 327.26,170.62 327.39,170.62
+5V_ALW on TOP (solid shape): 211.5,18.11 211.5,16.65 210.93,16.08 210.93,15 210.89,14.96 210.76,14.96 210.73,15 210.73,16.09 210.74,16.1 210.74,16.18 210.75,16.28 210.74,16.38 210.74,16.97 210.42,17.28 209.09,17.28 209.02,17.35 209.02,18.17 209.09,18.24 211.37,18.24
+5V_ALW on TOP (solid shape): 200.01,102.12 200.01,100.22 199.82,100.02 196.91,100.02 196.87,100.06 196.87,100.53 196.83,100.57 196.35,100.57 196.32,100.55 196.32,100.06 196.27,100.01 196.11,100.01 196.08,100.04 196.08,100.56 196.06,100.58 195.54,100.58 195.51,100.56 195.51,100.08 195.45,100.01 194.81,100.01 194.67,100.15 194.67,101.99 194.99,102.31 199.82,102.31
+5V_ALW on TOP (solid shape): outline of 565 points within 344.8,198.13 353.17,223.41
+5V_ALW on BOTTOM (solid shape): 352.03,222.52 353.55,222.52 353.68,222.39 353.68,221.63 353.55,221.5 351.9,221.5 351.77,221.37 349.61,221.37 349.36,221.63 349.36,222.52 349.49,222.64 351.9,222.64
+5V_ALW on BOTTOM (solid shape): 34.78,193.05 34.78,191.15 34.65,191.02 30.79,191.02 30.41,191.4 28.9,191.4 28.81,191.49 28.81,192.37 28.86,192.42 30.45,192.42 30.76,192.72 32.16,192.72 32.62,193.18 34.65,193.18
+5V_ALW on BOTTOM (solid shape): 175.78,4.23 175.78,1.22 175.59,1.03 165.9,1.03 165.53,1.39 165.53,4.18 165.63,4.28 166.14,4.28 166.19,4.23 166.19,3.81 166.21,3.78 166.21,3.75 166.25,3.75 166.26,3.73 166.84,3.73 166.85,3.75 166.92,3.75 166.92,4.16 167.04,4.28 167.28,4.28 167.38,4.18 167.38,3.78 167.45,3.72 168.11,3.72 168.14,3.76 168.14,4.22 168.21,4.28 171.42,4.28 171.48,4.22 171.48,3.77 171.51,3.74 171.52,3.74 171.55,3.71 172.18,3.71 172.23,3.76 172.23,4.2 172.28,4.25 172.64,4.25 172.69,4.2 172.69,3.76 172.74,3.71 173.39,3.71 173.44,3.76 173.44,4.22 173.49,4.27 173.97,4.27 173.99,4.29 174.09,4.29 174.09,4.36 174.25,4.52 174.35,4.52 174.35,4.53 175.47,4.53
+5V_ALW on BOTTOM (solid shape): outline of 861 points within 159.71,100.98 200.39,161.24
+5V_ALW on IN3 (solid shape): outline of 2699 points within 164.77,1.97 228.77,13.98
+5V_ALW on IN4 (solid shape): outline of 150 points within 165.02,1.99 189.17,8.08
+5V_ALW on BOTTOM: 223.18,38.33 223.19,38.34 223.19,40.93 223.01,41.11 220.51,41.11 218.62,39.21 218.62,34.06 218.95,33.73 224.32,33.73 224.77,34.18 224.77,34.94 224.12,35.59 223.4,35.59 223.21,35.79 223.21,36.83 223.18,36.85
+5V_ALW on VCC: outline of 272 points within 26.14,1.02 352.41,222.9
+5V_ALW2 on BOTTOM (solid shape): 151.24,10.36 151.24,9.47 150.86,9.09 150.86,7.49 150.83,7.47 150.64,7.47 150.6,7.51 150.6,8.84 150.16,9.28 150.16,10.36 150.29,10.49 151.11,10.49
+5V_HDD on TOP (solid shape): 114.8,41.85 114.8,40.89 114.88,40.81 115.31,40.81 115.35,40.77 115.35,40.63 115.29,40.57 114.85,40.57 114.8,40.52 114.8,40.04 114.83,40.01 115.32,40.01 115.35,39.99 115.35,39.81 115.31,39.77 114.85,39.77 114.8,39.72 114.8,39.29 114.65,39.13 112.75,39.13 112.57,39.32 112.57,41.86 112.76,42.05 114.6,42.05
+5V_HDD on BOTTOM (solid shape): 114.91,41.25 114.91,39 114.46,38.56 111.26,38.56 111.07,38.75 111.07,39.99 111.1,40.02 111.1,41.84 111.34,42.07 114.08,42.07
+5V_MOD on BOTTOM (solid shape): outline of 147 points within 223.78,37.86 237.32,43.59
+5V_RUN on TOP (solid shape): 22.46,211.85 22.46,208.93 22.33,208.8 20.81,208.8 20.68,208.93 20.68,211.85 20.81,211.98 22.33,211.98
+5V_RUN on TOP (solid shape): 279.6,116.09 279.6,114.91 279.38,114.69 278.28,114.69 278.02,114.44 278.02,113.91 278.01,113.89 277.54,113.89 277.43,114.01 277.43,115.28 277.64,115.49 278.06,115.49 278.14,115.57 278.14,115.96 278.24,116.07 278.24,116.09 278.39,116.24 279.45,116.24
+5V_RUN on TOP (solid shape): 52.18,200.22 52.18,198.08 52.31,197.95 52.31,197.04 52.18,196.91 50.4,196.91 50.15,196.66 50.15,195.64 49.89,195.39 37.45,195.39 37.32,195.52 37.32,197.04 37.7,197.42 49.13,197.42 50.91,199.2 50.91,200.22 51.04,200.34 52.05,200.34
+5V_RUN on TOP (solid shape): 117.71,41.54 117.71,37.86 117.33,37.48 115.3,37.48 115.03,37.75 115.03,39.59 115.05,39.61 115.52,39.61 115.57,39.66 115.57,40.09 115.51,40.16 115.05,40.16 115.03,40.18 115.03,40.39 115.05,40.41 115.53,40.41 115.57,40.45 115.57,40.91 115.52,40.96 115.09,40.96 115.03,41.02 115.03,41.65 115.17,41.8 117.46,41.8
+5V_RUN on TOP (solid shape): 276.08,136.79 276.08,127.52 275.7,127.14 274.47,127.14 273.11,127.14 273.03,127.14 272.27,126.38 272.27,124.6 268.97,121.3 268.97,118.37 268.93,118.36 268.69,118.02 268.93,117.68 268.97,117.67 268.97,116.09 268.33,115.46 265.92,115.46 265.67,115.71 265.67,120.35 270.75,125.43 270.75,128.79 271.25,129.3 273.09,129.3 273.18,129.25 273.17,129.14 273.52,128.6 273.73,129.21 273.71,129.23 273.71,129.3 273.79,129.3 274.18,129.68 274.18,136.79 274.3,136.92 275.95,136.92
+5V_RUN on BOTTOM (solid shape): 114.31,94.48 120.46,94.48 120.87,94.06 120.87,92.94 120.85,92.94 120,92.09 120,89 119.97,88.93 119.89,88.9 119.5,88.54 119.89,88.19 119.97,88.16 120,88.09 120,82.94 119.49,82.44 114.41,82.44 114.21,82.64 114.21,84.38 114.47,84.65 117.89,84.65 118.47,85.23 118.47,92.09 117.93,92.63 113.7,92.63 111.96,94.37 111.21,94.37 110.9,94.68 110.9,95.43 111.37,95.9 112.89,95.9
+5V_RUN on BOTTOM (solid shape): outline of 161 points within 341.27,178 344.66,181.77
+5V_RUN on BOTTOM (solid shape): outline of 335 points within 261.61,82.2 268.84,117.49
+5V_RUN on BOTTOM (solid shape): outline of 749 points within 208.77,26.59 250.93,84.98
+5V_RUN on IN1 (solid shape): outline of 279 points within 313.01,133.54 335.61,157.22
+5V_RUN on IN2 (solid shape): 267.7,116.81 267.7,115.87 267.41,115.58 266.2,115.58 265.96,115.82 265.96,117.14 266.17,117.36 267.15,117.36
+5V_RUN on IN2 (solid shape): 261.83,84.24 261.83,84.22 261.97,83.92 262.3,83.87 262.45,83.87 262.59,83.92 262.6,83.93 262.73,83.93 262.73,83.03 262.46,82.76 260.52,82.76 260.21,83.07 249.92,83.07 249.58,83.41 249.58,84 249.55,84.02 249.55,84.56 249.79,84.8 261.27,84.8
+5V_RUN on IN2 (solid shape): outline of 430 points within 274.81,131.97 315.91,139.08
+5V_RUN on IN2 (solid shape): outline of 682 points within 112.63,37.26 116.98,84.47
+5V_RUN on IN3 (solid shape): 53.32,198.06 53.32,197.04 52.69,196.41 51.8,196.41 50.91,197.29 50.91,198.69 51.29,199.07 52.31,199.07
+5V_RUN on IN3 (solid shape): 115.68,86.12 115.68,82.56 115.55,82.44 113.77,82.44 113.41,82.8 113.41,86.07 113.79,86.45 114.49,86.45 114.54,86.5 115.3,86.5
+5V_RUN on IN3 (solid shape): outline of 727 points within 331.83,155.97 343.9,182.64
+5V_RUN on TOP: 315.35,134.91 314.74,135.52 313.29,135.52 313.16,135.39 313.16,134.28 313.29,134.15 315.1,134.15 315.32,134.38 315.4,134.3 316.34,134.3 316.42,134.38 318.24,134.38 318.37,134.51 318.37,135.01 318.24,135.14 316.57,135.14 316.34,134.91
+5V_RUN on VCC: 122.64,10.05 115.93,16.75 115.93,27.42 114.92,28.44 114.92,41.69 115.53,42.3 120.91,42.3 121.52,41.69 121.52,32.8 124.08,30.24 129.65,30.24 129.65,15.53 131.07,14.11 187.41,14.11 193.76,20.46 203.92,20.46 213.83,30.37 219.33,30.37 219.82,29.88 219.82,12.31 219.33,11.82 204.73,11.82 202.95,10.05
+5V_RUN on IN4: 223.38,45.77 223.38,45.86 223.5,45.99 225.15,45.99 225.53,45.61 225.53,44.99 227,43.53 227,29.07 225.88,27.95 217.66,27.95 216.64,28.97 216.64,30.62 217.15,31.13 219.95,31.13 221.6,32.78 221.6,42.81 223.38,44.59 223.38,44.93 223.39,45.03 223.38,45.13 223.38,45.57 223.39,45.67
+5V_USB_CHG_PWR on TOP (solid shape): outline of 269 points within 332.39,222.26 348.18,227.47
+5V_USB_CHG_PWR on BOTTOM (solid shape): 349.3,223.85 349.3,222.63 349.23,222.57 349.23,221.56 349.16,221.49 346.83,221.49 346.79,221.52 346.77,221.56 346.79,221.6 346.57,222.24 346.34,221.6 346.36,221.56 346.34,221.52 346.3,221.49 345.82,221.49 345.62,221.68 345.56,221.76 345.48,221.83 345.21,222.09 345.21,222.11 345.06,222.4 344.76,222.56 344.74,222.56 344.28,223.02 344.28,224.29 344.53,224.55 348.6,224.55
+5V_USB_PWR2_3 on TOP (solid shape): outline of 103 points within 348.93,208.8 357.68,216.93
+5V_USB_PWR2_3 on TOP (solid shape): outline of 195 points within 348.34,190.77 357.83,196.35
+5V_USB_PWR2_3 on IN1: 349.8,211.52 354.17,211.52 354.74,210.95 354.74,192.15 354.47,191.87 351.72,191.87 351.25,192.34 351.25,208.23 349.6,209.88 349.6,211.32
+5V_USB_PWR4 on BOTTOM (solid shape): 25.99,193.26 25.99,191.41 25.92,191.34 24.34,191.34 22.33,189.33 22.33,187.59 22.08,187.34 19.29,187.34 19.28,187.34 17.06,187.34 16.49,186.77 16.49,186.32 16.42,186.25 14.51,186.25 14.21,186.55 14.21,189.5 16.89,192.18 21.69,192.18 22.94,193.43 25.81,193.43
+5VALWP on BOTTOM (solid shape): outline of 549 points within 161.78,3.86 174.23,10.81
+AVCC33 on BOTTOM (solid shape): 173.22,143.36 173.22,141.81 172.7,141.29 172.7,138.38 172.58,138.25 171.62,138.25 170.99,138.89 170.99,140.86 171.34,140.86 171.34,140.8 171.35,140.75 171.37,140.7 171.39,140.65 171.42,140.61 171.46,140.57 171.5,140.54 171.54,140.51 171.59,140.49 171.65,140.48 171.7,140.47 171.75,140.48 171.8,140.49 171.85,140.51 171.9,140.54 171.94,140.57 171.98,140.61 172.01,140.65 172.03,140.7 172.05,140.75 172.06,140.8 172.06,140.86 172.05,140.91 172.03,140.96 172.01,141.01 171.98,141.05 171.94,141.09 171.9,141.12 171.85,141.15 171.8,141.17 171.75,141.18 171.7,141.19 171.65,141.18 171.59,141.17 171.54,141.15 171.5,141.12 171.46,141.09 171.42,141.05 171.39,141.01 171.37,140.96 171.35,140.91 171.34,140.86 170.99,140.86 170.99,141.25 171.66,141.92 171.66,143.34 171.74,143.42 173.16,143.42
+DVCC33 on TOP (solid shape): 177.15,135.46 177.15,134.57 177.27,134.44 177.42,134.44 177.46,134.44 177.78,134.44 177.82,134.44 177.97,134.44 178.1,134.31 178.1,133.93 177.97,133.81 177.17,133.81 176.89,134.08 176.89,135.52 177.08,135.52
+DVCC33 on BOTTOM (solid shape): 177.22,135.36 178.29,135.36 178.31,135.34 180.77,135.34 181.71,134.4 181.71,132.12 181.68,132.09 180.09,132.09 179.62,132.57 177.73,132.57 176.44,133.86 175.42,133.86 175.07,134.21 175.07,135.32 175.11,135.36 176.15,135.36 176.25,135.46 177.12,135.46
+VCC_CORE on TOP (solid shape): 152.99,98.06 152.99,95.02 152.94,94.97 150.67,94.97 150.6,95.03 150.6,98.13 150.88,98.41 152.64,98.41
+VCC_CORE on TOP (solid shape): outline of 4141 points within 122.66,100.19 165.53,133.02
+VCC_CORE on BOTTOM (solid shape): outline of 4795 points within 122.79,100.22 167.47,132.73
+VCC_CORE on IN1 (solid shape): outline of 6548 points within 133.46,96.66 167.5,132.49
+VCC_CORE on IN2 (solid shape): outline of 11702 points within 122.92,97.87 167.33,132.97
+VCC_CORE on IN4 (solid shape): outline of 1644 points within 123.05,122.67 158.48,132.73
+VCC_CORE on IN4 (solid shape): outline of 6273 points within 140.44,98.06 167.5,118.63
+VCC_CORE on VCC: 142.33,88.79 142.1,89.02 142.1,109.72 125.82,126 123.91,126 123.3,126.61 123.3,131.61 123.91,132.22 127.72,132.22 128.23,132.73 165.36,132.73 165.97,132.11 165.97,130.59 167.37,129.19 167.37,106.92 166.73,106.29 166.73,104.68 167.37,104.05 167.37,91.83 165.36,91.83 163.94,90.41 163.94,88.79
+VDDA_AVDD on TOP (solid shape): 349.4,169.63 349.4,168.39 349.18,168.17 347.99,168.17 347.85,168.31 347.85,168.77 347.56,169.06 346.25,169.06 345.87,169.44 344.41,169.44 344.33,169.52 344.33,169.66 344.39,169.72 349.31,169.72
+VDDA_AVDD on BOTTOM (solid shape): 347.64,181.51 347.64,180.16 347.35,179.87 345.31,179.87 345.18,180 345.18,181.72 345.26,181.8 347.36,181.8
+VDDA_AVDD on IN1 (solid shape): 348.22,180.96 348.22,170.74 349.39,169.57 349.39,168.67 349.3,168.58 348.93,168.58 347.23,170.28 347.23,181.01 347.26,181.05 348.13,181.05
+VDDA_AVDD2 on BOTTOM (solid shape): 347.68,176.72 347.68,174.28 347.56,174.15 346.38,174.15 346.27,174.26 346.27,174.6 346.83,174.6 346.83,175.08 346.27,175.08 346.27,175.63 345.96,175.95 345.75,175.95 345.66,176.03 345.66,176.94 345.72,176.99 347.42,176.99
+VDDA_PVDD on TOP (solid shape): 344.03,176.67 344.03,176.16 343.14,175.27 343.14,174.49 343.07,174.42 342.92,174.42 342.83,174.51 342.83,175.35 343.14,175.65 343.14,176.42 343.52,176.8 343.9,176.8
+VDDA_PVDD on TOP (solid shape): 339.91,175.98 339.91,175.49 340.11,175.29 340.11,174.36 340.06,174.31 339.9,174.31 339.82,174.38 339.82,175.32 339.72,175.42 339.63,175.42 339.14,175.91 339.14,176.26 339.29,176.4 339.49,176.4
+VDDA_PVDD on BOTTOM (solid shape): 342.26,178.4 342.26,177.85 342.68,177.85 342.77,177.76 343.91,177.76 344.03,177.65 344.03,176.03 343.64,175.65 343.26,175.65 343.14,175.78 343.14,176.8 343.01,176.92 340.22,176.92 339.96,176.67 339.96,175.53 339.58,175.15 339.58,174.64 339.45,174.51 338.69,174.51 338.56,174.64 338.56,175.91 337.68,176.8 337.68,177.81 337.8,177.94 341.37,177.94 341.46,177.85 342.08,177.85 342.08,178.38 342.11,178.41 342.25,178.41
GND on TOP (solid shape): 368.66,188.73 368.66,185.69 358,185.69 357.61,186.07 357.61,188.61 358,188.99 368.41,188.99
GND on TOP (solid shape): 105.14,189.14 105.14,186.21 104.97,186.04 103.3,186.04 103.17,186.17 103.17,189.13 103.39,189.34 104.94,189.34
GND on TOP (solid shape): 113.14,190.13 113.14,187.21 112.63,186.7 107.3,186.7 106.15,187.85 106.15,190 106.54,190.39 112.89,190.39
GND on TOP (solid shape): 188.24,96.28 188.24,89.55 188.11,89.42 186.06,89.42 185.85,89.63 185.85,96.3 185.95,96.41 188.11,96.41
GND on TOP (solid shape): 195.05,98.18 195.05,96.15 194.93,96.02 193.66,96.02 193.53,96.15 193.53,98.18 193.66,98.31 194.93,98.31
GND on TOP (solid shape): 278,33.71 278,32.84 277.93,32.77 276.87,32.77 276.78,32.86 276.78,33.69 276.96,33.87 277.83,33.87
GND on TOP (solid shape): 289.54,137.81 289.54,136.16 289.42,136.03 286.24,136.03 286.11,136.16 286.11,137.81 286.24,137.93 289.42,137.93
GND on TOP (solid shape): 142.36,127.43 142.36,125.56 141.65,124.85 139.67,124.85 139.23,125.3 139.23,127.37 139.4,127.55 142.25,127.55
GND on TOP (solid shape): 109.28,160.91 109.28,160.25 108.28,159.25 108.28,158.7 108.17,158.6 107.16,158.6 106.8,158.95 106.8,159.5 108.34,161.04 109.15,161.04
GND on TOP (solid shape): 163.81,66.56 163.81,63.77 163.56,63.51 155.1,63.51 155,63.61 155,66.64 155.18,66.81 163.56,66.81
GND on TOP (solid shape): 198.93,85.67 198.93,85.45 197.8,84.32 197.47,84.32 196.64,85.14 196.64,85.42 197.66,86.44 198.17,86.44
GND on TOP (solid shape): 336.53,201.18 336.53,197.24 336.22,196.93 328.65,196.93 328.53,197.04 328.53,200.04 329.8,201.31 336.41,201.31
GND on TOP (solid shape): 337.83,187.69 337.83,186.36 337.79,186.32 336.22,186.32 336,186.54 336,187.73 336.04,187.77 337.75,187.77
GND on TOP (solid shape): 128.25,163.59 128.25,161.05 128.13,160.92 125.71,160.92 124.95,161.68 124.06,161.68 123.81,161.94 121.65,161.94 121.52,162.06 121.52,163.59 121.65,163.72 128.13,163.72
GND on TOP (solid shape): 241.85,100.53 241.85,99.01 241.73,98.88 237.35,98.88 237.28,98.95 237.28,100.41 237.35,100.47 240.95,100.47 241.02,100.53 241.03,100.53 241.09,100.6 241.79,100.6
GND on TOP (solid shape): 267.23,36.91 267.23,36.08 267.67,35.64 267.67,34.23 267.6,34.15 266.45,34.15 266.18,34.42 266.18,37.04 266.33,37.19 266.95,37.19
GND on TOP (solid shape): 18.27,210.65 18.27,209.44 18.12,209.28 16.71,209.28 16.62,209.37 16.62,210.76 16.81,210.95 17.98,210.95
GND on TOP (solid shape): 173.5,13.66 173.5,10.01 172.69,9.19 169.54,9.19 169.43,9.31 169.39,9.31 168.89,9.8 168.89,13.59 169.31,14.01 173.16,14.01
GND on TOP (solid shape): 78.2,183.43 78.2,182.5 78.9,181.8 78.9,181.46 78.76,181.32 78.53,181.32 77.95,181.9 77.95,183.39 78.02,183.46 78.16,183.46
GND on TOP (solid shape): 115.27,28.82 115.27,12.99 114.79,12.51 112.23,12.51 111.45,11.73 111.45,8.13 111.2,7.87 108.91,7.87 108.05,8.73 108.05,28.73 108.69,29.37 114.71,29.37
GND on TOP (solid shape): 157.19,127.76 157.19,125.6 156.95,125.36 155.05,125.36 154.92,125.23 154.92,124.85 154.62,124.55 154.26,124.55 153.6,125.21 153.6,127.42 154,127.81 157.14,127.81
GND on TOP (solid shape): 117.2,173.37 117.33,173.24 117.33,171.56 116.85,171.08 111.62,171.08 111.36,171.34 110.22,171.34 110.16,171.27 109.43,171.27 109.2,171.5 109.2,172.76 109.81,173.37 112.71,173.37
GND on TOP (solid shape): 348.22,221.96 348.22,219.85 348.09,219.72 347.2,219.72 347.11,219.81 347.02,219.94 346.9,220.03 346.31,220.61 346.31,221.98 346.46,222.13 348.04,222.13
GND on TOP (solid shape): 195.31,18.3 195.31,11.19 195.05,10.93 191.35,10.93 191.07,11.21 191.07,12.51 190.86,12.71 189.04,12.71 188.67,13.08 188.67,15.21 189.97,16.52 190.99,16.52 192.92,18.45 193.1,18.45 193.21,18.55 195.05,18.55
GND on TOP (solid shape): 309.01,166.22 309.01,164.97 308.92,164.88 308.47,164.88 308.43,164.85 308.43,164.35 308.4,164.33 308.28,164.33 308.25,164.35 308.25,164.85 308.21,164.88 307.72,164.88 307.53,165.07 307.53,166.24 307.59,166.31 308.92,166.31
GND on TOP (solid shape): 13.95,196.99 13.95,191.27 13.57,190.89 4.24,190.89 2.92,192.21 1.46,192.21 1.25,192.42 1.25,195.97 1.51,196.23 7.22,196.23 7.86,195.59 9.51,195.59 10.4,196.48 10.4,198.13 10.78,198.51 12.43,198.51
GND on TOP (solid shape): 229.85,7.51 229.85,5.22 229.73,5.09 227.19,5.09 226.93,4.84 223.5,4.84 223.5,4.84 222.99,5.35 222.99,5.35 222.74,5.6 222.74,7.38 222.99,7.63 229.73,7.63
GND on TOP (solid shape): 138.48,12.08 138.48,5.98 138.16,5.66 136.15,5.66 135.96,5.85 135.96,6.69 135.73,6.92 135.14,6.92 134.73,7.33 134.73,10.75 135.04,11.06 136.56,11.06 136.61,11.11 136.81,11.11 137.07,11.37 137.07,12.09 137.3,12.32 138.24,12.32
GND on TOP (solid shape): 341.61,175.3 341.61,174.26 341.74,174.13 343.9,174.13 344.03,174 344.03,168.67 343.9,168.54 338.56,168.54 338.44,168.67 338.44,174.13 341.1,174.13 341.36,174.38 341.36,175.27 341.42,175.34 341.57,175.34
GND on TOP (solid shape): 347.71,207.53 347.71,205.75 348.22,205.24 348.22,204.61 347.11,203.5 344.18,203.5 343.84,203.85 343.84,205.23 343.98,205.37 345.68,205.37 345.76,205.45 346.29,205.45 346.43,205.59 346.43,206.83 346.13,207.12 346.13,207.66 346.26,207.78 347.45,207.78
GND on TOP (solid shape): 334.53,160.29 334.53,159.94 334.6,159.87 335.05,159.87 335.09,159.83 335.09,159.73 335.05,159.69 334.6,159.69 334.53,159.61 334.53,159.28 334.49,159.25 333.88,159.25 333.68,159.45 333.68,160.17 333.83,160.32 334.49,160.32
GND on TOP (solid shape): 142.69,182.33 142.69,178.63 142.26,178.19 139.94,178.19 139.68,177.94 138.54,177.94 138.41,178.07 137.83,178.07 137.83,178.07 137.02,178.07 136.76,178.32 136.76,179.97 136.89,180.1 136.9,180.1 136.9,180.11 139.59,182.8 142.22,182.8
GND on TOP (solid shape): 234.79,106.29 235.05,106.29 235.19,106.15 235.19,102.5 234.52,101.83 233.77,101.83 233.37,101.43 232.53,101.43 232.41,101.56 232.41,102.83 232.53,102.96 232.76,102.96 233.43,103.63 233.43,106.13 233.61,106.31 234.79,106.31
GND on TOP (solid shape): 122.54,156.1 122.54,153.22 122.53,153.19 122.52,153.17 122.42,153.08 122.36,152.96 122.34,152.93 122.31,152.92 121.65,152.92 121.27,153.3 118.73,153.3 118.6,153.43 118.6,155.08 119.11,155.59 119.11,156.1 119.24,156.22 122.41,156.22
GND on TOP (solid shape): 162.16,13.73 162.16,6.87 162.03,6.74 161.83,6.74 159.88,6.74 159.49,7.12 159.49,8.27 159.19,8.57 159.19,8.71 158.95,8.95 158.95,8.96 158.88,9.06 158.78,9.13 158.77,9.13 158.72,9.18 158.45,9.18 157.97,9.66 156.7,9.66 156.45,9.92 156.45,13.98 156.7,14.24 161.65,14.24
GND on TOP (solid shape): 325.23,173.35 325.23,170.81 325.22,170.8 325.14,170.75 325.08,170.67 325.07,170.66 324.98,170.56 324.98,169.35 324.72,169.35 324.72,171.39 323.77,172.34 323.03,172.34 322.93,172.35 322.84,172.34 321.36,172.34 321.1,172.59 321.1,175.26 321.48,175.64 322.94,175.64
GND on TOP (solid shape): 141.18,171.52 141.93,171.52 141.93,172.08 142.38,172.08 142.38,171.52 143.12,171.52 143.12,172.08 143.71,172.08 143.75,172.04 143.75,165.8 143.53,165.58 141.82,165.58 141.59,165.35 141.59,163.93 141.4,163.74 138.74,163.74 138.67,163.82 138.67,166.75 139.68,167.77 139.68,170.87 139.7,170.89 139.7,171.88 139.9,172.08 141.18,172.08
GND on TOP (solid shape): 338,237.58 338.26,237.51 338.44,237.31 338.44,230.39 339.83,228.99 339.83,227.72 338.82,226.71 337.04,226.71 336.79,226.96 336.79,237.36 336.96,237.52 337.2,237.58
GND on TOP (solid shape): 368.53,212.48 368.71,212.3 368.78,212.06 368.78,204.06 368.74,203.88 368.64,203.72 358.35,203.72 356.14,201.51 352.17,201.51 351.9,201.78 351.9,206.27 353.39,207.76 356.76,207.76 357.87,208.86 357.87,212.23 358.12,212.48
GND on TOP (solid shape): 317.86,201.25 317.86,198.46 317.86,198.46 317.86,198.26 319.39,196.74 319.39,195.79 319.39,195.47 319.26,195.34 317.86,195.34 317.74,195.46 317.74,196.15 317.74,196.23 317.36,196.61 315.45,196.61 315.2,196.86 315.2,197.24 315.07,197.37 314.64,197.37 314.38,197.12 314.05,197.12 313.93,197.24 313.93,201.61 314.13,201.81 317.3,201.81
GND on TOP (solid shape): 136.16,41.03 136.42,40.93 136.68,41.03 138.74,41.03 138.96,40.96 139.18,41.03 140.27,41.03 140.89,40.41 140.89,37.74 140.37,37.22 134.98,37.22 134.73,37.48 134.73,40.78 134.98,41.03
GND on TOP (solid shape): 161.34,155.78 161.34,155.21 161.15,155.02 160.45,155.02 160.38,154.95 160.38,154.85 160.33,154.69 160.38,154.54 160.38,154.4 160.33,154.34 160.33,154.19 160.33,154.09 160.38,154.04 160.38,153.9 160.32,153.84 160.32,153.68 160.26,153.62 159.49,153.62 159.43,153.68 159.43,154.07 159.43,154.79 159.43,155.05 159.43,155.78 159.62,155.97 161.15,155.97
GND on TOP (solid shape): 368.51,228.99 368.7,228.81 368.78,228.56 368.78,227.56 368.63,227.21 368.29,227.07 368.09,227.07 368.09,227.09 359.13,227.09 358.57,226.53 358.57,226.26 355.57,223.27 355.57,222.24 355.24,221.91 352.29,221.91 352.09,222.11 352.09,225.45 352.18,225.54 354.8,225.54 357.74,228.49 358.38,228.49 358.88,228.99
GND on TOP (solid shape): 23.19,174.17 23.19,168.76 22.91,168.48 13.57,168.48 10.96,167.36 8.37,168.54 1.51,168.54 1.25,168.8 1.25,173.38 1.86,173.98 2.8,173.98 4.09,175.27 22.08,175.27
GND on TOP (solid shape): 166.14,38.71 166.14,35.47 165.73,35.06 162.23,35.06 160.83,36.46 160.59,36.46 160.58,36.47 160.39,36.52 160.2,36.46 158.15,36.46 158.02,36.59 158.02,37.17 158.58,37.73 159.88,37.73 159.98,37.63 159.98,37.61 160.29,37.26 160.68,37.51 160.68,37.52 160.89,37.73 160.89,37.76 161.02,37.88 161.02,38.9 161.2,39.09 165.76,39.09
GND on TOP (solid shape): 287.64,134.89 287.64,134.12 287.45,133.93 287.45,133.04 287.38,132.98 284.53,132.98 284.08,132.54 279.32,132.54 279.13,132.73 279.13,133.42 279.13,133.43 279.15,133.53 279.13,133.64 279.13,133.65 279.13,134.31 279.19,134.38 281.35,134.38 281.41,134.31 281.61,134.31 281.68,134.31 281.76,134.31 282.11,134.31 282.18,134.31 282.26,134.31 282.5,134.31 282.61,134.31 282.68,134.31 282.76,134.31 283.11,134.31 283.18,134.31 283.31,134.31 283.61,134.31 283.68,134.31 283.76,134.31 284.53,134.31 285.35,135.14 287.38,135.14
GND on TOP (solid shape): 289.03,124.09 289.03,123.2 289.42,122.82 289.8,122.82 289.89,122.73 289.89,122.15 289.8,122.06 285.86,122.06 285.73,122.19 285.73,122.82 285.86,122.95 286,122.95 286.01,122.94 286.23,122.87 286.45,122.95 286.99,122.95 287.35,122.92 287.55,123.22 287.55,123.24 287.81,123.5 287.84,123.49 288.27,123.61 288.24,124.05 288.22,124.12 288.25,124.19 288.27,124.22 288.91,124.22
GND on TOP (solid shape): 366.98,160.71 366.55,159.66 365.5,159.22 364,159.22 361.51,158.19 360.48,155.71 360.48,153.06 360.05,152.01 359,151.57 338.11,151.57 338.11,157.06 348.04,157.06 350.3,154.8 353.07,154.8 354.02,155.76 356.31,155.76 357.26,156.71 357.26,165.09 359.39,167.22 366.98,167.22
GND on TOP (solid shape): 113.23,99.52 113.23,82.63 114.75,81.1 130.55,81.1 133.02,78.64 133.02,73.63 131.5,72.12 119.64,72.12 112.71,65.19 108.67,65.19 108.05,65.81 108.05,88.76 107.46,90.18 106.04,90.77 98.84,90.77 97.03,91.94 97.36,94.07 100.09,97.45 102.51,101.05 111.69,101.05
GND on TOP (solid shape): outline of 89 points within 298.69,148.73 303.51,158.62
GND on TOP (solid shape): 317.31,228.56 317.88,228.61 318.46,228.57 320.65,228.57 321.9,228.57 321.9,225.17 320.97,221.92 317.9,220.5 314.82,221.93 313.9,225.19 313.9,228.56
GND on TOP (solid shape): 62.87,204.83 66.55,205.19 68.5,202.06 67.24,199.37 64.37,198.61 60.34,198.61 59.93,199.02 59.93,201.18 60.43,201.69 60.43,202.45 59.29,203.59 59.29,204.23 59.9,204.83
GND on TOP (solid shape): 45.71,198.63 41.71,203.25 47.74,204.23 50.53,204.23 50.66,204.1 50.66,203.34 49.64,202.32 49.64,201.82 50.15,201.31 50.15,199.02 49.75,198.63
GND on TOP (solid shape): 303.26,168.92 303.26,162.79 302.51,162.04 302.51,160.17 301.72,159.39 300.67,159.39 300.58,159.43 300.57,159.52 300.43,159.97 299.96,159.94 299.89,159.91 299.83,159.94 299.42,160 299.19,159.64 299.13,159.55 299.02,159.57 298.94,159.65 298.94,162.57 299.07,162.7 299.07,164.52 299.09,164.53 299.28,164.77 299.21,165.06 299.2,165.13 299.23,165.2 299.37,165.55 299.11,165.83 299.07,165.84 299.07,168.92 299.32,169.18 303,169.18
GND on TOP (solid shape): 72.6,218.02 72.6,199.66 70.95,198.01 64.4,198.01 62.87,199.53 62.87,207.26 62.95,207.48 62.87,207.7 62.87,208.24 62.26,208.85 37.65,208.85 32.29,214.21 25.02,214.21 24.21,217.51 23.41,214.21 15.21,214.21 12.54,211.54 10.57,211.54 10.37,211.75 10.37,213.58 9.56,214.39 7.78,214.39 7.3,213.91 1.28,213.91 1.11,214.07 1.11,215.25 1.35,215.49 10.56,215.49 13.37,218.3 72.32,218.3
GND on TOP (solid shape): 210.13,15.8 210.13,14.85 210.23,14.74 210.35,14.74 210.42,14.73 210.49,14.74 210.75,14.74 210.82,14.73 210.89,14.74 211.15,14.74 211.2,14.73 211.26,14.73 211.3,14.69 211.3,14.63 211.31,14.58 211.31,14.33 211.3,14.26 211.31,14.18 211.31,13.93 211.3,13.86 211.31,13.78 211.31,13.53 211.3,13.46 211.31,13.38 211.31,13.13 211.3,13.08 211.3,13.02 211.26,12.98 211.2,12.98 211.15,12.97 210.89,12.97 210.82,12.98 210.75,12.97 210.61,12.97 210.55,12.9 210.55,11.93 210.49,11.86 210.36,11.86 210.32,11.9 210.32,12.98 210.27,13.03 209.79,13.03 209.72,12.97 209.72,11.89 209.53,11.89 209.53,12.86 209.57,12.89 209.57,13.15 209.53,13.18 209.53,13.35 209.55,13.36 209.55,13.58 209.53,13.59 209.53,13.78 209.54,13.86 209.53,13.93 209.53,14.18 209.54,14.26 209.53,14.33 209.53,14.59 209.54,14.63 209.54,14.69 209.59,14.73 209.65,14.73 209.69,14.74 209.85,14.74 209.91,14.81 209.91,15.81 209.95,15.85 210.08,15.85
GND on TOP (solid shape): 321.7,237.58 322.02,237.46 322.18,237.17 322.18,227.98 322.69,227.47 323.71,227.47 323.96,227.22 323.96,225.18 323.32,224.55 321.9,224.55 314.63,222.26 319.25,228.32 319.25,228.35 320.53,229.63 320.53,237.42 320.7,237.54 320.9,237.58
GND on TOP (solid shape): outline of 143 points within 83.89,172.73 98.66,180.35
GND on TOP (solid shape): outline of 164 points within 123.17,145.81 159.1,152.84
GND on TOP (solid shape): outline of 238 points within 284.46,36.41 304.23,63.9
GND on TOP (solid shape): outline of 289 points within 245.22,0.65 290.1,25.67
GND on TOP (solid shape): outline of 311 points within 142.73,92.34 166.17,100.79
GND on BOTTOM (solid shape): 119.21,28.92 119.21,23.74 115.12,19.65 115.12,9.89 108.05,9.89 108.05,29.34 118.79,29.34
GND on BOTTOM (solid shape): 113.08,190.32 113.08,186.7 112.89,186.51 107.62,186.51 106.15,187.97 106.15,190.32 106.35,190.51 112.89,190.51
GND on BOTTOM (solid shape): 113.44,172.66 113.44,171.46 113.2,171.22 109.48,171.22 109.21,171.49 109.21,172.61 109.63,173.04 113.06,173.04
GND on BOTTOM (solid shape): 127.36,11.95 127.36,9.54 127.24,9.41 124.06,9.41 123.81,9.66 123.81,11.95 124.06,12.2 127.11,12.2
GND on BOTTOM (solid shape): 178.29,140.98 178.29,135.78 178.16,135.65 173.66,135.65 172.89,136.41 172.89,141.11 173.21,141.43 177.85,141.43
GND on BOTTOM (solid shape): 233.73,112.26 233.73,110.44 233.27,109.98 232.3,109.98 232.14,110.15 232.14,112.34 232.2,112.41 233.57,112.41
GND on BOTTOM (solid shape): 368.73,188.61 368.73,185.69 358,185.69 357.61,186.07 357.61,188.61 358,188.99 368.35,188.99
GND on BOTTOM (solid shape): 158.05,127.06 158.05,125.37 157.78,125.11 157.23,125.11 156.76,124.64 154.25,124.64 153.61,125.27 153.61,126.97 153.93,127.29 157.82,127.29
GND on BOTTOM (solid shape): 169.78,15.01 169.78,11.37 169.65,11.24 166.02,11.24 165.36,11.9 165.36,13.77 166.01,14.41 167.43,14.41 168.28,15.27 169.53,15.27
GND on BOTTOM (solid shape): 323.3,196.7 323.3,195.53 323.24,195.47 322.44,195.47 321.8,196.1 321.8,197.37 321.93,197.5 322.51,197.5
GND on BOTTOM (solid shape): 143.11,127.27 143.11,125.11 142.83,124.82 141.87,124.82 141.85,124.8 138.97,124.8 138.16,125.62 138.16,127.27 138.41,127.52 142.86,127.52
GND on BOTTOM (solid shape): 150.6,132.08 150.6,129.44 150.14,128.97 149.53,128.97 149.11,129.39 146.38,129.39 145.63,130.14 145.63,132.45 145.88,132.7 149.98,132.7
GND on BOTTOM (solid shape): 180.46,152.77 181.22,152.77 181.36,152.63 181.36,149.42 181.16,149.21 179.78,149.21 179.52,149.47 179.52,152.97 179.61,153.06 180.17,153.06
GND on BOTTOM (solid shape): 182.28,15.28 182.28,11.66 181.86,11.24 178.06,11.24 177.58,11.72 177.58,15 178.09,15.51 182.05,15.51
GND on BOTTOM (solid shape): 278.49,151.14 278.49,148.68 278.39,148.57 271.24,148.57 271.15,148.65 270.57,148.65 270.49,148.73 270.49,151.14 270.75,151.4 278.24,151.4
GND on BOTTOM (solid shape): 21.95,196.35 21.95,193.29 21.33,192.67 18.18,192.67 17.38,193.47 17.38,196.23 17.64,196.48 21.83,196.48
GND on BOTTOM (solid shape): 203.65,114.43 203.88,114.43 204.01,114.3 204.01,110.63 203.72,110.34 203.2,110.34 202.89,110.64 202.89,112.37 201.54,113.72 201.54,114.35 202.47,115.28 202.8,115.28
GND on BOTTOM (solid shape): 230.27,42.71 230.27,41.65 230.17,41.55 227.82,41.55 227.5,41.86 227.5,42.73 227.61,42.83 230.16,42.83
GND on BOTTOM (solid shape): 195.44,97.8 195.44,96.76 196.7,95.5 197.93,95.5 198.69,94.73 198.69,93.41 198.49,93.21 196.19,93.21 193.65,95.76 193.65,97.79 193.91,98.06 195.18,98.06
GND on BOTTOM (solid shape): 13.95,196.99 13.95,191.27 13.57,190.89 4.2,190.89 2.88,192.21 1.46,192.21 1.25,192.42 1.25,195.97 1.51,196.23 7.22,196.23 7.86,195.59 9.51,195.59 10.4,196.48 10.4,198.13 10.78,198.51 12.43,198.51
GND on BOTTOM (solid shape): 148.7,13.58 148.7,11.3 148.56,11.16 148.56,11.14 148.06,10.64 143.91,10.64 143.61,10.95 143.61,11.89 142.95,12.55 142.95,15.16 143.19,15.41 143.93,15.41 143.96,15.44 146.83,15.44
GND on BOTTOM (solid shape): 75.93,183.4 75.93,183.02 75.98,183.02 75.98,183.01 76.44,183.01 76.44,182.78 75.98,182.78 75.98,182.77 75.93,182.77 75.93,182.13 75.8,182 74.91,182 74.79,182.13 74.79,182.38 75.29,182.89 75.29,183.04 75.57,183.32 75.57,183.53 75.8,183.53
GND on BOTTOM (solid shape): 306.89,163.71 306.92,163.71 306.97,163.66 308.16,163.66 308.21,163.61 308.21,163.46 308.16,163.41 307.3,163.41 307.25,163.46 306.49,163.46 306.44,163.51 305.67,163.51 305.67,163.92 305.72,163.97 306.64,163.97
GND on BOTTOM (solid shape): 109.84,92.54 109.84,86.73 114.89,81.67 118.3,81.67 119.49,80.48 119.49,73.67 113.14,67.32 113.14,65.21 108.05,65.21 108.05,80.85 108.06,80.86 108.05,80.87 108.05,89.73 106.92,90.86 104.66,90.86 104.35,91.16 104.35,94.79 104.95,95.39 106.99,95.39
GND on BOTTOM (solid shape): 194.04,16.27 194.04,15.13 193.78,14.87 193.53,14.87 193.4,14.74 193.4,14.41 193.3,14.31 192.26,14.31 192.13,14.19 192.13,13.35 192.39,13.09 193.18,13.09 193.45,12.81 193.45,12.56 193.23,12.33 188.83,12.33 188.7,12.46 188.7,15.51 189.59,16.4 193.91,16.4
