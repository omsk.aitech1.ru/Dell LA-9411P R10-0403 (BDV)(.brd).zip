# Allegro board LA-9411P R10-0403.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
N23050732: length 14.5
  TOP w0.089: 157.48,115.46 157.04,115.02 156.75,115.02 156.3,114.57 155.68,114.57 155.35,114.24 155.35,113.61 155.13,113.38 155.13,112.67 154.86,112.41 154.57,112.41 154.31,112.15 154.31,111.04 154.21,110.93 154.21,110.6 153.74,110.13 v2(153.74,109.92)
  TOP w0.102: 157.48,115.46 158.26,116.24 158.94,116.24 161.22,118.53 T28.1
  BOTTOM w0.089: JCPU1.W31 v2(153.74,109.92)
N23050736: length 4.5
  TOP w0.089: T10.1 153.22,104.74 153.22,107.41 v2(153.73,107.92)
  BOTTOM w0.089: v2(153.73,107.92) JCPU1.W29
N23050738: length 3.3
  TOP w0.089: v2(153.73,106.93) 154.29,106.37 T15.1
  BOTTOM w0.089: JCPU1.W28 v2(153.73,106.93)
N23050778: length 1.7
  TOP w0.089: v2(159.73,87.92) 159.24,88.41 T32.1
  BOTTOM w0.089: v2(159.73,87.92) JCPU1.P10
N23050780: length 1.7
  TOP w0.089: v2(156.73,87.92) 156.19,88.46 T31.1
  BOTTOM w0.089: v2(156.73,87.92) JCPU1.U10
N23050887: length 3.2
  TOP w0.089: v2(141.73,103.92) 142.21,103.44 142.21,102.08 142.55,101.74 T23.1
  BOTTOM w0.102: v2(141.73,103.92) JCPU1.AL25
N23050901: length 6.3
  BOTTOM w0.089: JCPU1.AT1 136.11,79.45
  BOTTOM w0.102: 136.11,79.45 135.48,79.45 T11.1
N23050918: length 5.8
  TOP w0.089: T24.1 142.35,100.34 141.59,100.34 141.21,100.72 141.21,103.52 140.8,103.92 v2(140.73,103.92)
  BOTTOM w0.089: v2(140.73,103.92) 141.2,104.39 JCPU1.AM26
N23050938: length 10.2
  TOP w0.089: v2(137.73,111.92) 137.27,112.38 137.27,113.3 136,114.57
  TOP w0.102: T19.1 132.7,118.63 132.7,117.87 136,114.57
  BOTTOM w0.089: v2(137.73,111.92) JCPU1.AR33
N23050940: length 9.6
  TOP w0.089: v2(140.73,104.92) 140.73,104.8 140.31,104.37 140.31,103.73 139.94,103.37 138.98,103.37 138.97,103.35 138.5,103.35 138.49,103.37 137.98,103.37 137.97,103.35 137.5,103.35 137.49,103.37 136.65,103.37 136.36,103.08 136.36,102.95 136,102.59
  TOP w0.102: 136,102.59 135.41,101.99 135.26,101.99 134.37,101.1 T22.1
  BOTTOM w0.089: v2(140.73,104.92) 141.2,105.39 JCPU1.AM27
N23050958: length 2.8
  TOP w0.089: 173.59,101.75 171.9,101.75 v2(171.73,101.92)
  TOP w0.102: T7.1 173.59,101.75
  BOTTOM w0.089: JCPU1.B23 171.26,101.45 v2(171.73,101.92)
N23050968: length 4.7
  TOP w0.089: 173.59,100.42 172.68,101.33 171.32,101.33 v2(170.73,101.92)
  TOP w0.102: T12.1 173.59,100.42
  BOTTOM w0.089: v2(170.73,101.92) 170.26,101.45 JCPU1.C23
N23050970: length 3.2
  TOP w0.089: v2(169.73,102.92) 170.13,102.53 171.8,102.53 T13.1
  BOTTOM w0.089: JCPU1.D24 169.26,102.45 v2(169.73,102.92)
N23051071: length 15.7
  TOP w0.089: v2(141.73,108.92) 141.76,108.92 142.3,109.46 142.95,109.46 143.28,109.79 143.28,114.15 141.97,115.46
  TOP w0.102: 141.97,115.46 138.49,118.94 138.49,119.95 T16.1
  BOTTOM w0.102: v2(141.73,108.92) JCPU1.AL30
N23051073: length 15.6
  TOP w0.089: 140.24,115.46 141.36,114.33 141.36,113.08 141.36,112.76 141.74,112.38 141.92,112.38 142.21,112.09 142.21,110.63 142.01,110.43 141.47,110.43 141.32,110.27 141.32,109.6 141.33,109.59 141.33,108.32 v2(141.73,107.92)
  TOP w0.102: 140.24,115.46 140.24,115.57 136.38,119.43 T17.1
  BOTTOM w0.102: v2(141.73,107.92) JCPU1.AL29
N23051091: length 1.7
  TOP w0.089: T6.1 148.19,88.46 v2(148.73,87.92)
  BOTTOM w0.089: v2(148.73,87.92) 149.2,88.39 JCPU1.AD10
N24843313: length 2.2
  BOTTOM w0.102: v1(198.59,177.81) 199.35,177.05 R756.2 C704.1
N24843502: length 2.3
  BOTTOM w0.102: v1(192.39,177.25) 191.85,176.72 CE8.1 RE11.2
N24844156: length 2.1
  BOTTOM w0.102: v1(189.39,176.87) 189.24,176.72 CE9.1 RE12.2
N25368131: length 9.4
  TOP w0.102: v2(193.02,115.52) 193.4,115.89 UV5.J13
  BOTTOM w0.102: RV107.2 199.92,111.59 198.99,112.52 198.6,112.52 v1(198.27,112.85) 196.49,114.63 194.26,114.63 193.91,114.97 193.91,115.29 193.68,115.52 v2(193.02,115.52)
N25669355: length 17.3
  TOP w0.102: v1(184.13,150.18) 183.71,150.6 v2(183.71,150.75)
  IN3 w0.102: v2(192.99,143.3) 192.63,143.65 192.63,145.94
  IN3 w0.127: v2(183.71,150.75) 184.31,150.15 184.31,149.36 186.22,147.46 192.31,147.46 192.99,146.78 192.99,146.29 192.63,145.94
  BOTTOM w0.102: RV117.2 183.7,150.74 v2(183.71,150.75) ; UV6.J13 193.39,143.7 v2(192.99,143.3)
N29179028: length 3.9
  TOP w0.102: U46.B18 272.19,57.59 273.16,58.56 v1(273.16,59.36) 273.16,60.39 R802.2
N31479955: length 5.9
  TOP w0.102: v2(272.12,56.52) 272.14,56.52 272.12,56.54 272.12,56.6 271.69,57.04 U46.B19 ; v2(274.47,57.07) 274.94,57.54 v1(275.6,57.54) R804.1
  IN2 w0.127: v2(272.12,56.52) 273.92,56.52 v2(274.47,57.07)
N35502990: length 4.3
  BOTTOM w0.102: v1(121.65,8.52) 121.45,8.32 Q29.6
  BOTTOM w0.254: Q29.5 120.65,6.81 R508.2 120,7.46 Q29.6
N35569138: length 5
  BOTTOM w0.102: Y3.1 312.24,188.52 311.39,189.37 311.39,190.82 C470.2 312.28,191.71 R1144.1
N35662040: length 2.2
  TOP w0.102: CE3.1 RE5.2 v1(295,126.3)
N41576026: length 3
  TOP w0.254: PU400.4 236.2,105.29 236.71,105.8 v1(236.71,106.25) 236.71,107 PR400.2
N45129141: length 3.5
  BOTTOM w0.102: v1(182.6,144.93) 182.35,144.69 181.39,144.69 R423.2
  BOTTOM w0.254: R423.2 180.45,144.72 Q22.1
N46595644: length 6.9
  TOP w0.102: T122.1 v2(275.51,55.55) ; v2(271.33,54.51) 271.51,54.51 271.95,54.95 272.25,54.95 272.44,55.14 U46.B14
  IN2 w0.127: v2(275.51,55.55) 275.51,55.54 275.43,55.46 274.13,55.46 273.63,54.97 271.95,54.97 271.49,54.51 v2(271.33,54.51)
N48324044: length 18.1
  TOP w0.102: v1(314.61,212.92) 313.93,212.23 v2(313.42,212.23)
  IN4 w0.102: v2(313.42,212.23) 313.42,212.48 314.16,213.22 314.16,224.82 313.22,225.76 JLOM1.13
  BOTTOM w0.102: R1167.2 v2(313.42,212.23)
N48324090: length 20.7
  TOP w0.102: v1(313.77,210.58) 312.53,211.82 v2(312.53,212.23)
  IN4 w0.102: v2(312.53,212.23) 312.53,212.36 313.93,213.75 313.93,224.1 313.1,224.93 310.88,224.93 310.05,225.76 JLOM1.11
  BOTTOM w0.102: R1653.2 v2(312.53,212.23)
N48705646: length 12
  BOTTOM w0.102: PR10.1 154.16,170.42 v1(153.54,169.8)
  BOTTOM w0.254: PR13.2 149.22,169.38 149.46,169.14 149.46,168.35 149.72,168.1 151.26,168.1 151.33,168.17 PL4.1 151.33,169.6 151.49,169.76 PQ1.1 151.49,171.7 151.71,171.92 152.36,171.92 152.93,171.35 153.82,171.35 PR10.1
N48705653: length 6.5
  BOTTOM w0.102: PR10.2 154.16,171.84 155.39,170.61 v1(155.39,169.56)
  BOTTOM w0.254: PR12.1 PR10.2 152.98,171.92 152.46,172.44 PQ1.3
N48705663: length 5.5
  BOTTOM w0.102: v1(148.57,167.08) PR13.1
  BOTTOM w0.254: PQ2.2 148.84,170.21 148.6,169.96 148.17,169.96 148.04,169.84 148.04,169 PR13.1 PR15.2
N48705666: length 8.9
  BOTTOM w0.254: PQ2.1 148.19,173.33 v1(147.68,173.84) 148.53,174.69 148.53,175.62 148.9,175.98 PR16.1 PR14.2 149.67,175.42 149.67,174.48 150.53,173.61 PQ1.2
N48711348: length 2.7
  BOTTOM w0.102: v1(124.93,150.61) 124.76,150.61 124.14,149.99 124.14,149.3 123.5,148.67 PC522.1
N48716673: length 3.5
  TOP w0.254: PU800.28 148.59,169.53 147.58,170.54 v1(147.34,170.54) 146.62,169.81 PR838.2
N48716693: length 4.2
  TOP w0.254: PR850.1 148.19,173.16 149.03,172.33 v1(149.16,172.33) 149.68,172.33 150.25,171.76 PU800.26
N48716711: length 6.3
  TOP w0.102: v4(135.75,186.58) v1(135.75,187.74)
  TOP w0.508: PQ811.4 135.11,185.94 v4(135.75,186.58)
  BOTTOM w0.508: PC811.1 PR821.1 135.36,186.45 135.49,186.58 v4(135.75,186.58)
N49342732: length 3.8
  TOP w0.102: R3671.1 Q79.1 324.21,165.21 324.8,164.63 325.84,164.63 v1(326.04,164.43)
N49563382: length 0.9
  BOTTOM w0.102: 121.2,142.79 121.2,142.6 v1(120.72,142.11)
N49574226: length 3.6
  BOTTOM w0.102: v3(147.2,139.93) 147.2,141.74 148.41,142.95 PC508.2
N50215889: length 2.3
  BOTTOM w0.102: v1(320.63,213.84) 320.66,213.87 R938.1 320.86,215.02 Q81.1
N50225127: length 3.1
  BOTTOM w0.102: Q84.3 326.69,215.67 v1(325.71,215.67) Q81.2
N50261142: length 68.1
  TOP w0.102: D62.2 328.96,162.03 v2(329.55,162.62) R932.2 ; D59.2 332.57,157.11 331.45,158.23 331.45,159.66 331.07,160.05 Q74.1 330.4,160.05 330.28,160.16 330.28,160.54 v2(330.34,160.59) ; v2(327.52,215.55) v1(328.39,215.55)
  IN3 w0.127: v2(330.34,160.59) 329.83,161.1 329.45,161.1 329.15,161.39 329.15,162.13 329.55,162.52 v2(329.55,162.62) 329.81,162.89 329.81,163.49 330.26,163.94 330.26,168.44 329.04,169.66 329.04,171.57 328.9,171.71 328.9,171.77 328.69,171.98 328.69,175.01 v2(328.46,175.25)
  IN4 w0.102: v2(327.52,215.55) 327.52,213.88 327.77,213.63 327.77,207.57 327.52,207.31 327.52,203.1 328.56,202.06 328.56,197.7 327.36,196.51 327.36,195.46 327.82,195.01 327.82,185.5 327.2,184.88 327.2,181.37 328.02,180.55 328.02,179.97 327.72,179.67 327.72,175.98 v2(328.46,175.25)
  BOTTOM w0.102: Q84.4 v2(327.52,215.55)
N51290432:
  vias: v1(163.3,152.29)
N51302473: length 2.8
  TOP w0.102: PR501.1 156.51,155.26 156.26,155.51 156.26,156.86 v1(156,157.11)
N51922312: length 2.6
  TOP w0.102: v1(317.74,160.41) 317.61,160.41 v4(317.15,160.87)
  TOP w0.254: PR639.2 316.95,160.67 v4(317.15,160.87)
  BOTTOM w0.254: v4(317.15,160.87) 317.61,161.33 PC612.1
N51922324: length 3.8
  TOP w0.254: PC625.2 310.62,158.25 310.88,158.51 v4(311.01,158.51)
  BOTTOM w0.203: v4(311.01,158.51) 310.86,158.66 v1(310.86,159.08) 310.89,159.11 310.89,159.76 310.84,159.81 PU600.14
  BOTTOM w0.254: PC625.2 310.62,158.13 v4(311.01,158.51)
N51922366: length 8.7
  TOP w0.102: v1(314.18,168.03) 313.98,167.83 PR607.2
  TOP w0.254: PR607.2 312.91,167.64 v4(312.42,167.14) 311.44,167.14 310.37,166.08 PC600.2
  BOTTOM w0.203: PU600.38 311.24,166.11 312.28,167.14 v4(312.42,167.14)
  BOTTOM w0.254: PR600.2 312.95,167.68 v4(312.42,167.14)
N51922430: length 2.7
  BOTTOM w0.203: PR633.1 v1(314.31,163.72) 313.63,163.72 313.47,163.55 PU600.4
N51922457: length 6
  TOP w0.127: v1(309.47,157.56) 310.04,158.13 v4(310.04,159.46)
  TOP w0.254: v4(310.04,159.46) 310.04,160.09 PC617.1
  BOTTOM w0.203: v4(310.04,159.46) PU600.16
  BOTTOM w0.254: PR645.1 309.23,157.94 310.08,158.79 310.08,159.21 310.04,159.25 v4(310.04,159.46)
N51922465: length 2.8
  TOP w0.102: v4(313.98,164.22) 313.98,164.53 v1(314.28,164.83)
  TOP w0.254: PR632.1 v4(313.98,164.22)
  BOTTOM w0.203: PU600.3 313.4,163.95 313.67,164.22 v4(313.98,164.22)
N51922467: length 11.9
  TOP w0.102: PC613.2 316.34,161.68 316.72,161.3 318.35,161.3 v1(319.1,160.55)
  TOP w0.254: PR644.1 314.05,162.19 v4(314.43,161.81) 314.51,161.81 314.84,161.48 314.84,161.2 PR639.1 316.29,161.58 PC613.2
  BOTTOM w0.203: PU600.8 314.29,161.95 v4(314.43,161.81) 314.43,161.61 PR639.1
  BOTTOM w0.254: PR640.1 PR639.1
N51922471: length 2.2
  BOTTOM w0.102: v1(317.27,160.21) 317.16,160.21 316.71,160.67 PR642.1
  BOTTOM w0.254: PC614.2 PR642.1
N51922473: length 11.2
  TOP w0.102: v4(316.97,162.7) v1(317.74,162.7)
  TOP w0.254: v4(316.97,162.7) PC611.2 315.37,161.79 PC613.1 314.49,162.57 313.86,162.57 313.35,163.08 PR637.1
  BOTTOM w0.203: PU600.7 314.7,162.35 PC613.1
  BOTTOM w0.254: PC613.1 316.29,162.6 PC611.2 v4(316.97,162.7) PC609.1
N51922497: length 10.9
  TOP w0.254: v4(305.85,162.5) 305.8,162.45 PR635.1 304.87,162.2 304.87,162.09 PC610.1
  BOTTOM w0.102: PC610.1 303,160.92 302.75,160.67 v1(302.62,160.67)
  BOTTOM w0.203: PU600.25 306.88,162.75 306.63,162.51 305.86,162.51 v4(305.85,162.5)
  BOTTOM w0.254: PC610.1 303.52,161.1 303.52,162.84 303.7,163.02 304.77,163.02 305.11,162.67 PR635.1 305.8,162.45 v4(305.85,162.5)
N51922501: length 4.8
  TOP w0.102: 314.7,163.21 v1(315.29,163.79)
  TOP w0.254: v4(314.69,163.21) 314.87,163.21 PC611.1
  BOTTOM w0.203: PU600.6 313.72,162.75 313.76,162.71 314.19,162.71 v4(314.69,163.21)
  BOTTOM w0.254: v4(314.69,163.21) 315.2,162.7 PC611.1
N51922603: length 3.8
  TOP w0.254: PR627.2 v4(314.69,165.75)
  BOTTOM w0.203: PU600.1 313.22,164.75 313.51,165.04 313.98,165.04 v1(314.18,165.24) v4(314.69,165.75) PR627.2
N51922663: length 6.3
  TOP w0.254: PC625.1 310.12,156.4 310.12,155.84 v4(310.62,155.33)
  BOTTOM w0.127: v1(310.55,152.21) 310.55,152.72 311.43,153.61 PR647.2
  BOTTOM w0.254: v4(310.62,155.33) 310.75,155.33 311.16,154.93 311.16,154.15 PR647.2
N51922671: length 29.1
  TOP w0.254: PR648.2 310.62,153.17 v4(309.99,152.54)
  BOTTOM w0.254: v4(309.99,152.54) 309.99,151.17 310.27,150.89 v1(310.27,150.14) 310.27,149.61 309.04,148.37 305.66,148.37 302.41,145.12 289.7,145.12 288.81,146.01 288.81,146.67 PH601.1
N51922720: length 5.5
  BOTTOM w0.102: PR641.1 306.76,157.82 v1(305.86,156.92)
  BOTTOM w0.203: PR641.1 307.68,158.31 308.2,158.31 309,159.11 309.2,159.31 309.2,159.48 309.23,159.51 309.23,159.8 309.24,159.81 PU600.18
N51922903: length 10.7
  BOTTOM w0.203: 314.43,159.49 314.43,160.3 v1(314.19,160.55) 313.18,161.55 PU600.9
  BOTTOM w0.254: PC609.2 319.16,162.12 319.16,160.97 317.28,159.09 314.83,159.09 314.43,159.49
N51922909: length 34.3
  TOP w0.254: v2(297.8,145.68) 297.29,146.19 v1(296.68,146.19) 296.07,145.58 PH600.2
  IN3 w0.254: v4(313.99,163.23) 313.31,162.55 313.31,159.52 312.95,159.16 312.95,158.78 312.06,157.9 312.06,154.91 311.51,154.36 311.51,153.05 312.02,152.54 312.02,150.67 309.58,148.22 305.77,148.22 303.23,145.68 v2(297.8,145.68)
  BOTTOM w0.203: v4(313.99,163.23) 313.91,163.23 313.84,163.15 PU600.5
N51924346: length 5.3
  TOP w0.254: v4(309.58,159) 308.96,159 v1(308.91,159.05) PC618.1
  BOTTOM w0.203: PR643.1 309.09,158.7 309.1,158.7 309.48,159.08 309.48,159 309.56,159 ; 309.56,159 309.56,159.66 309.64,159.74 PU600.17 ; 309.56,159 v4(309.58,159)
N51924368: length 4.2
  BOTTOM w0.203: PR636.1 304.2,162.15 304.54,161.81 305.35,161.81 305.53,161.99 306.19,161.99 v1(306.31,162.11) 306.76,162.11 307.01,162.35 PU600.24
N51924378: length 2.1
  TOP w0.102: PR634.1 v1(293.21,144.69)
  TOP w0.254: PH600.1 PR634.1
N53085144: length 1.5
  TOP w0.102: PC206.2 v1(203.69,15.13)
N53085275: length 2.8
  TOP w0.203: PR205.2 213.34,15.13 v1(213.22,15) 213.22,14.81 212.66,14.26 PU200.9
N53866851: length 2.6
  TOP w0.102: v1(284.17,121.98) 284.69,121.98 R885.2 C747.1
N57652826: length 6.5
  BOTTOM w0.089: JCPU1.AT35 136,113.45
  BOTTOM w0.102: T52.1 135.34,113.45 136,113.45
N57659725: length 8
  BOTTOM w0.089: 136,114.94 136.77,114.17 137.48,114.17 JCPU1.AR35
  BOTTOM w0.102: 136,114.94 132.89,118.05 T53.1
N57663191: length 12.2
  TOP w0.089: 136,114.26 136.36,113.9 136.36,112.76 136.58,112.55 136.74,112.55 137.27,112.01 137.27,111.38 v2(137.73,110.92)
  TOP w0.102: T54.1 131.53,118.27 131.97,118.27 135.91,114.34 135.92,114.34 136,114.26
  BOTTOM w0.089: v2(137.73,110.92) JCPU1.AR32
N57663201: length 3.3
  TOP w0.089: v2(141.73,104.92) 141.73,104.51 142.3,103.95 142.3,103.64 142.55,103.39 142.97,103.39 143.1,103.26 T55.1
  BOTTOM w0.102: v2(141.73,104.92) JCPU1.AL26
N60687816: length 5.6
  BOTTOM w0.102: v1(219.95,51.7) 219.76,51.52 C289.1
  BOTTOM w0.508: R1629.2 216.43,51.9 217.84,51.9 C289.1 218.23,51.38 U8.1
N61506560: length 5.3
  TOP w0.102: v1(75.75,178.4) 75.75,180.05 75.37,180.43 PR722.1
  TOP w0.254: PR722.1 75.89,181.03 75.89,181.8 76.58,182.49 PU700.11
N61513947: length 5.5
  TOP w0.254: PR745.2 PR746.2 ; PR746.2 73.72,183.71 73.85,183.58 v1(74.21,183.58) 74.63,183.58 74.73,183.67 PU700.10 ; PR746.2 PR747.2 PR720.2
N63746311: length 11.7
  TOP w0.102: v1(298.8,110.41) 298.73,110.34 v2(298.73,109.7) 298.5,109.47 R884.1 ; v2(291.45,110.12) 291.46,110.13 291.65,110.13 291.93,110.41 U51.B2
  IN3 w0.127: v2(291.45,110.12) 292,110.12 292.79,110.91 295.64,110.91 295.84,110.71 295.84,109.58 296.38,109.04 298.06,109.04 v2(298.73,109.7)
N63746359: length 10.8
  TOP w0.102: v1(299.58,113.61) 299.33,113.37 R888.1 299.33,112.62 v2(298.69,111.98) ; U51.B8 291.38,113.41 v2(291.35,113.44)
  IN2 w0.127: v2(291.35,113.44) 291.81,112.98 294.58,112.98 294.72,113.12 296.78,113.12 297.92,111.98 v2(298.69,111.98)
N70862806: length 3.6
  TOP w0.102: v1(331.38,155.57) 331.38,156.21 D59.1 330.48,158.6 Q74.3
N70877887: length 9.8
  TOP w0.102: v1(326.69,159.22) 326.69,158.3 Q75.2 327.53,157.76 327.74,157.98 327.74,159.58 328.25,160.08 329.46,160.08 329.92,160.54 329.92,160.75 330.17,161 330.53,161 331.48,160.05 Q74.6
N70882773: length 5.1
  TOP w0.102: v1(321.22,164.92) 321.67,165.38 Q100.1 321.9,165.94 322.07,166.1 322.79,166.1 323.56,165.33 Q79.2
N72304780: length 2.6
  TOP w0.102: v2(194.83,70.05) 195.25,69.63 T86.1
  BOTTOM w0.089: UH1.AY1 196.32,70.7 195.98,70.7 195.42,70.14 195.03,70.14
  BOTTOM w0.102: 195.03,70.14 194.93,70.14 v2(194.83,70.05)
N74863185: length 18.7
  TOP w0.508: v4(126.09,175.91) 125.71,176.29 PQ809.4
  IN2 w0.508: v4(126.09,175.91) 123.15,178.85 v2(123.15,183.04)
  BOTTOM w0.508: PR813.1 v2(123.15,183.04) ; PD809.1 120.36,173.32 PR815.1 v1(122.03,174.45) 123.49,175.91 v4(126.09,175.91)
N78936752: length 1.7
  BOTTOM w0.102: PR816.1 117.53,167.45 v1(116.72,168.26)
N78945927: length 2.9
  TOP w0.102: v1(55.53,182.03) 55.53,183.58 55.81,183.86 55.81,184.78
N78946737: length 24.7
  TOP w0.102: PQ810.4 149.84,182.13 v1(149.2,182.78)
  TOP w0.254: v4(159.27,167.97) 159.09,168.15 PR811.2 ; v2(152.31,182.13) PQ810.4
  IN4 w0.254: v2(152.31,182.13) 154.33,180.11 154.33,175.77 155.44,174.65 159.03,174.65 159.28,174.4 159.28,171.26 158.77,170.76 158.77,168.47 v4(159.27,167.97)
  BOTTOM w0.254: PC807.2 159.75,168.45 v4(159.27,167.97)
N78948236: length 7.5
  TOP w0.102: v1(146.66,179.44) 147.06,179.03 147.29,179.03
  TOP w0.254: PD817.2 149.31,176.44 148.85,175.98 147.68,175.98 147.29,176.38 147.29,179.03 147.65,179.39 PQ828.1
N78957298:
  vias: v1(118.28,174.32) v4(119.17,175.21) v4(119.19,174.55) v4(119.85,175.2) v4(119.86,174.52) v4(120.49,175.18) v4(120.49,174.5) v4(121.13,175.18) v4(121.13,174.5) v4(121.76,175.18)
N78957443: length 115
  TOP w0.254: PD816.1 45.65,173.29 45.88,173.52 45.88,177.15 46.35,177.62 v2(47.32,177.62) ; PD821.1 v2(42.03,172.36)
  TOP w0.508: v4(121.98,171.16) 122.08,171.26 PR822.1 PR818.1 PC809.2 122.54,174.21 122.54,175.42 121.9,176.06 PQ815.4
  IN1 w0.254: v2(47.32,177.62) 49.47,179.78 52.5,179.78 52.84,179.44 52.84,177.72 54.12,176.44 57.39,176.44 59.16,178.22 62.99,178.22 63.72,177.49 65.09,177.49 65.31,177.7 69.23,177.7 70.25,176.68 71.76,176.68 72.79,177.7 76.26,177.7 77.29,176.67 82.37,176.67 88.95,170.09 90.8,170.09 91.32,169.57 105.93,169.57 106.49,169.01 113.38,169.01 114.18,169.81 120.46,169.81 121.8,171.16 v4(121.98,171.16)
  IN3 w0.254: v2(47.32,177.62) 46.49,177.62 42.03,173.16 v2(42.03,172.36)
  BOTTOM w0.102: v2(47.32,177.62) v1(47.93,177.62)
  BOTTOM w0.508: v4(121.98,171.16) 121.98,171.37 121.03,172.33 119.77,172.33 119.08,173.01 119.08,173.74 118.09,174.73 PQ826.4
N78957489: length 3.8
  TOP w0.254: PQ816.1 119.92,170.21 119.68,170.45 119.68,171.17 v1(119.76,171.25) 120.35,171.84 PR822.2
N78963519: length 12.1
  TOP w0.254: PQ817.1 71.86,177.41 72.5,178.04 v1(74.23,178.04) 75.03,178.04 76.31,176.76 PU805.2 76.31,172.87 77.14,172.05 PR819.1
N78963697: length 5.3
  TOP w0.254: PU806.1 72.39,173.76 72.62,173.99 73.07,173.99 73.76,173.3 v1(74.3,173.3) 75.14,172.47 75.14,172.33 75.66,171.81 PU805.4
N78964443: length 63
  TOP w0.254: v1(69.41,175.91) 69.41,177.83 v2(68.97,178.27) ; v4(120.25,170.7) 120.93,170.03 120.93,168.55 119.49,167.12 PQ816.2
  IN1 w0.254: v2(68.97,178.27) 71.05,178.27 71.24,178.09 76.42,178.09 77.45,177.05 82.53,177.05 89.11,170.47 91.08,170.47 91.6,169.95 106.18,169.95 106.74,169.39 113.22,169.39 114.02,170.19 119.74,170.19 v4(120.25,170.7)
N78967013:
  vias: v1(68.39,171.16)
N78985854: length 17.4
  TOP w0.102: v1(44.18,189.37) 44.23,189.32 v2(44.95,189.32)
  TOP w0.254: PQ806.3 54.86,186.44 v2(54.85,186.42) ; v2(44.95,189.32) PR810.2 ; PR812.2 50.71,186.25 51.11,186.65 v2(51.42,186.65) PU804.2
  BOTTOM w0.254: v2(54.85,186.42) 54.85,186.3 54.11,185.56 53.32,185.56 52.91,185.15 52.01,185.15 51.42,185.75 v2(51.42,186.65) 48.75,189.32 v2(44.95,189.32)
N78999867: length 205.9
  TOP w0.102: v4(133.78,172.68) 134.03,172.68 v1(134.64,172.07)
  TOP w0.254: PD802.1 245.77,91.07 242.9,93.94 PQ801.3 241.18,93.48 239.78,92.09 v2(239.78,90.74) 239.33,90.28 PR804.1 ; PD807.1 132.82,173.63 v4(133.78,172.68)
  IN3 w0.254: v2(134.12,169.27) 134.22,169.16 134.74,169.16 135.16,169.58 143.23,169.58 143.58,169.93 144.13,169.93 146.17,171.97 149.72,171.97 150.22,171.46 152.13,171.46 153.75,173.09 153.75,173.11 154.67,174.03 155.44,174.03 157.73,176.32 157.73,176.76 158.16,177.19 v2(158.3,177.19) ; v2(172.93,151.5) 172.83,151.4 172.83,146.24 173.6,145.47 173.6,144.25 173,143.65 173,134.87 172.27,134.15 172.27,133.44 172.63,133.08 173.6,133.08 174.72,131.96 174.72,131.2 176.34,129.58 176.34,121.95 175.73,121.34 175.73,115.06 179.81,110.97 179.81,107.48 179.32,106.99 179.32,105.19 181.03,103.48 181.03,100.48 182.19,99.33 187.81,99.33 188.11,99.62 188.11,99.97 190,101.85 193.18,101.85 194.88,100.15 202.24,100.15 202.51,99.89 213.77,99.89 217.15,96.51 219.35,96.51 222.41,93.45 224.47,93.45 225.17,92.75 237.7,92.75 239.71,90.74 v2(239.78,90.74)
  IN4 w0.254: v2(172.93,151.5) 170.57,151.5 169.32,152.74 167.57,152.74 167.14,153.17 167.14,162.09 163.5,165.73 163.5,168.66 164.21,169.36 164.21,174.79 163.37,175.63 163.37,176.73 162.38,177.72 160.28,177.72 160.05,177.49 158.61,177.49 v2(158.3,177.19)
  BOTTOM w0.254: v4(133.78,172.68) 133.78,169.61 v2(134.12,169.27)
N78999869: length 8
  TOP w0.102: v3(243.49,91.6) 243.09,92.01 PQ801.2
  TOP w0.254: PQ801.2 241.18,91.26 240.7,90.78 PR802.2 240.7,89.61 240.33,89.24 238.84,89.24 238.41,89.67 PR804.2
N78999885: length 2.3
  TOP w0.254: PR802.1 241.96,89.59 v1(241.96,88.94) 241.56,88.55 PQ807.6
N79001628: length 7.9
  TOP w0.254: PU801.4 49.02,185.09 v2(49.37,185.45) ; PQ802.2 v2(53.96,182.12)
  BOTTOM w0.254: v2(53.96,182.12) 53.96,182.23 53.59,182.6 v1(52.43,182.6) 52.22,182.6 v2(49.37,185.45)
N79002783: length 18.6
  TOP w0.254: v2(54.61,182.1) PQ802.3 ; PQ806.6 53.56,190.71 PR801.2 52.97,190.77 v2(52.84,190.64) ; v2(53.04,186.04) 53.31,185.78 PQ802.6 ; v2(56.75,182.12) PQ805.2
  IN2 w0.254: v2(52.84,190.64) 53.04,190.44 v2(53.04,186.04) 54.61,184.48 v2(54.61,182.1)
  BOTTOM w0.254: PD818.1 57.49,181.38 v2(56.75,182.12) 56.75,182.23 56.35,182.64 v1(55.35,182.64) 55.1,182.64 54.61,182.15 v2(54.61,182.1)
N79002827: length 5.7
  TOP w0.254: PU804.4 v2(52.07,188.52) ; PQ806.2 v2(54.21,186.42)
  BOTTOM w0.254: v2(52.07,188.52) 52.07,188.12 52.52,187.67 v1(53.32,187.67) 53.97,187.67 54.21,187.43 v2(54.21,186.42)
N79017925: length 4.4
  TOP w0.102: v1(69.91,170.32) PR820.1
  TOP w0.254: PU806.2 71.74,171.18 71.31,170.76 71.25,170.76 70.9,170.41 PR820.1
N79021833: length 9.6
  TOP w0.254: PD814.3 69.52,172.82 69.21,173.13 67.79,173.13 67.43,172.77 67.43,170.85 v2(67.19,170.61) ; PU807.4 64.51,171.45 64.8,171.16 v2(64.8,170.94)
  IN1 w0.254: v2(67.19,170.61) 67.19,170.89 66.68,171.4 65.26,171.4 v2(64.8,170.94)
  BOTTOM w0.102: v2(67.19,170.61) v1(67.19,171.18)
N79023703: length 3.2
  TOP w0.254: PR863.1 154.08,173.21 v1(154.08,172.31) 154.08,171.4 153.75,171.07 PU800.19
N79025276: length 5.8
  TOP w0.102: v1(237.27,86.88) 237.27,86.55 237.96,85.86 PR808.2
  TOP w0.254: 237.99,87.2 237.99,86.6 238.41,86.18 PR808.2 ; 237.99,87.2 237.99,87.54 238.35,87.9 PQ807.2 ; 237.99,87.2 238.04,87.25 PQ807.3
N79026790: length 15.6
  TOP w0.254: PR882.2 58.95,173.38 59.62,174.05 60.23,174.05 PQ818.2 61.13,173.15 61.7,173.15 62.43,173.88 PR824.1 62.96,173.88 63.25,174.17 63.25,174.76 63.01,175 PQ819.6 61.07,175 60.74,175.33 v1(60.74,176.82) 60.74,177.52 61.06,177.84 62.27,177.84 63.8,176.3 PQ819.3
N79026826: length 7.7
  TOP w0.254: PR823.1 65.39,170.57 65.13,170.32 PR825.2 64.45,170.07 64.07,169.68 60.71,169.68 v1(60.43,169.96) PQ818.1
N79029876: length 4
  TOP w0.254: PR825.1 v1(62.05,170.32) 61.6,170.76 61.6,171.67 62.04,172.1 PU807.2
N79030038: length 9.7
  TOP w0.254: 55.29,175 PQ813.3 ; 55.29,175 56.18,174.11 v1(56.18,173.46) 56.18,172.67 56.59,172.26 56.98,172.26 57.72,173 57.72,174.04 57.88,174.21 59.08,174.21 PR829.2 ; 55.29,175 55.29,175.49 55.13,175.65 PQ813.2
N79030087: length 9
  TOP w0.254: PQ813.6 55.91,176.3 55.71,176.5 v2(55.71,177.09) ; PR826.2 v2(52.27,172.81)
  BOTTOM w0.254: v2(55.71,177.09) 55.63,177.09 54.83,176.29 v1(53.32,176.29) 52.27,175.23 v2(52.27,172.81)
N79030091: length 7.5
  TOP w0.102: v1(51.06,170.93) PQ814.2
  TOP w0.254: PR827.1 53.3,174.05 54.01,173.34 54.01,172.24 53.67,171.89 PR826.1 52.28,171.89 51.52,172.66 PQ814.2
N79030745:
  vias: v1(47.86,171.79)
N79031357:
  vias: v1(58.4,179.72)
N79031404: length 4.7
  TOP w0.254: 53.46,176.33 53.46,175.72 53.98,175.2 53.98,174.14 v1(54.22,173.91) 55.01,173.11 PQ827.1
N79031406: length 1
  TOP w0.102: PQ822.2 v2(51.06,175.97)
N79031414:
  vias: v1(47.99,180.12)
N79033064: length 4
  TOP w0.254: PR863.2 PR870.1 155.3,175.25 v1(155.46,175.4) 155.28,175.58 PQ823.3
N79033066: length 8.8
  TOP w0.102: PR869.1 156.4,172.77 v1(156.69,172.48)
  TOP w0.254: PR869.1 PR870.2 155.84,173.95 155.84,175.06 156.35,175.56 156.35,177.66 155.28,178.73 PQ823.2
N79033085: length 4.2
  TOP w0.254: PR869.2 156.4,175.01 v1(156.85,175.46) 157.98,176.59 v2(158.29,176.59)
  BOTTOM w0.254: v2(158.29,176.59) 158.21,176.67 157.84,176.67 157.73,176.56 PQ824.6
N79033110: length 8.4
  TOP w0.254: v2(158.91,175.3) 158.91,175.11 158.13,174.33 PR875.2
  BOTTOM w0.102: v1(159.67,175.3) v2(158.91,175.3)
  BOTTOM w0.254: v2(158.91,175.3) 158.91,174.97 158.24,174.29 158.24,173.53 158.02,173.32 157.55,173.32 157.46,173.41 157.08,173.41 ; 157.08,173.41 156.52,173.41 156.43,173.5 PQ824.3 ; 157.08,173.41 PQ824.2
N79033126: length 2.6
  BOTTOM w0.254: PQ824.5 157.08,176.56 157.72,177.19 v1(157.72,177.51) 157.53,177.7 PR883.2
N79099120: length 10.9
  TOP w0.102: v1(105.89,165.54) 106.18,165.84 PC700.2
  TOP w0.254: PR702.2 111.92,165.75 PQ701.2 111.92,168.24 111.62,168.54 109.41,168.54 108.36,167.5 PQ702.2 107.11,166.75 PC700.2
N79099356: length 17.8
  TOP w0.102: PR706.2 110.4,164.53 v1(110.47,164.6)
  TOP w0.254: PR707.2 114.51,164.53 115.03,164.01 115.03,161.92 114.09,160.98 PQ703.3 114.09,159.71 113.81,159.44 112.47,159.44 112.19,159.71 PQ703.1 112.19,161.1 111.52,161.77 v2(111.49,161.77) ; PR706.2 PR709.1 108.28,164.53 107.86,164.11 v4(107.86,163.93)
  BOTTOM w0.254: v4(107.86,163.93) 108.95,163.93 111.07,161.81 111.45,161.81 v2(111.49,161.77)
N79099392: length 5.7
  TOP w0.254: PR705.1 80.04,189.37 PC704.2 79.36,188.15 v2(79.12,187.91) 79.12,187.67 78.58,187.13 PU700.1
  BOTTOM w0.102: v2(79.12,187.91) 79.33,187.91 v1(79.61,188.19)
  BOTTOM w0.254: v2(79.12,187.91) 79.12,187.58 79.4,187.3 PC705.1
N79099442: length 7.4
  TOP w0.254: PU700.2 78.08,187.38 78.49,187.79 v2(78.49,187.91) 78.44,187.96 PC704.1 78.44,188.89 79.94,190.39 PR704.1
  BOTTOM w0.102: v2(78.49,187.91) 78.15,187.91 v1(77.33,188.73)
  BOTTOM w0.254: v2(78.49,187.91) 78.34,187.76 PC703.2
N79099542: length 5.9
  TOP w0.254: PR713.1 73.76,186.84 v4(74.53,186.07) 74.66,186.07 75.06,185.67 PU700.6
  BOTTOM w0.102: v4(74.53,186.07) v1(73.64,186.07)
  BOTTOM w0.254: v4(74.53,186.07) 74.7,186.23 PC708.1 PR714.1
N79099544: length 3.5
  TOP w0.102: v1(76.13,189.75) PR717.2
  TOP w0.254: PU700.5 76.58,186.81 76.13,187.26 PR717.2
N79100287: length 24.6
  TOP w0.254: PR701.2 127.74,173.75 v4(127.36,173.37) ; PQ701.1 111.59,169.46 111.23,169.81 v2(111.23,170.79)
  IN1 w0.254: v4(127.36,173.37) 126.9,173.37 126.71,173.56 126.41,173.56 124.63,175.34 123.06,175.34 122.79,175.07 122.79,174.54 121.43,173.18 111.68,173.18 111.11,172.61 111.11,170.92 v2(111.23,170.79)
N79100289: length 26.6
  TOP w0.254: v4(110.6,170.79) 110.6,169.81 110.37,169.58 PQ702.1 ; v4(127.36,174.13) 127.22,174.13 126.83,173.75 PR701.3
  IN1 w0.254: v4(127.36,174.13) 127.17,173.94 126.57,173.94 124.72,175.79 122.94,175.79 122.31,175.16 122.31,174.59 121.28,173.56 111.52,173.56 110.73,172.76 110.73,170.92 v4(110.6,170.79)
  BOTTOM w0.102: v4(127.36,174.13) 128.38,174.13 v1(128.51,174)
N79100387: length 44
  TOP w0.508: PQ700.4 v4(123.43,169.44) ; PR700.1 154.21,160.25 153.97,160.01 v2(153.97,159.69)
  BOTTOM w0.508: v4(123.43,169.44) v1(122.41,169.44) 122.06,169.44 121.86,169.25 121.86,165.16 122.39,164.64 129.36,164.64 131.59,162.41 148.56,162.41 151.61,159.36 153.64,159.36 v2(153.97,159.69)
N79108656: length 32.1
  TOP w0.203: PR749.2 93.66,169.52 93.87,169.3 93.87,167.99 PU701.1
  TOP w0.254: PQ707.2 94.09,158.31 94.34,158.05 95.78,158.05 PC728.1 96.96,157.4 99.04,157.4 100.64,159 100.64,162.08 99.86,162.86 v2(98.65,162.86) ; PR723.1 91.84,168.03 v2(92.31,168.51) 92.32,168.51 93.05,167.78 PU701.1
  IN4 w0.254: v2(92.31,168.51) 92.64,168.19 93.76,168.19 95.13,166.81 95.13,163.68 95.96,162.85 98.64,162.85 v2(98.65,162.86)
  BOTTOM w0.102: v2(98.65,162.86) v1(99.46,162.86)
  BOTTOM w0.254: PR725.2 92.67,167.35 92.34,167.68 92.34,168.48 v2(92.31,168.51)
N79108660: length 32
  TOP w0.254: v2(75.05,177.14) 75.04,177.14 74.53,176.63 PQ709.1 ; PR730.2 90.03,166.26 88.59,164.82 88.59,164.19 v1(89.04,163.74) 89.19,163.74 89.82,163.11 89.82,161.75 v2(89.71,161.63)
  IN4 w0.254: v2(89.71,161.63) 89.71,161.52 89.33,161.14 88.27,161.14 85.99,163.42 85.99,166.6 82.4,170.19 79.65,170.19 75.05,174.79 v2(75.05,177.14)
N79108839: length 10.1
  TOP w0.254: PU701.7 100.48,166.51 100.73,166.26 PR734.2 PR735.2 100.61,168.17 v2(100.61,169)
  BOTTOM w0.102: v1(100.31,166.51) 100.57,166.26 PR734.2
  BOTTOM w0.254: v2(100.61,169) 100.62,168.99 100.62,168.16 PR735.2 PR734.2
N79108872: length 6.2
  TOP w0.254: PR728.2 PC727.1 91.73,164.48 v2(92.02,164.76) 92.48,165.22 92.48,165.24 PU701.3
  BOTTOM w0.254: PR725.1 92.53,166.43 92.02,165.92 v1(92.02,165.49) v2(92.02,164.76)
N79108988: length 15.7
  TOP w0.254: PR734.1 v1(104.12,166.26) 104.88,166.26 105.32,165.82 105.32,163.64 102.55,160.87 102.07,160.87 101.51,161.43 v2(101.51,161.47) PR738.1 PR732.2 100.48,163.21 99.72,163.97 PU701.5
  BOTTOM w0.254: PR738.1 v2(101.51,161.47)
N79109000: length 7
  TOP w0.254: PU701.6 99.74,165.24 99.96,165.46 101.29,165.46 PR733.2 PC730.1 100.83,164.22 100.63,164.43 v2(100.63,164.76)
  BOTTOM w0.102: v2(100.63,164.76) v1(99.71,164.76)
  BOTTOM w0.254: PR733.2 101.11,165.24 100.64,164.76 v2(100.63,164.76)
N79109047: length 14.2
  TOP w0.102: v2(95.18,169.01) v1(95.18,169.86)
  TOP w0.254: PC726.1 PR730.1 PR726.2 91.82,167.14 92.45,166.51 PU701.2 94.65,166.51 95.18,167.04 v2(95.18,169.01)
  BOTTOM w0.254: v2(95.18,169.01) 95.18,166.14 94.48,165.44 PR731.1
N79111305: length 4
  TOP w0.254: 80.34,183.76 79.92,184.17 PU700.17
  TOP w0.508: PR715.1 82.22,182.77 81.66,183.32 v1(81.2,183.32) 80.77,183.32 80.34,183.76
N81870153: length 2.9
  TOP w0.102: R65.2 27.8,206.45 27.27,205.93 v1(27.27,205.57) U19.13
N81907121: length 3.9
  TOP w0.102: U19.23 23.24,202.56 22.98,202.82 22.66,202.82 22.47,203.01 21.83,203.01 R72.2 20.28,202.5 v1(20.25,202.48)
N81942445: length 3.3
  TOP w0.102: R76.1 v1(24.9,205.52) 25.27,205.16 25.27,204.05 U19.18
N82972829: length 3.4
  BOTTOM w0.102: v1(210.89,51.6) 210.89,50.83 210.9,50.81 ; U9.4 211.32,50.39 210.9,50.81 ; R1655.1 209.94,50.15 209.94,50.46 210.29,50.81 210.9,50.81
N85751870: length 2
  TOP w0.102: PR301.2 237.1,13.6 v1(236.01,12.51)
N89358580: length 2.5
  TOP w0.089: T50.1 164.19,105.46 v2(163.73,105.92)
  BOTTOM w0.089: v2(163.73,105.92) JCPU1.J27
N90453832: length 3.8
  TOP w0.102: R100.2 170.89,141.62 v1(171.22,141.29) 171.22,140.61 171.97,139.86 U27.2
N90453843: length 3.2
  TOP w0.102: R101.2 170.42,134.51 v1(171.05,135.14) 171.47,135.56 171.83,135.56 172.13,135.86 U27.12
N91483552: length 4.6
  BOTTOM w0.102: JLVDS1.10 177.13,152.47 177.4,152.74 177.4,154.22 v1(177.66,154.47) 178.32,154.47 RE32.1
N91583217: length 3.5
  TOP w0.254: 344.78,175.15 344.16,175.15 343.98,174.97 U74.37
  TOP w0.508: 344.78,175.15 345.04,175.41 v1(345.04,176.29) 344.91,176.42 C962.1
N91583233: length 5.1
  TOP w0.127: v1(341.05,163.31) 341.54,163.79 341.54,164.41 342.5,165.38 C963.1
  TOP w0.254: U74.21 342.48,165.45 C963.1
N91583239: length 4.1
  TOP w0.102: v1(345.12,165.32) R1642.1
  TOP w0.254: U74.22 342.98,166.58 343.9,165.66 R1642.1
N91583241: length 4.8
  TOP w0.102: C965.2 347.3,175.27 v1(347.68,175.65)
  TOP w0.254: U74.34 346.06,173.09 346.86,173.89 C965.2
N91583245:
  vias: v1(346.24,167.7)
N91583249: length 4.3
  TOP w0.102: v1(332.16,168.41) 332.34,168.59 R1119.1 332.55,169.76 R1142.1 332.98,170.57 333.87,169.68 C1105.1
N91583257: length 3.4
  TOP w0.102: v1(333.98,165.21) 334.17,165.4 R1141.1 R1120.1 C1106.1
N91583289: length 8.5
  BOTTOM w0.102: R1080.2 338.15,164.31 338.15,161.66 338.01,161.52 338.01,160.67 338.34,160.34 339.62,160.34 340.44,161.16 Q106.3 341.7,161.16 v1(341.94,161.4)
N91583291: length 5.4
  BOTTOM w0.102: R1079.2 338.43,164.01 338.43,162.69 338.65,162.46 Q106.6 340.05,162.46 v1(341.17,163.58)
N91583293: length 4.1
  TOP w0.102: v1(329.31,169.61) 329.18,169.74 329.18,170.97 329.75,171.54 C977.1 331.58,171.54 R1076.2
N91583295: length 2
  TOP w0.102: R1077.2 333.65,173.13 333.04,173.13 C978.1
N91814864: length 3.2
  TOP w0.102: v1(213.69,137.93) 213.89,137.73 RV34.2 214.63,138.03 v2(215.28,138.68)
  BOTTOM w0.102: UV1.M12 215.84,138.4 215.55,138.4 v2(215.28,138.68)
N91814866: length 1.4
  TOP w0.102: RV32.2 228.03,138.34 v2(227.58,137.89)
  BOTTOM w0.102: UV1.AG12 227.89,138.2 v2(227.58,137.89)
N91814868: length 3
  TOP w0.102: v1(214.99,126.76) 214.54,126.31 v2(214.45,126.31) 214.45,125.94 215.18,125.21 RV28.2
  BOTTOM w0.102: v2(214.45,126.31) 214.56,126.2 UV1.L27
N91814874: length 1.4
  TOP w0.102: RV31.2 217.17,138.83 217.33,138.66 217.33,138.67 v2(217.34,138.67)
  BOTTOM w0.102: v2(217.34,138.67) 217.33,138.67 217.33,138.66 217.05,138.38 UV1.N12
N91814876: length 3.3
  TOP w0.102: v1(216.01,127.9) 216.09,127.82 RV36.2 216.09,126.26 v2(215.5,125.68)
  BOTTOM w0.102: UV1.M27 216.02,126.2 v2(215.5,125.68)
N92289874: length 3.2
  TOP w0.102: v1(186.14,169.51) R61.2 185.02,169.94 185.06,169.98 U6.8
N93761952: length 6
  TOP w0.102: RV163.2 v1(208.39,153.81) 208.39,153.96 207.86,154.5 207.47,154.5 206.6,155.37 206.6,155.85 206.71,155.97 206.71,156.34 206.57,156.48 v2(205.94,156.48)
  BOTTOM w0.102: UV8.J13 206.31,156.85 v2(205.94,156.48)
N93762059: length 12.8
  TOP w0.102: v2(206.8,157.29) 206.4,156.89 UV7.J13
  IN2 w0.102: 208.72,154.57 206.79,156.5 206.79,157.29 v2(206.8,157.29)
  IN2 w0.127: v2(213.9,154.51) 208.78,154.51 208.72,154.57
  BOTTOM w0.102: v1(214.69,151.57) 213.77,152.49 RV162.2 213.77,154.38 v2(213.9,154.51)
N93819115: length 6.1
  IN2 w0.102: 228.2,154.57 227.49,155.29 227.49,156.18 227.27,156.39 227.27,156.93 v2(226.89,157.31)
  IN2 w0.127: v2(228.88,153.89) 228.2,154.57
  BOTTOM w0.102: v2(228.88,153.89) 229.22,153.56 RV171.2 ; v2(226.89,157.31) 227.31,156.9 UV10.J13
N93820861: length 7.3
  TOP w0.102: v2(228.67,153.31) 228.67,153.45 v1(228.24,153.89) ; v2(226.88,156.52) 227.26,156.89 UV9.J13
  IN2 w0.102: v2(226.88,156.52) 226.47,156.52 226.13,156.18 226.13,155.16 226.59,154.7 227.31,154.7 227.44,154.57
  IN2 w0.127: 227.44,154.57 228.67,153.34 v2(228.67,153.31)
  BOTTOM w0.102: RV169.2 228.2,152.84 v2(228.67,153.31)
N106386290: length 2.6
  TOP w0.102: RE1.2 CE1.1 v1(193.15,42.35)
N106390602: length 2.2
  TOP w0.102: v1(204.85,38.71) 204.07,39.48 CE2.1 203.84,39.47 RE2.2
N106528709: length 2.1
  TOP w0.102: U38.26 249.52,41.32 248.6,40.4 R1702.1
N111614398: length 2.3
  TOP w0.102: v1(229.27,134.54) 229.15,134.67 v2(228.62,134.67) 228.11,135.18 RV25.2
  BOTTOM w0.102: UV1.AH16 228.62,134.77 v2(228.62,134.67)
N111681891: length 3.3
  TOP w0.102: QV1.4 188.96,107.28 188.35,107.89 188.35,108.85 187.83,109.37 v1(187.71,109.37)
N111719849: length 3.4
  BOTTOM w0.102: U102.3 302.06,189.29 R1615.2 R1616.2 303.47,189.28 v1(303.92,188.84)
N111721348: length 3.8
  TOP w0.102: v1(50.91,195.35) 51.74,195.35 52.35,194.74 Q80.1 R3672.1
N111722051: length 2.6
  TOP w0.102: Q82.1 54.81,194.74 v1(54.28,195.27) 53.96,195.59 R954.1
N111722441: length 5.2
  TOP w0.102: R989.1 55.99,195.82 56.04,195.77 56.04,195.54 56.84,194.74 Q86.1 59.62,194.74 v1(60.03,195.15)
N111877798: length 3.8
  TOP w0.102: v1(145.42,69.94) RC98.2 RC96.2 142.83,70.47 142.83,70.84 142.67,71.01 QC4.2
N114027505: length 2.6
  TOP w0.102: RV298.1 222.72,124.94 222.06,124.28 v2(221.84,124.28) 221.84,124.27 v1(222.39,123.72)
  BOTTOM w0.102: UV1.Y29 221.96,124.4 v2(221.84,124.28)
N114027546: length 2.6
  TOP w0.102: v2(223.04,123.45) 223.3,123.19 RV296.1 224.58,123.19 v1(224.82,122.95)
  BOTTOM w0.102: UV1.Y30 222.9,123.6 v2(223.04,123.45)
N114040420: length 2.7
  TOP w0.102: v2(229.68,138.42) 229.68,137.83 229.45,137.6 RV35.2
  BOTTOM w0.102: UV1.AH12 229.45,138.2 v2(229.68,138.42)
N114202850: length 4.5
  BOTTOM w0.102: v1(239.68,126.4) RV42.1 239.65,125.4 238.67,125.4 ; 237.14,125.4 UV1.AW28
  BOTTOM w0.127: 238.67,125.4 237.14,125.4
N114204212: length 6.2
  BOTTOM w0.102: UV1.AW18 239.01,133.4 RV43.1 239.68,132.91 240.03,133.25 241.56,133.25 v1(241.75,133.44)
N114204319: length 3.9
  BOTTOM w0.102: UV1.AM39 232.05,117.01 v1(232.86,116.2) 233.28,115.77 RV44.1
N114207917: length 7.8
  TOP w0.102: CV206.1 v1(237.35,136.41)
  TOP w0.508: v2(234.5,137.1) 234.87,137.47 CV204.1 CV211.1 235.81,137.74 CV206.1
  BOTTOM w0.254: UV1.AP13 234,137.6 v2(234.5,137.1) ; UV1.AP15 UV1.AP14 234.2,136.8 v2(234.5,137.1) ; v2(234.5,137.1) 234.8,137.4 UV1.AT13
N114214511: length 1.9
  TOP w0.102: CV81.2 232.21,138.5 RV45.1 233.1,139.27 v1(233.27,139.43)
N114214513: length 1.8
  TOP w0.102: CV82.2 230.35,139.42 v2(230.24,139.53) 229.64,140.13 RV46.1
N114518899: length 6.9
  TOP w0.102: RV53.2 244.54,121.42 D71.2 243.9,119.89 RV47.2 RV55.1 v1(246.03,120.23)
N114599272: length 10
  TOP w0.102: v2(246.42,115.87) QV4.1 246.42,114.51 246.03,114.12 RV60.2 RV58.1 v1(244.71,112.15) ; RV77.2 v2(245.08,118) RV56.1
  IN4 w0.102: v2(246.42,115.87) 246.42,116.65 v2(245.08,118)
N114599279: length 9.2
  TOP w0.102: v1(251.05,114.3) QV3.2 248.83,115.2 CV52.1 RV61.2 248.83,118.8 248.61,119.01 RV55.2 RV56.2
N114599731: length 5.1
  TOP w0.102: RV59.1 245.56,116.98 245.3,116.71 245.3,116.37 QV4.2 244.33,115.4 RV57.2 242.12,115.4 v1(241.92,115.2)
N114599774: length 3.4
  TOP w0.102: v1(247.91,117.18) 247.71,116.98 RV59.2 247.83,116.1 QV3.1
N114600614: length 3.8
  TOP w0.102: QV7.2 247.6,112.8 RV58.2 CV53.1 246.95,110.2 v1(246.62,109.87)
N116042141: length 2.1
  TOP w0.102: U46.A44 262.39,50.89 262.12,50.62 262.12,50.34 262,50.22 261.67,50.22 261.37,49.92 T146.1
N116212675: length 3.4
  TOP w0.102: v1(227.25,140.32) 227.15,140.23 RV178.1 226.54,139.37 226.52,139.39 CV343.1 225.44,140 RV179.2
N116646280: length 3.5
  BOTTOM w0.102: R3754.2 v1(38.84,182) 38.59,182 38.21,182.38 38.21,183.01 37.92,183.29 U94.24
N116650187: length 6.8
  TOP w0.254: PD4.3 116.36,185.77 115.5,184.91 v1(115.11,184.91) 114.25,185.77 PBATT1.3
N116870152: length 6.9
  TOP w0.254: PU703.4 109.73,161.81 109.24,161.33 108.14,161.33 107.15,160.34 v1(106.82,160.34) 106.41,160.34 PR744.1 PR736.2
N116874102: length 6.5
  TOP w0.102: v1(103.84,160.38) 104.05,160.17 105.23,160.17 PR710.2
  TOP w0.254: PU703.6 108.43,162.42 108.34,162.33 106.88,162.33 PR727.2 106.73,162.18 106.73,161.23 106.17,160.67 PR710.2
N117653907: length 14.6
  BOTTOM w0.381: JHP1.5 358.55,173.32 358.12,173.75 358.12,175.15 v1(357.03,176.24) 357.03,177.16 355.76,178.43 354.17,178.43 D83.2 352.87,177.13 350.88,177.13 R1676.1 R1100.2
N117654516: length 13.9
  TOP w0.254: Q324.1 347.58,161.15 347.02,160.59 345.93,160.59 v1(345.55,160.21) 345.55,159.71 344.84,159 339.58,159 337.6,160.98 337.6,161.07 336.94,161.73 R1086.2
N118052171: length 3.9
  TOP w0.102: v1(184.59,152.23) 184.6,152.23 v2(184.6,152.87) 184.54,152.93 182.99,152.93 182.88,152.82 U54.4
  BOTTOM w0.102: D64.2 v2(184.6,152.87)
N118093465: length 4.2
  TOP w0.102: v1(174.93,156.86) 174.94,156.87 R115.2 174.51,158.38 D65.2 173.93,157.96 173.23,157.25 U55.4
N118416353: length 7.4
  TOP w0.254: U74.35 345.84,173.59 346.25,173.99 v1(346.25,175.78) 346.25,176.73 345.8,177.18 345.8,178.56 345.47,178.89 C962.2
N119819670: length 23.4
  TOP w0.102: v2(297.42,212.05) 295.41,212.05 v1(294.98,211.62)
  IN4 w0.102: v2(297.42,212.05) 297.42,212.98 294.62,215.77 294.62,226.33 295.55,227.26 JLOM1.10
  BOTTOM w0.102: R1166.2 v2(297.42,212.05)
N121245733: length 6.1
  TOP w0.102: v1(337.05,206.97) 336.85,206.77 336.85,204.53 337.09,204.29 v2(337.42,204.29) 337.93,203.78 R704.1
  BOTTOM w0.102: v2(337.42,204.29) 337.75,203.96 JMINI1.22
N122052446: length 4
  TOP w0.102: U39.9 295.55,138.2 296.45,139.1 R657.1 v1(296.45,140.79)
N123100505: length 1
  TOP w0.102: v4(153.09,5.75) 153.3,5.75 153.53,5.98 v1(154.03,5.98)
N123142800: length 2.5
  TOP w0.102: PR881.1 65.85,174.82 v1(65.96,174.7)
  TOP w0.254: PQ819.2 65.83,175.65 PR881.1
N123143115: length 5.1
  TOP w0.102: v1(60.7,174.71) 60.7,174.94 60.34,175.31 59.3,175.31 59.23,175.23 59.23,175.01 59.05,174.83 PR886.1
  TOP w0.254: PQ813.5 57.08,175.65 PR884.1 PR886.1
N123143189: length 6.8
  TOP w0.254: v2(53.74,178.87) 54.16,178.45 PQ821.5 ; PR887.1 PR885.1 v2(57.91,179.01)
  BOTTOM w0.254: v2(57.91,179.01) 57.77,178.87 v1(56.04,178.87) v2(53.74,178.87)
N123208235: length 2.2
  TOP w0.102: PQ7.1 106.55,184.85 v1(105.65,185.75)
N123208651: length 4
  TOP w0.102: v1(105.2,180.03) PR26.2 PC17.1 PQ7.2
N123209586: length 11.2
  TOP w0.102: PR888.2 49.27,190.48
  TOP w0.254: PU803.4 49.27,191.25 v1(49.47,191.45) 50.3,192.28 52.72,192.28 52.91,192.09 54.31,192.09 55.14,191.26 55.14,190.53 54.78,190.17 54.48,190.17 54.21,189.9 PQ806.5
N123214460: length 12.7
  BOTTOM w0.102: v1(116.58,165.09) 118.74,165.09 119.27,165.62 PD811.2
  BOTTOM w0.254: PR815.2 122.63,171.81 122.63,170.17 122.41,169.95 121.84,169.95 121.36,169.46 121.36,165.99 120.99,165.62 PD811.2
N123214476: length 8.8
  BOTTOM w0.102: v1(116.44,166.64) 116.44,166.19 117.01,165.62 PD811.1
  BOTTOM w0.254: PD811.1 118.74,165.62 119.34,166.22 120.39,166.22 120.98,166.8 120.98,168.53 120.47,169.03 PQ812.6
N123257917: length 9.2
  TOP w0.254: PR748.2 86.37,164.19 86.62,163.93 PQ710.1 86.96,161.64 v1(88.01,160.59) 88.21,160.39 90.08,160.39 90.25,160.21 90.25,159.8 91.01,159.04 PU704.1
N123258004: length 4.7
  TOP w0.102: PU704.4 92.31,161.32 v1(92.77,161.77)
  TOP w0.254: PU704.4 92.31,160.26 92.46,160.11 92.46,159.68 92.76,159.38 93.1,159.38 94.09,160.38 PQ707.5
N123885734: length 7
  TOP w0.254: PU802.4 51.81,184.2 51.9,184.11 v2(52.26,184.11) ; v2(55.33,185.94) 55.24,185.85 54.06,185.85 53.96,185.75 PQ802.5
  BOTTOM w0.254: v2(52.26,184.11) 52.41,184.11 v1(52.89,184.59) 53.48,185.18 54.29,185.18 55.05,185.94 v2(55.33,185.94)
N123891751: length 3.1
  TOP w0.102: v1(169.78,167.78) 169.78,168.11 PQ825.2
  TOP w0.254: PR872.2 170.9,169.1 PQ825.2
N123898600: length 8
  BOTTOM w0.254: PQ910.6 161.31,171.45 161.44,171.57 ; 161.44,171.57 161.44,170.64 v1(160.99,170.19) 159.36,170.19 158.72,170.83 PR878.2 ; 161.44,171.57 161.44,171.86 161.2,172.1 PQ910.5
N123898606: length 5
  BOTTOM w0.102: PQ910.3 159.34,172.75 159.85,173.25 161.49,173.25 v1(161.81,173.57)
  BOTTOM w0.254: PR879.1 158.11,172.81 158.17,172.75 PQ910.3
N123900627: length 8.6
  BOTTOM w0.102: v1(115.04,172.92) 115.06,172.94 PR889.1
  BOTTOM w0.254: PR889.1 PR890.1 116.4,172.39 117.05,172.39 117.37,172.07 118.66,172.07 119.27,171.46 PD812.1 120.06,171.21 120.04,171.21 119.74,170.91 119.74,170.45 119.82,170.37 PQ812.5
N123905334: length 3.6
  TOP w0.102: v1(132.88,189.29) PR892.1
  TOP w0.254: v2(132.85,186.45) 132.88,186.47 PR891.1 PR892.1
  BOTTOM w0.254: PR821.2 v2(132.85,186.45)
N123911328: length 10.1
  TOP w0.254: PD804.1 233.55,83.32 234.67,82.21 235.27,82.21 237.42,80.05 v1(237.64,80.05) 239.67,80.05 240.54,80.91 PQ808.6
N123911330: length 12
  TOP w0.102: PR805.2 241.92,82.77 241.44,82.28 241.44,81.27 v1(241.7,81)
  TOP w0.254: v2(241.19,82.98) 241.28,82.89 PR805.2 ; PD804.2 235.72,83.32 236.65,82.4 236.65,81.74 v2(236.58,81.67)
  IN2 w0.254: v2(241.19,82.98) 240.47,82.98 239.84,83.62 237.13,83.62 236.7,83.18 236.7,81.79 v2(236.58,81.67)
N123911332: length 5
  TOP w0.102: v1(237.49,85.28) 238.3,85.28 238.6,84.98 PR800.1
  TOP w0.254: 239.24,84.26 PQ808.3 ; 239.24,84.26 239.67,84.26 239.89,84.05 PQ808.2 ; 239.24,84.26 239.24,84.91 PR800.1
N123911345: length 252.5
  TOP w0.102: v1(134.68,159.7) 135.8,159.7 v2(136,159.5)
  TOP w0.254: v2(241.07,84.54) 241.6,84.01 PR803.1 242.13,84.01 242.45,83.69 242.45,82.51 PR805.1 241.92,81.57 242.71,80.78 PQ803.4 ; PD805.1 134.6,174.69 v4(134.76,174.84)
  IN3 w0.254: v2(136,159.5) 136.51,158.99 150.77,158.99 151.27,159.5 152.92,159.5 153.73,160.31 157.62,160.31 160.94,163.64 163.3,163.64 164.07,164.4 165.41,164.4 171.1,170.09 173.46,170.09 173.96,169.6 175.07,169.6 175.55,169.11 176.18,169.11 176.66,169.6 177.95,169.6 178.5,169.05 180.28,169.05 182.02,167.31 186.16,167.31 187.6,168.74 193.81,168.74 194.06,168.49 194.62,168.49 195.05,168.92 195.53,168.92 196.11,169.49 198.61,169.49 199.32,168.78 220.56,168.78 224.82,173.05 232.09,173.05 232.49,173.46 239.96,173.46 240,173.42 252.61,173.42 253.55,172.48 253.98,172.48 255.18,171.28 255.18,165.26 255.77,164.67 255.77,158.94 257.2,157.52 257.2,144.87 258.87,143.19 258.87,139.41 257.28,137.82 257.28,136.01 256.59,135.31 256.59,132.55 258.02,131.12 258.02,114.07 255.39,111.44 255.39,104.1 248.49,97.19 246.51,97.19 244.17,94.84 244.17,87.64 v2(241.07,84.54)
  IN4 w0.254: v4(134.76,174.84) 134.6,174.69 134.6,161 136,159.6 v2(136,159.5)
N123911602: length 5.5
  TOP w0.102: v1(242.93,71.92) PR809.1
  TOP w0.254: PR809.1 PC800.1 244.65,73.99 244.65,74.99 244.45,75.2 PQ804.4
N124176605: length 6.4
  TOP w0.254: PR894.2 PR830.1 152.36,179.76 v1(152.36,180.7) 152.33,180.72 151.82,180.72 151.46,180.35 PQ828.3 149.67,180.35 149.14,180.87 149.14,181.83 PR895.2
N124178621: length 5.8
  TOP w0.254: PR830.2 151.75,178.82 151.35,178.42 PQ828.2 148.74,178.42 v2(148.44,178.12) 148.01,177.7 PQ829.1
N124179121: length 4.3
  TOP w0.102: v1(145.35,179.39) 145.66,179.39 146.19,178.87 PR828.1
  TOP w0.254: PD820.2 145.41,177.03 145.69,177.31 PQ829.2 146.41,178.16 PR828.1
N124410754: length 3.6
  TOP w0.102: PD821.2 v1(38.27,169.96)
  TOP w0.254: PD821.2 39.63,170.8 39.84,171.01 PQ820.1
N124410864: length 3.9
  TOP w0.102: PR897.1 v1(42.03,177.06)
  TOP w0.254: PQ820.2 40.8,175.17 41.03,175.4 PR896.2 PR897.1
N124411234: length 6.7
  TOP w0.254: PQ830.1 35.03,175.4 36.7,177.06 v1(37.73,177.06) PR897.2
N124411371: length 3.2
  TOP w0.254: PQ830.2 33.42,173.28 33.83,172.87 v1(34.11,172.87) 35.14,172.87 35.26,173 PU809.4
N124735836: length 3.7
  TOP w0.102: v1(281.43,126.34) 281.43,125.78 Q4.2 279.93,124.76 279.59,125.11 R55.2
N124736450: length 2.3
  TOP w0.102: v1(243.95,132.41) 243.78,132.24 RV78.2 242.64,132.59 QV8.2
N126184618: length 1.9
  TOP w0.102: U46.A23 268.94,58.78 269.26,59.11 T147.1
N126754711: length 3.7
  TOP w0.102: U74.46 339.48,175.3 338.74,176.03 338.07,176.03 v1(337.82,176.29) 337.68,176.43 R169.1
N126755046: length 4.8
  TOP w0.102: C969.1 347.65,172.39 348.01,172.02 v1(348.01,170.9)
  TOP w0.254: C969.1 346.35,171.59 U74.31
N126756741: length 3.4
  TOP w0.102: Q327.5 350.67,172.94 350.93,173.2 v1(350.93,173.62) 350.93,173.74 350.88,173.79 349.98,173.79 R1084.2 349.89,173.26 350.02,173.14 Q327.6
N126942376: length 2.6
  BOTTOM w0.102: v1(346.3,168.05) R210.2 347.35,168.69 D12.1
N126942378: length 2.3
  BOTTOM w0.102: D11.1 348.37,168.62 348.26,168.5 R209.2 v1(349.22,168.05)
N126978921: length 5.2
  TOP w0.102: U46.B1 273.19,48.64 274.23,47.6 275.53,47.6 275.76,47.37 275.76,45.99 T148.1
N127053194: length 2.6
  BOTTOM w0.102: U100.12 284.32,177.87 C445.1 283.37,177.86 v1(283.27,177.76)
N127053198: length 2.6
  BOTTOM w0.102: v1(286.22,177.69) 286.04,177.86 C450.1 285.12,177.97 U100.10
N127053228: length 5.8
  BOTTOM w0.102: v1(285.89,184.89) 285.89,183.27 286.34,182.82 ; R1633.2 286.34,182.82 ; 286.34,182.82 R1631.2 R716.1 284.32,182.8 U100.3
N127056523: length 2.1
  TOP w0.102: C448.1 324.23,203.73 323.76,204.2 323.76,204.69 323.45,204.99 v1(322.89,204.99)
N127056527: length 2.5
  TOP w0.102: C452.1 325.66,204.18 325.66,205.02 v1(324.98,205.7)
N127058740: length 4.1
  BOTTOM w0.102: U102.12 302.06,193.2 302.17,193.31 302.17,194.44 C455.1 302.05,194.58 302.51,195.03 302.51,196.11 v1(302.26,196.37)
N127058744: length 4.1
  BOTTOM w0.102: v1(300.71,196.46) 300.64,196.39 300.64,195.03 301.13,194.55 C456.1 301.32,194.37 301.32,193.36 301.26,193.3 U102.10
N127061181: length 1.5
  TOP w0.102: C465.1 248.64,139.75 248.16,140.23 U103.12
N127061185: length 1.4
  TOP w0.102: C476.1 247.36,139.57 U103.10
N127066552: length 8
  TOP w0.102: R1607.2 v2(169.15,161.26) v1(168.36,161.26) ; R1607.2 R1620.2 ; R1607.2 R1608.2 ; v2(170.4,164.6) 170.4,164.62 170.75,164.97 U104.5
  IN3 w0.127: v2(169.15,161.26) 170.4,162.52 v2(170.4,164.6)
N127066560: length 1.6
  TOP w0.102: C477.1 174.64,165.77 U104.12
N127066572: length 1.7
  TOP w0.102: C486.1 174.55,164.97 U104.10
N127068793: length 1.6
  BOTTOM w0.102: U105.12 226.09,37.19 C487.1
N127068797: length 2.7
  BOTTOM w0.102: U105.10 225.81,37.99 226,37.79 C488.1 226.37,38.26 v1(226.83,38.72)
N127656110: length 6.1
  TOP w0.102: v1(354.01,167.93) 353.56,167.93 353.23,167.6 R40.2 R39.2 351.51,167.6 351.18,167.93 C970.1 351.18,169.48 350.67,169.99 Q327.2
N127916603: length 1.2
  BOTTOM w0.102: v1(344.05,173.05) 343.68,172.68 R1680.1
N129001439: length 3.6
  TOP w0.102: CD47.2 RC109.1 126.11,32.09 126.37,31.83 126.37,30.77 v1(127.03,30.11)
N129001503: length 2.2
  TOP w0.102: CD48.2 RC110.1 169.57,17.68 v1(170.12,17.12)
N129004419: length 3.5
  TOP w0.102: RC108.1 CD46.2 127.95,25.46 127.63,25.15 v1(127.63,23.32)
N129121341: length 3.4
  TOP w0.102: v1(142.35,66.27) 142.28,66.33 QC1.1 142.55,68.21 RC15.1
N129121543: length 4.1
  TOP w0.102: RC14.1 RC13.1 139.3,60.02 v1(139.3,61.24) UC1.2
N129600569: length 3.2
  BOTTOM w0.102: U95.24 340.22,187.99 R3769.2 338.37,187.12 v1(338.36,187.13)
N1320394060: length 4.6
  TOP w0.102: v1(198.86,99.16) 198.67,99.16 198.2,98.69 198.2,97.43 197.73,96.96 PC666.1
  TOP w0.254: PC666.1 198.37,96.31 PU602.7

## Copper pours and planes (outline as drawn)
1.5VSP_FB on TOP (solid shape): 231.76,107.58 231.76,106.95 232.65,106.06 233.15,106.06 233.28,105.93 233.28,105.68 233.16,105.56 233.07,105.57 232.82,105.57 232.77,105.56 232.72,105.55 232.27,105.55 232.14,105.42 232.14,104.79 232.01,104.66 231.38,104.66 231.25,104.79 231.25,106.57 230.87,106.95 230.87,107.58 231,107.71 231.63,107.71
