# Allegro board LA-9411P R10-0403.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
USB3TP5_C: length 2.2
  BOTTOM w0.102: U95.19 342.72,188.47 342.58,188.33 342.58,188.18 343,187.76 343,187.51 C1554.2
USB3TP5_CO: length 8.3
  TOP w0.102: R36.2 343,187.51 343,188.18 343.25,188.43 v4(343.25,189.26) 343.25,193.1 343.27,193.12 343.27,193.67 343.25,193.69 343.25,194.55 C1564.2
USB3TP5_D+: length 10.7
  BOTTOM w0.102: JUSB3.9 357.19,193.82 356.34,193.82 355.96,194.2 355.96,194.65 355.78,194.83 355.18,194.83 354.71,194.36 v4(354.22,194.36) 353.69,194.36 353.55,194.21 D91.5 D91.6 351.45,194.21 351.3,194.37 351.05,194.37 350.71,194.02 L112.3 349.9,194.02 R3727.2
USB3TP5_RP: length 2.6
  BOTTOM w0.102: C1553.2 343.23,194.53 343.23,194.34 342.58,193.69 342.58,193.53 342.72,193.39 U95.12
USB3TP6: length 399.4
  TOP w0.089: v2(202.45,81.64) 202.45,82.96 v1(202.34,83.06)
  TOP w0.102: v2(41.79,186.09) 41.6,185.91 41.36,185.91 R20.1
  IN1 w0.114: v2(202.45,81.64) 202.45,81.62 202.21,81.39 202.21,81.39 201.76,80.94 200.99,80.94 200.52,81.41 200.52,82.58 201.29,83.35 201.29,84.51 202.65,85.86 203.21,85.86 203.5,85.57 204.8,85.57 206.91,87.68 208.13,87.68 216.98,96.53 232.83,96.53 233.75,95.61 243.64,95.61 246.44,98.41 247.27,98.41 253.04,104.18 253.04,111.43 253.51,111.9 253.51,113.13 252.98,113.66 252.98,134.36 252.31,135.03 252.31,142.3 251.85,142.75 251.85,146.65 253.51,148.31 253.51,165.06 253.88,165.43 253.88,170.78 251.45,173.22 247.66,173.22 245.97,173.21 243.49,175.69 231,175.69 230.14,176.56 218.17,176.56 217.31,175.69 202.4,175.69 201.87,176.22 201.87,177.21 201.58,177.5 201.58,180.7 201.33,180.95 199.39,180.95 197.49,182.85 193.51,182.85 193.32,182.66 190.85,182.66 188.19,185.32 182.34,185.32 180.8,186.85 179.91,186.85 178.65,188.12 174.98,188.12 174.41,188.68 166.63,188.68 165.41,189.9 161.96,189.9 159.86,187.81 159.86,180.69 159.49,180.31 159.49,179.14 159.49,179.13 159.49,178.31 159.86,177.94 159.86,173.15 155.07,168.35 155.07,166.32 154.17,165.42 148.32,165.42 146.11,163.21 141.33,163.21 140.9,163.64 138.07,163.64 136.64,165.07 136.36,165.07 135.76,165.07 135.76,165.07 133.33,165.07 132.7,165.7 116.22,165.7 116.08,165.56 95.52,165.56 94.99,166.09 90.62,166.09 81.82,174.89 69.52,174.89 68.72,175.69 60.23,175.69 59.42,174.88 48.85,174.88 42.85,180.89 42.85,183.61 41.98,184.47 41.79,184.47 41.07,185.2 41.07,185.9 41.26,186.09 v2(41.79,186.09)
  BOTTOM w0.089: UH1.BE28 202.6,80.49 202.43,80.66 202.33,80.66 201.92,81.07 201.92,81.48 202.06,81.62 202.06,81.9 202.13,81.97 202.22,81.97 202.45,81.74 v2(202.45,81.64)
  BOTTOM w0.102: R20.1 41.37,185.91 41.6,185.91 v2(41.79,186.09)
USB3TP6_C: length 3
  BOTTOM w0.102: C1550.2 39.65,185.94 39.4,185.94 39.11,185.65 v4(38.72,185.65) 38.2,185.65 38.06,185.79 U94.19
USB3TP6_CO: length 9.3
  TOP w0.102: R20.2 39.64,185.92 38.35,185.92 38.33,185.94 37.78,185.94 37.77,185.92 v4(35.72,185.92) 31.45,185.92 C421.1
USB3TP6_D+: length 14.6
  BOTTOM w0.102: JUSB4.9 13.29,186.42 13.62,186.1 13.87,186.1 14.28,185.69 16.29,185.69 16.51,185.47 16.51,184.7 16.63,184.57 17.19,184.57 17.32,184.7 17.32,185.37 17.64,185.69 17.74,185.69 17.76,185.71 18.47,185.71 18.5,185.69 v4(19.43,185.69) 20.32,185.69 20.43,185.8 D79.10 D79.1 22.54,185.8 22.65,185.7 23.28,185.7 23.57,185.98 24.15,185.98 L97.3 24.72,186.24 R1613.2
USB3TP6_RP: length 2.6
  BOTTOM w0.102: C415.1 31.58,185.79 v4(32.09,185.79) U94.12
USB30_EN: length 3.7
  BOTTOM w0.102: Q123.5 Q123.6 228.09,45.74 R515.2 v1(227.64,47.35)
USB30_SMI#: length 41.5
  TOP w0.102: v2(224.28,50.53) 226.13,48.68 230.95,48.68 v2(231.36,48.26)
  IN3 w0.089: v2(214.89,65.05) 214.91,65.07 214.91,66.6 217.32,69.01 218.83,69.01 219.22,68.62
  IN3 w0.127: v2(226.17,56.4) 225.92,56.65 225.92,60.68 221.92,64.67 221.92,65.92 219.22,68.62
  BOTTOM w0.089: v2(214.89,65.05) 214.52,65.42 214.52,65.67 214.28,65.91 213.8,65.91 213.54,66.17 UH1.C22
  BOTTOM w0.102: v2(226.17,56.4) 226.14,56.37 226.14,54.27 v1(224.17,52.3) 224.17,50.64 v2(224.28,50.53) ; Q123.3 230.63,48.66 R514.2 231.16,49.03 231.36,48.82 v2(231.36,48.26)
USB_MCARD1_DET#: length 179.3
  TOP w0.102: v2(269.74,177.52) v1(269.74,176.94)
  IN2 w0.127: v2(256.01,167.2) 261.83,167.2 262.82,168.19 268.74,168.19 268.74,168.19 v2(268.72,168.19)
  IN3 w0.089: 213.67,61.56 213.15,61.56 212.96,61.36
  IN3 w0.127: v2(256.01,167.2) 255.53,166.71 255.53,165.36 256.22,164.67 256.22,163 257.04,162.18 257.04,158.75 257.51,158.28 257.51,145 259.7,142.81 259.7,137.98 256.9,135.18 256.9,132.68 258.34,131.25 258.34,113.89 255.71,111.26 255.71,103.96 248.62,96.88 246.65,96.88 244.75,94.98 244.75,87.48 242.39,85.12 242.39,74.95 239.01,71.56 239.01,71.07 236.19,68.25 232.04,68.25 230.63,66.84 230.63,59.08 227.53,55.98 225.66,55.98 225.47,56.17 225.47,57.18 225.04,57.62 219.13,57.62 218.22,58.53 217.52,58.53 215.59,60.46 214.92,60.46 213.83,61.56 213.67,61.56 ; v2(212.39,59.91) 212.42,59.95 212.42,60.83 212.96,61.36
  BOTTOM w0.089: 211.62,61.02 211.45,61.19 211.45,61.25 210.73,61.97 UH1.A10
  BOTTOM w0.102: v2(212.39,59.91) 211.88,60.42 211.88,60.76 211.62,61.02 ; JMINI2.40 269.85,177.63 v2(269.74,177.52) R739.1 268.84,176.53 268.38,176.07 268.38,174.87 268.31,174.79 268.31,174.03 269.21,173.13 269.21,168.64 268.75,168.19 268.74,168.2 268.73,168.19 v2(268.72,168.19)
USB_OC0#: length 307.9
  TOP w0.102: v2(347.57,213.93) 348.45,213.05 U91.5
  IN1 w0.102: v2(201.96,51.73) 201.96,51.64 201.66,51.33 201.66,49.14 205.77,45.03 214.02,45.03 215.54,46.56 217.41,46.56 222.25,51.4 226.17,51.4 226.41,51.16 229.96,51.16 230.9,52.1 234.91,52.1 236.64,53.83 236.64,54.97 239.32,57.65 240.01,57.65 241.31,58.95 241.31,59.64 243.14,61.47 245.08,61.47 246.83,63.22 253.61,63.22 255.48,65.09 263.1,72.71 263.1,76.05 266.25,79.2 266.25,84.87 265.17,85.95 265.17,86.29 266.92,88.04 266.92,89.92 v2(267.89,90.88)
  IN2 w0.127: v2(301.44,136.17) 299.97,134.7 292.75,134.7 292.47,134.98 289.95,134.98 286.69,131.71 285.56,131.71 285.22,131.37 282.72,131.37 282.43,131.08 281.06,131.08 280.27,131.86 280.06,131.86 279.65,131.86 279.38,131.58 v2(276.44,131.58)
  IN3 w0.127: v2(313.95,170.1) 314.1,169.95 314.1,169.7 314.43,169.37 314.43,166.81 315.77,165.48 315.77,157.64 315.33,157.21 315.33,153.79 316.29,152.83 316.29,149.13 315.18,148.02 315.18,146.34 312.95,144.11 311.4,144.11 311.3,144.01 309.32,144.01 307.41,142.1 307.41,141.2 303.17,136.96 302.64,136.96 302.54,136.85 301.95,136.85 301.44,136.35 v2(301.44,136.17)
  IN4 w0.102: v2(313.95,170.1) 313.95,170.09 314.26,170.4 314.26,171.02 315.02,171.78 318.91,171.78 319.2,172.07 321.29,172.07 321.94,172.72 323.29,172.72 325.88,170.13 329.26,170.13 329.33,170.19 329.95,170.19 330.26,170.5 330.26,174.44 330.51,174.69 330.51,180.99 333,183.48 333,192.73 334.22,193.95 334.22,197.07 333.57,197.71 333.57,203.29 336.33,206.04 336.33,210.39 337.46,211.52 346.03,211.52 347.57,213.05 v2(347.57,213.93) 347.57,218.4 v2(350.06,220.89)
  BOTTOM w0.102: RH189.2 203.39,52.64 202.47,51.73 v2(201.96,51.73) ; v2(350.06,220.89) 349.92,221.03 U48.5 ; v2(267.89,90.88) 267.89,91.07 268.17,91.35 268.68,91.35 269.21,91.88 270.91,91.88 271.79,92.76 271.79,95.3 270.97,96.12 270.97,100.06 v1(271.38,100.47) 272.98,102.07 272.98,104.29 272.02,105.26 272.02,117.46 272.54,117.98 272.54,123.15 274.95,125.56 274.95,128.18 276.44,129.67 v2(276.44,131.58)
USB_OC0#_R: length 196.5
  TOP w0.089: RPH3.4 205.52,62.1 205.52,62.32 204.43,63.41 204.05,63.41 203.28,62.65 v2(203.06,62.65)
  TOP w0.102: v2(273.67,91.22) 273.71,91.22 274.11,90.82 275.06,90.82 275.32,90.56 RH3.1
  IN1 w0.089: v2(203.06,62.65) 203.79,62.65 204.3,62.14 204.3,60.92 204.28,60.9
  IN1 w0.102: 204.28,60.9 204.17,60.79 204.17,60.36 203.22,59.41 203.22,59.38 202.01,58.18 202.01,56.59 202.4,56.21 202.4,55.08 201.87,54.55 201.87,54.01 201.32,53.46 201.32,52.44 201.52,52.23 v2(201.52,52.13)
  IN2 w0.127: v2(273.67,91.22) 272.28,92.62 256.37,92.62 256.19,92.44 256.18,92.44 v2(256.01,92.27)
  IN3 w0.089: 202.8,62.38 203.06,62.64 v2(203.06,62.65)
  IN3 w0.127: 202.8,62.38 202.66,62.24 201.38,62.24 199.74,60.6 199.74,59.46 200.25,58.94 200.25,57.35 199.55,56.65 199.55,56.18 199.87,55.86 199.87,55.02 198.79,53.94 198.79,49.76 201.09,47.45 201.99,47.45 205.33,44.11 211.51,44.11 224.99,30.62 224.99,28.32 229.26,24.05 232.22,24.05 233.4,22.87 243.25,22.87 248.28,27.9 248.28,29.46 251.11,32.29 251.35,32.29 251.75,32.69 251.75,33.1 253.54,34.9 253.54,38.34 252.14,39.74 250.71,39.74 249.8,40.64 249.8,49.56 251.26,51.02 251.26,53.88 251.46,54.08 251.46,56.07 251.54,56.16 251.54,57.16 252.04,57.66 252.04,60.1 251.33,60.82 251.33,65.84 255.74,70.25 255.74,91.38 255.61,91.51 255.61,91.86 255.85,92.11 255.91,92.11 256.01,92.21 256.01,92.27 v2(256.01,92.27)
  BOTTOM w0.089: UH1.P3 204.44,63.93 204.11,63.6 203.75,63.6 203.58,63.43 203.58,62.94 203.28,62.65 v2(203.06,62.65)
  BOTTOM w0.102: v2(201.52,52.13) v1(201.52,52.72) 201.52,53.02 202.37,53.87 RH189.1
USB_OC1#: length 289.3
  TOP w0.102: U93.5 347.88,195.2 347.58,195.49 347.1,195.49 v2(346.85,195.74)
  IN1 w0.102: v2(308.82,134.48) 308.82,137.06 319.34,147.58 319.34,154.08 319.73,154.47 319.73,158.2 318.93,159 318.93,166.38 318.52,166.79 318.52,170.09 321.48,173.04 322.58,173.04 324.35,174.8 330.37,174.8 330.9,175.34 337.2,175.34 337.47,175.61 337.47,177.85 338.5,178.88 338.5,185.18 340.42,187.1 341.91,187.1 342.86,188.05 347.7,188.05 348.09,188.44 348.09,194.5 v2(346.85,195.74) ; v2(200.21,60.45) 200.02,60.26 200.02,58.69 200.17,58.53 200.17,57.32 199.5,56.65 199.5,55.77 199.84,55.42 199.84,54.05 199.78,53.98 199.78,50.45 200.36,49.87 200.36,48.66 204.9,44.12 216.43,44.12 221.79,49.48 230.04,49.48 231.74,51.18 235.29,51.18 244.66,60.55 245.46,60.55 247.21,62.31 253.99,62.31 255.86,64.17 255.86,64.17 265.2,73.51 v2(265.24,73.51)
  IN2 w0.127: v2(273.48,128.96) 273.62,128.96 274.98,130.31 282.82,130.31 283.12,130.61 285.54,130.61 285.88,130.95 287.01,130.95 290.27,134.21 292.1,134.21 292.41,133.91 308.25,133.91 v2(308.82,134.48)
  BOTTOM w0.102: v2(200.21,60.45) 199.93,60.45 199.41,59.93 RH190.2 ; v2(273.48,128.96) 273.48,127.34 273.02,126.89 273.02,126.34 265.34,118.66 265.34,113.63 259.37,107.66 259.37,99.83 258.1,98.56 258.1,96.08 259.27,94.91 259.27,91.48 258.67,90.88 258.67,81.98 259.25,81.4 259.25,79.96 260.23,78.98 260.23,76.82 v1(263.24,73.81) 263.54,73.51 v2(265.24,73.51)
USB_OC1#_R: length 191.1
  TOP w0.089: RPH3.3 204.15,61.43 204.15,61.15 204.08,61.09
  TOP w0.102: RH4.1 275.38,89.55 275.06,89.86 v1(274.3,89.86) 274.14,89.86 v2(273.67,90.33) ; 204.08,61.09 v2(203.77,60.77)
  IN1 w0.089: 204.08,61.09 204.1,61.1 204.1,61.79 203.94,61.94 203.23,61.94
  IN1 w0.102: 203.23,61.94 202.37,61.94 202.26,61.82 200.97,61.82 198.56,59.41 198.56,58.96 v2(198.28,58.67) ; 204.08,61.09 v2(203.77,60.77)
  IN2 w0.127: v2(273.67,90.33) 273.26,90.75 270.21,90.75 269.63,91.34 267.83,91.34 266.8,92.36 261.06,92.36 260,91.3 256.42,91.3 v2(256.03,91.69)
  IN3 w0.127: v2(198.28,58.67) 197.53,57.93 197.53,56.87 196.12,55.46 196.12,53.95 196.25,53.83 196.25,52.32 196.23,52.31 196.23,49.98 199.53,46.69 201.67,46.69 205.02,43.34 211.19,43.34 224.2,30.34 224.2,28.03 228.99,23.24 231.9,23.24 233.03,22.11 243.57,22.11 249.04,27.59 249.04,29.15 251.43,31.53 252.83,31.53 254.5,33.21 254.5,36.44 255.51,37.45 255.51,40.15 253.33,42.32 253.33,47.42 252.38,48.37 252.38,50.08 251.76,50.69 251.76,52.57 252.62,53.43 252.62,56.57 252.55,56.64 252.55,60.31 251.84,61.03 251.84,65.11 256.23,69.51 256.56,69.51 257.15,70.1 257.15,71.18 256.28,72.04 256.28,77.77 256.07,77.99 256.07,91.69 v2(256.03,91.69)
  BOTTOM w0.089: 201.62,63 202.15,63.53 202.15,63.72 202.73,64.31 UH1.V1
  BOTTOM w0.102: 201.62,63 200.36,61.74 200.36,60.94 200.69,60.6 200.69,60.13 199.84,59.28 198.76,59.28 RH190.1 198.73,59.13 v2(198.28,58.67)
USB_OC2#: length 125.1
  TOP w0.102: v2(273.66,89.43) 273.72,89.43 274.24,88.91 275,88.91 275.39,88.53 RH6.1
  IN1 w0.102: v2(201.42,61.37) 201.42,60.87 200.33,59.78 200.33,58.76 200.4,58.69 200.4,57.23 199.75,56.58 199.75,55.84 200.07,55.52 200.07,53.95 200.01,53.89 200.01,50.55 200.68,49.87 200.68,48.79 205.13,44.35 216.33,44.35 221.76,49.77 230.01,49.77 231.64,51.41 235.19,51.41 244.56,60.78 245.36,60.78 247.12,62.53 253.9,62.53 255.77,64.4 263.79,72.42 263.79,73.06 265,74.27 265,76.73 267.06,78.8 267.06,86.7 267.39,87.03 267.39,88.86 v2(268.07,89.53)
  IN2 w0.127: v2(268.07,89.53) 268.16,89.62 271.43,89.62 271.61,89.8 273.29,89.8 v2(273.66,89.43)
  BOTTOM w0.089: 202.38,62.79 202.42,62.83 202.42,63.06 202.64,63.27 202.64,63.67 203.36,64.39 UH1.U2
  BOTTOM w0.102: 202.38,62.79 201.79,62.19 201.79,61.73 v2(201.42,61.37) 201.42,60.31 200.85,59.74 200.85,59.38 201,59.23 201,58.6 RPH1.1
USB_OC3#: length 150.1
  TOP w0.089: 203.31,61.86 203.46,62.01 204.02,62.01 RPH3.2
  TOP w0.102: v2(248.5,71.67) 249.35,72.52 265.43,72.52 265.44,72.5 273.07,72.5 273.49,72.08 277.14,72.08 278.43,73.38 278.43,79.11 278.18,79.36 278.18,87.49 277.67,88 276.61,88 276.13,87.52 RH7.1 ; 203.31,61.86 v1(203.03,61.57) 202.71,61.26 v2(202.71,61.05)
  IN3 w0.127: v2(248.5,71.67) 247.38,70.55 247.38,62.9 247.84,62.45 247.84,61.73 247.09,60.98 247.09,57.41 246.64,56.97 246.64,55.27 245.22,53.85 245.22,51.49 244.8,51.07 244.8,45.29 243.9,44.39 241.17,44.39 238.63,46.93 233.69,46.93 233,46.24 233,41.48 232.41,40.88 223.19,40.88 217.72,46.34 212.14,46.34 211.79,45.99 206.73,45.99 206.42,46.29 206.42,47.43 204.28,49.58 204.28,54.18 v2(204.46,54.36)
  IN4 w0.102: v2(202.71,61.05) 203.28,60.48 203.28,59.45 202.34,58.51 202.34,58.09 201.46,57.21 201.46,56.75 200.69,55.98 200.69,54.7 201.56,53.84 203.93,53.84 v2(204.46,54.36)
  BOTTOM w0.089: UH1.P1 203.76,63.17 203.76,62.8 203.21,62.26 203.1,62.26 203.01,62.16
  BOTTOM w0.102: v2(202.71,61.05) 202.75,61.09 202.75,61.92 203,62.16 203.01,62.16
USB_OC4#: length 311.7
  TOP w0.102: v2(103.49,150) 103.49,150 104.28,149.21 v1(108.06,149.21) 109.19,149.21 v2(109.56,148.84) ; v2(205.4,53.43) 205.4,52.46 203.55,50.61 201.37,50.61 197.52,46.76 v2(195.41,46.76)
  IN2 w0.127: v2(195.41,46.76) 195.28,46.89 195.28,47.7 194.1,48.88 126.84,48.88 120.01,55.71 120.01,64.45 118.55,65.91 118.55,80.16 117.88,80.83 117.88,84.47 116.87,85.48 113.14,85.48 112.77,85.85 112.77,125.08 111.9,125.96 111.9,135.94 108.57,139.27 108.57,147.85 v2(109.56,148.84)
  IN4 w0.102: v2(103.49,150) 103.49,150.06 103.14,150.41 103.14,150.86 96.15,157.85 92.99,157.85 90.33,160.5 86.95,160.5 85.45,162 85.45,166.38 82.53,169.3 32.3,169.3 29.24,172.36 29.24,178.76 30.17,179.69 30.17,187.13 26.63,190.66 v2(26.63,190.69)
  BOTTOM w0.102: v2(26.63,190.69) 26.39,190.93 U49.5 ; RH191.2 204.15,55.89 205.4,54.64 v2(205.4,53.43)
USB_OC4#_R: length 181.7
  TOP w0.089: RPH3.1 203.68,62.38 203.42,62.38 203.23,62.19 203.06,62.19 203.02,62.15
  TOP w0.102: v2(202.55,59.39) 202.17,59.77 v1(202.17,60.4) 202.31,60.54 202.31,61.44 203.02,62.15 ; v2(273.66,86.87) 273.72,86.87 274.11,86.47 275.42,86.47 275.45,86.5 RH8.1
  IN2 w0.127: v2(256.02,92.86) 255.85,92.69 255.84,92.69 255.59,92.45 255.59,91.04 256.07,90.56 262.25,90.56 262.83,91.15 265.63,91.15 268,88.77 271.52,88.77 272.11,88.19 272.74,88.19 273.03,87.9 273.03,87.49 v2(273.66,86.87)
  IN3 w0.127: v2(202.55,59.39) 201.94,59.39 201.19,58.64 201.19,58.2 201.71,57.68 201.71,55.36 v2(201.7,55.35) 201.7,55.04 201.2,54.55 200.6,54.55 199.3,53.24 199.3,50.49 201,48.78 201.38,48.78 205.5,44.66 211.67,44.66 225.53,30.8 225.53,28.49 227.37,26.66 229.06,26.66 230.52,25.2 232.7,25.2 233.88,24.02 240.7,24.02 242.25,25.57 244.33,25.57 246.12,27.36 246.12,30.04 247.93,31.84 247.93,32.4 247.29,33.03 247.29,35.64 246.12,36.8 246.12,38.9 248.43,41.21 248.43,49.81 249.66,51.04 249.66,51.43 249.23,51.87 249.23,53.38 249.7,53.85 249.7,57.55 250.28,58.13 250.28,58.7 249.5,59.49 249.5,60.15 250.08,60.73 250.08,66.21 253.73,69.85 253.73,81.92 252.62,83.02 252.62,90.28 253.54,91.2 254.37,91.2 255.59,92.43 255.59,92.45 255.84,92.69 255.86,92.69 256.01,92.85 256.01,92.86 v2(256.02,92.86)
  BOTTOM w0.089: 204.2,60.97 204.06,61.11 204.06,61.28 204.11,61.33 204.11,61.62 204.53,62.04 204.53,62.34 204.77,62.59 204.77,63 205.1,63.33 UH1.M3
  BOTTOM w0.102: 204.2,60.97 204.2,60.58 203.01,59.39 v2(202.55,59.39) ; v2(201.7,55.35) 201.81,55.24 RH191.1
USB_OC5#: length 174.8
  TOP w0.102: v2(273.66,86.05) 273.76,86.05 274.16,85.65 275.84,85.65 RH9.1 ; v2(202.71,60.46) 203.01,60.17 v1(203.01,58.69) v2(203.01,58.11)
  IN2 w0.127: v2(273.66,86.05) 273.35,86.05 272.91,86.5 272.26,86.5 271.88,86.88 268.75,86.88 268.66,86.79 268.11,86.79 266.2,88.7 265.37,88.7 263.42,86.74 255.91,86.74 v2(255.27,87.38)
  IN3 w0.127: v2(255.27,87.38) 255.42,87.23 255.42,70.28 251.07,65.94 251.07,60.71 251.71,60.08 251.71,59.17 251.21,58.66 251.21,57.59 251.29,57.51 251.29,56.27 251.2,56.18 251.2,54.18 251,53.98 251,51.12 249.55,49.67 249.55,40.54 250.6,39.48 251.87,39.48 253.26,38.1 253.26,34.98 251.49,33.21 251.49,32.79 251.25,32.55 251.01,32.55 248.03,29.57 248.03,28.01 243.15,23.13 233.51,23.13 232.33,24.31 229.36,24.31 225.28,28.39 225.28,30.69 222.08,33.89 222.08,33.89 211.6,44.37 205.43,44.37 201.27,48.53 200.9,48.53 199.04,50.38 199.04,53.68 200.52,55.16 200.52,55.94 200.78,56.21 200.78,57.48 200.58,57.68 200.58,59.5 201.57,60.49 202.69,60.49 v2(202.71,60.46)
  BOTTOM w0.089: 202.61,62.56 202.67,62.62 202.67,62.81 202.81,62.95 202.81,63.5 203.18,63.87 UH1.T1
  BOTTOM w0.102: 202.61,62.56 202.12,62.06 202.12,60.74 202.37,60.48 202.7,60.48 v2(202.71,60.46) ; RPH1.4 202.63,58.11 v2(203.01,58.11)
USB_OC6#: length 128.6
  TOP w0.102: RH17.1 275.97,84.51 273.78,84.51 v2(273.67,84.62)
  IN2 w0.127: v2(232.86,69.67) 232.86,70.01 234.72,71.87 240.67,71.87 241.61,70.93 244.22,70.93 245.44,72.15 254.59,72.15 254.73,72.01 271.39,72.01 274.35,74.97 274.35,81.7 274.32,81.74 274.32,84.1 273.79,84.62 v2(273.67,84.62)
  IN3 w0.127: v2(213.04,45.85) 213.04,45.78 212.17,44.92 205.6,44.92 201.48,49.03 201.11,49.03 199.58,50.57 199.58,52.08 201.4,53.91 202.55,53.91 202.79,54.16 202.79,55.77 202.04,56.52 202.04,57.92 201.68,58.28 v2(201.68,58.47)
  BOTTOM w0.089: UH1.N2 204.51,63.2 204.15,62.84 204.15,62.59 203.37,61.8
  BOTTOM w0.102: 203.37,61.8 203.32,61.76 203.32,61.34 203.36,61.3 203.36,60.13 203.03,59.8 202.35,59.8 201.68,59.13 v2(201.68,58.47) 201.84,58.31 201.84,58.03 RPH1.3 ; v2(232.86,69.67) 232.86,68.91 230.72,66.76 230.72,56.64 227.94,53.86 227.94,51.65 v1(227.6,51.31) 225.98,49.69 219.42,49.69 216.04,46.32 213.93,46.32 213.46,45.85 v2(213.04,45.85)
USB_PWR_SHR_EN#: length 229.6
  TOP w0.102: v2(275.25,48.09) 276.14,48.09 R776.2 R806.2 ; v2(271.29,52.57) 271.86,53.14 U46.B10 ; v2(309.09,194.88) v1(309.09,195.58)
  IN2 w0.127: v2(277,54.55) 277,54.23 276.22,53.45 274.24,53.45 272.93,52.15 271.71,52.15 v2(271.29,52.57)
  IN3 w0.127: v2(309.09,194.88) 311.91,194.88 314.12,192.67 314.12,189.68 315.08,188.72 315.08,185.33 314.12,184.37 314.12,177.27 312.78,175.93 312.78,174.3 314.37,172.72 316.26,172.72 317.66,171.32 317.66,168.97 317.22,168.53 317.22,166.53 318.03,165.72 318.03,161.35 319.05,160.33 319.05,154.5 317.95,153.41 317.95,148.99 316.59,147.63 316.59,145.95 311.8,141.16 v2(310.85,141.16)
  IN4 w0.102: v2(317.48,218.83) 317.48,218.77 316.91,218.2 v2(316.91,211.39) 316.91,211.19 317,211.1 317,210.3 316.63,209.93 316.63,204.13 314.95,202.45 310.56,202.45 310.07,201.96 310.07,200.08 309.27,199.28 309.27,195.06 v2(309.09,194.88) ; v2(275.25,48.09) 276.45,49.28 276.45,54 v2(277,54.55) 278.54,54.55 281.48,57.48 281.48,65.29 279.1,67.66 279.1,91.42 283.28,95.6 283.28,97.51 283.67,97.9 283.73,97.9 287.12,101.29 289.21,101.29 290.63,102.72 299.04,102.72 302.47,106.15 303.88,106.15 310.61,112.88 310.61,140.92 v2(310.85,141.16)
  BOTTOM w0.102: v2(316.91,211.39) 316.71,211.39 316.52,211.58 Q59.2 ; R1626.1 317.98,218.07 317.48,218.57 v2(317.48,218.83)
USB_PWR_SHR_VBUS_EN: length 244.8
  TOP w0.102: U46.B50 264.12,49.14 v2(264.33,49.35) ; v2(315.82,214.12) 316.85,215.15 316.85,215.46 317.7,216.31 322.55,216.31 324.13,217.88 v2(324.13,218.57) ; R778.2 261.25,53.54 v2(261.44,53.73)
  IN1 w0.102: v2(261.44,53.73) 261.44,54.01 261.6,54.18 263.55,54.18 263.91,54.55 265.78,54.55 266.43,55.19 268.56,55.19 269.1,55.73 269.1,56.93 271.74,59.57 272.49,59.57 274.71,61.79 274.71,63.62 275.94,64.85 275.94,92.25 286.4,102.71 305.55,102.71 309.05,106.21 309.05,127.64 309.86,128.45 309.86,137.07 320.03,147.24 320.03,153.74 320.65,154.36 320.65,160.23 320.87,160.45 320.87,168.88 v2(321.23,169.24)
  IN3 w0.127: v2(308.21,193.76) 308.53,193.76 308.9,193.4 312.31,193.4 313.36,192.35 313.36,188.01 313.63,187.73 313.63,185.04 311.97,183.38 311.97,181.69 313.27,180.39 313.27,177.88 311.29,175.89 311.29,174.36 313.94,171.7 315.3,171.7 315.91,171.09 315.91,170.66 316.29,170.28 316.29,169.36 316.04,169.1 v2(316.04,168.82)
  IN4 w0.102: v2(321.23,169.24) 321.03,169.24 320.62,169.65 316.88,169.65 316.14,168.91 316.12,168.91 v2(316.04,168.82) ; v2(315.82,214.12) 316.37,213.58 316.37,211.83 316.1,211.56 316.1,209 313.83,206.73 313.83,203.64 313.09,202.91 310.32,202.91 309.24,201.83 307.92,201.83 307.03,200.94 307.03,200.28 308.52,198.79 308.52,194.07 v2(308.21,193.76)
  BOTTOM w0.102: v2(324.13,218.57) U2.1 ; v2(261.44,53.73) 260.93,53.23 260.93,52.49 261.25,52.17 v1(262.36,52.17) 262.48,52.17 263.29,51.36 263.29,49.8 263.74,49.35 v2(264.33,49.35) ; Q48.2 v2(315.82,214.12)
USB_SIDE_EN#: length 579.3
  TOP w0.102: U46.A33 262.53,56.39 262.08,56.84 262,56.84 v2(261.85,56.98) 261.73,56.98 261.36,57.35 260.51,57.35 R768.2
  IN1 w0.102: v2(347.88,197.62) 348.55,196.95 348.55,188.24 347.9,187.59 343.05,187.59 341.75,186.3 341.75,182.85 339.67,180.77 339.67,179.4 337.93,177.66 337.93,175.42 337.39,174.88 331.09,174.88 330.56,174.35 324.54,174.35 322.67,172.48 321.57,172.48 318.98,169.89 318.98,166.98 319.39,166.57 319.39,159.19 320.23,158.35 320.23,154.29 319.8,153.87 319.8,147.33 309.63,137.17 309.63,128.55 308.82,127.73 308.82,106.35 305.41,102.94 286.31,102.94 275.71,92.34 275.71,64.95 v2(273.97,63.21)
  IN2 w0.127: v2(347.88,197.62) 346.09,199.42 338.96,199.42 336.6,197.05 336.6,195.27 333.99,192.67 329.04,192.67 328.66,193.05 324.21,193.05 323.83,192.67 321.56,192.67 320.95,193.28 314.6,193.28 313.63,192.32 313.63,188.13 313.67,188.09 313.67,186.7 313.42,186.45 312.78,186.45 v2(312.15,187.08) ; v2(223.88,173.88) 223.25,174.51 214.36,174.51 214.09,174.24 206.85,174.24 206.1,173.49 204.96,173.49 204.45,172.99 201.28,172.99 200.64,172.35 199.5,172.35 197.72,170.57 195.94,170.57 195.46,170.09 193.19,170.09 192.03,171.25 185.39,171.25 184.08,169.94 183.74,169.94 180.59,166.79 180.59,165.82 180.11,165.34 178.32,165.34 178.19,165.47 177.02,165.47 176.08,164.53 174.35,164.53 169.71,159.89 164.84,159.89 163.81,160.92 157.08,160.92 154.8,158.64 136.13,158.64 133.76,161 129.27,161 127.19,158.91 123.73,158.91 123.07,158.25 121.01,158.25 120.38,158.89 117.84,158.89 115.81,156.86 108.95,156.86 108.19,157.62 102.85,157.62 102.34,158.13 100.31,158.13 98.53,159.91 93.77,159.91 93.25,159.38 91.78,159.38 90.9,160.27 90.9,160.51 90.2,161.2 88.79,161.2 86.41,163.59 86.41,165.3 82.46,169.24 59.23,169.24 46.85,181.62 46.85,182.89 41.13,188.61 32.75,188.61 v2(30.93,190.42)
  BOTTOM w0.102: v2(273.97,63.21) 272.39,61.62 264.07,61.62 262.77,60.32 v1(262.77,59.19) 262.77,57.91 v2(261.85,56.98) ; v2(312.15,187.08) 311.06,185.99 298.59,185.99 292.92,191.66 289.67,191.66 289.29,191.27 274.71,191.27 274.2,191.78 245.84,191.78 241.51,187.45 241.51,183.63 231.76,173.88 v2(223.88,173.88) ; v2(30.93,190.42) 30.42,190.93 U49.4
USBP0+: length 259.9
  IN1 w0.114: v2(315.78,183.06) 315.78,183.63 315.13,184.28 311.68,184.28 310.61,185.34 302.49,185.34 301,183.85 301,182.69 299.94,181.64 295.89,181.64 294.69,182.84 291.45,182.84 290.73,182.12 287.98,182.12 287.42,182.68 286.19,182.68 285.22,181.7 278.07,181.7 276.83,180.47 267.73,180.47 263.2,175.94 263.2,166.68 262.57,166.05 262.57,144.15 264.61,142.11 264.61,139.1 264.89,138.82 264.89,137.99 264.8,137.9 264.8,136.9 265.08,136.62 265.08,132.71 263.53,131.16 263.53,111.69 263.76,111.46 263.76,109.22 263.58,109.04 263.58,101.56 256.44,94.42 256.44,91.5 251.89,86.95 251.89,74.41 252.07,74.23 252.07,71.17 251.32,70.42 247.75,70.42 247.28,69.95 237.42,69.95 236.09,71.28 231.2,71.28 227.91,68 227.91,67.43 226.8,66.32 226.23,66.32 224.79,64.87 224.79,64.48 v2(224.6,64.29)
  IN4 w0.114: v2(320.15,217.65) 320.15,217.75 320,217.91 319.95,217.91 319.76,218.1 319.62,218.1 318.97,217.44 318.97,214.44 320.16,213.25 320.16,210.7 319.91,210.45 319.91,203 318.96,202.04 318.96,195.68 319.92,194.72 320.32,194.72 321.25,193.78 321.25,191 320.39,190.13 319.85,190.13 319.51,189.8 319.51,188.96 320.45,188.02 320.45,186.99 320.24,186.77 320.24,185 318.87,183.63 317.47,183.63 317.2,183.9 315.81,183.9 315.43,183.51 315.43,183.41 v2(315.78,183.06)
  BOTTOM w0.089: 220.08,69.49 220.07,69.5 220.07,69.51 219.89,69.68 218.56,69.68 218.32,69.92 218.07,69.92 217.88,70.12 217.88,70.52 UH1.D37
  BOTTOM w0.102: v2(224.6,64.29) 224.79,64.48 224.79,65.16 222.84,67.11 222.2,67.11 221.13,68.17 221.13,68.44 220.08,69.49 ; U2.6 320.66,217.57 320.48,217.74 320.24,217.74 v2(320.15,217.65)
USBP0-: length 259.9
  IN1 w0.114: v2(315.2,183.06) 315.55,183.41 315.55,183.53 315.04,184.05 311.58,184.05 310.52,185.11 302.59,185.11 301.23,183.75 301.23,182.59 300.04,181.41 295.8,181.41 294.59,182.61 291.55,182.61 290.83,181.89 287.89,181.89 287.33,182.45 286.28,182.45 285.31,181.48 278.16,181.48 276.93,180.24 267.83,180.24 263.43,175.84 263.43,166.59 262.8,165.95 262.8,144.25 264.84,142.2 264.84,139.19 265.12,138.91 265.12,137.9 265.03,137.81 265.03,137 265.31,136.72 265.31,132.61 263.76,131.06 263.76,111.78 263.99,111.55 263.99,109.13 263.81,108.95 263.81,101.47 256.67,94.32 256.67,91.4 252.12,86.86 252.12,74.5 252.3,74.33 252.3,71.08 251.42,70.19 247.84,70.19 247.38,69.73 237.33,69.73 236,71.06 231.29,71.06 228.14,67.9 228.14,67.33 226.89,66.09 226.32,66.09 225.01,64.78 225.01,64.17 225.08,64.11 225.2,64.11 225.43,64.34 v2(225.43,64.36)
  IN4 w0.114: v2(320.15,218.33) 319.53,218.33 318.74,217.54 318.74,214.34 319.93,213.15 319.93,210.79 319.68,210.54 319.68,203.09 318.73,202.14 318.73,195.59 319.83,194.49 320.22,194.49 321.03,193.68 321.03,191.09 320.3,190.36 319.76,190.36 319.29,189.89 319.29,188.87 320.23,187.93 320.23,187.08 320.01,186.87 320.01,185.1 318.77,183.86 317.57,183.86 317.3,184.12 315.71,184.12 315.2,183.61 v2(315.2,183.06)
  BOTTOM w0.089: UH1.B37 218.43,70.24 218.47,70.19 218.47,70.07 218.66,69.88 219.99,69.88 220.23,69.64
  BOTTOM w0.102: v2(225.43,64.36) 225.43,64.2 225.27,64.03 225.08,64.03 225,64.11 225,65.25 222.93,67.32 222.29,67.32 221.34,68.26 221.34,68.52 220.23,69.64 ; U2.7 320.41,218.07 v2(320.15,218.33)
USBP0_D+: length 5.4
  BOTTOM w0.102: R740.1 326.42,218.04 L51.4 326.42,217.25 326.1,216.93 326.1,216.74 325.84,216.49 324.87,216.49 324.64,216.73 v4(324.64,217.18) 324.64,217.44 324.51,217.57 U2.3
USBP0_D-: length 5.3
  BOTTOM w0.102: R736.1 325.57,218.04 L51.1 325.57,217.25 325.69,217.13 325.81,217.13 325.89,217.06 325.89,216.83 325.75,216.7 324.96,216.7 324.85,216.81 324.85,216.89 324.86,216.91 324.86,217.46 324.85,217.47 324.85,217.53 324.6,217.78 323.86,217.78 323.79,217.84 323.79,217.98 323.71,218.07 U2.2
USBP0_R_D+: length 15.4
  TOP w0.102: v2(325.65,222.73) 325.65,222.71 325.82,222.55 327.96,222.55 328.2,222.78 328.2,222.95 328.18,222.97 328.18,223.51 328.2,223.53 328.2,224.03 329.45,225.27 329.45,225.79 329.23,226.01 JUSB1.3
  BOTTOM w0.102: R740.2 326.42,219.12 L51.3 326.42,220.46 326.5,220.54 327.41,220.54 327.9,221.03 327.9,222.41 327.72,222.59 327.35,222.59 D72.2 326.55,222.63 326.46,222.55 325.84,222.55 v2(325.65,222.73)
USBP0_R_D-: length 15.4
  TOP w0.102: v2(325.65,222.15) 325.84,222.33 328.05,222.33 328.41,222.7 v4(328.41,223.24) 328.41,223.94 329.66,225.18 329.66,225.55 330.12,226.01 JUSB1.2
  BOTTOM w0.102: v2(325.65,222.15) 325.84,222.33 326.44,222.33 326.55,222.22 D72.3 327.47,222.38 327.63,222.38 327.69,222.33 327.69,221.12 327.32,220.75 326.41,220.75 326.21,220.55 326.21,220.43 325.57,219.79 L51.2 325.57,219.12 R736.2
USBP1+: length 263.4
  IN1 w0.114: v2(346.08,215.01) 346.08,215.11 346.2,215.23 346.26,215.23 346.43,215.39 346.66,215.39 346.82,215.23 346.82,211.79 345.49,210.46 334.23,210.46 333.13,209.36 333.13,198.75 334.34,197.54 334.34,195.03 333.47,194.17 333.47,192.44 327.07,186.04 322.47,186.04 321.44,185.01 312.03,185.01 310.96,186.09 302.22,186.09 300.27,184.15 300.27,183.11 299.55,182.38 296.52,182.38 295.33,183.58 291.17,183.58 290.43,182.84 289.65,182.84 288.99,183.5 285.72,183.5 285.06,182.84 277.85,182.84 276.41,181.41 274.25,181.41 273.88,181.77 271.85,181.77 271.48,181.41 267.49,181.41 261.45,175.37 261.45,172 261.86,171.59 261.86,167.53 261.52,167.2 261.52,143.14 262.47,142.2 262.47,133.58 262.68,133.36 262.68,120.61 261.84,119.77 261.84,117.53 262.78,116.59 262.78,112.07 262.78,111.41 263.03,111.17 263.03,109.81 262.75,109.53 262.75,102.31 251.57,91.13 251.57,90.84 249.13,88.4 249.13,76.23 245.8,72.9 237.65,72.9 236.96,73.58 229.77,73.58 225.95,69.76 225.8,69.76 224.82,68.78 224.53,68.49 222.69,68.49 222.59,68.39 222.51,68.39 v2(222.34,68.56)
  BOTTOM w0.089: UH1.C38 218.46,70.51 218.9,70.51 219.03,70.38 220.76,70.38 220.77,70.38 220.87,70.28
  BOTTOM w0.102: v2(222.34,68.56) 222.15,68.56 222.07,68.64 222.07,69.08 220.87,70.28 ; R3690.1 347.19,214.85 L107.4 346.54,215.19 346.27,215.19 v2(346.08,215.01)
USBP1-: length 263.5
  IN1 w0.114: v2(346.07,215.62) 346.76,215.62 347.05,215.33 347.05,211.7 345.59,210.24 334.33,210.24 333.36,209.26 333.36,198.84 334.56,197.64 334.56,194.94 333.7,194.08 333.7,192.35 327.17,185.81 322.56,185.81 321.53,184.78 311.94,184.78 310.86,185.86 302.31,185.86 300.5,184.05 300.5,183.01 299.65,182.16 296.43,182.16 295.23,183.35 291.26,183.35 290.53,182.61 289.56,182.61 288.9,183.27 285.82,183.27 285.16,182.61 277.94,182.61 276.51,181.18 274.16,181.18 273.79,181.55 271.94,181.55 271.57,181.18 267.58,181.18 261.68,175.27 261.68,172.09 262.09,171.68 262.09,167.44 261.75,167.1 261.75,143.24 262.7,142.29 262.7,133.67 262.91,133.46 262.91,120.51 262.07,119.68 262.07,117.62 263.01,116.68 263.01,111.98 263.01,111.51 263.25,111.26 263.25,109.72 262.97,109.44 262.97,102.22 251.8,91.04 251.8,90.74 249.36,88.31 249.36,76.13 245.9,72.67 237.56,72.67 236.87,73.35 229.87,73.35 226.05,69.54 225.9,69.54 224.92,68.55 224.62,68.26 223.03,68.26 v2(222.79,68.03)
  BOTTOM w0.089: 220.72,70.13 220.67,70.18 220.03,70.18 219.95,70.1 219.82,70.1 219.74,70.18 219.57,70.18 219.49,70.1 219.35,70.1 219.27,70.18 219.14,70.18 219.08,70.12 218.85,70.12 UH1.A38
  BOTTOM w0.102: v2(346.07,215.62) 346.29,215.4 346.59,215.4 L107.1 347.19,215.7 R3689.1 ; v2(222.79,68.03) 222.29,68.03 221.86,68.46 221.86,68.99 220.72,70.13
USBP1_D+: length 16.8
  TOP w0.102: v2(354.58,214.81) 354.52,214.87 354.05,214.87 353.63,215.29 v4(353.63,217.16) 353.63,217.4 354.3,218.07 354.66,218.07 356.71,220.12 356.87,220.12 357.21,220.46 JUSB2.3
  BOTTOM w0.102: v2(354.58,214.81) 354.36,215.03 353.43,215.03 D89.3 352.59,214.85 352.43,215 351.94,215 351.03,215.9 350.01,215.9 349.28,215.17 348.9,215.17 L107.3 348.5,214.77 R3690.2
USBP1_D-: length 16.8
  TOP w0.102: JUSB2.2 357.21,219.75 357.04,219.91 356.8,219.91 354.74,217.86 354.38,217.86 353.86,217.33 353.86,216.88 353.84,216.87 353.84,215.38 354.14,215.08 354.28,215.08 354.55,215.36 v2(354.55,215.46)
  BOTTOM w0.102: R3689.2 348.5,215.79 L107.2 348.9,215.38 349.19,215.38 349.93,216.12 351.12,216.12 352.03,215.21 352.26,215.21 352.59,215.53 D89.2 353.46,215.24 354.34,215.24 v2(354.55,215.46)
USBP2+: length 257.6
  IN1 w0.114: v2(223.49,63.7) 223.98,63.7 224.31,63.37 225.52,63.37 226.63,64.48 226.63,64.76 228.89,67.02 228.89,67.63 231.59,70.33 234.76,70.33 236.09,69 247.86,69 248.27,69.42 251.67,69.42 253.02,70.77 253.02,74.63 252.85,74.8 252.85,86.56 257.39,91.1 257.39,92.91 264.55,100.07 264.55,104.5 264.79,104.74 264.79,111.78 264.52,112.04 264.52,130.76 265.23,131.47 265.24,131.47 266.04,132.27 266.04,136.37 266.23,136.56 266.23,138.9 265.63,139.5 265.63,142.47 263.52,144.58 263.52,165.4 264.16,166.03 264.16,173.82 266.16,175.83 266.16,176.58 269.06,179.48 277.29,179.48 278.56,180.75 291.75,180.75 292.84,181.84 294.12,181.84 295.44,180.52 300.19,180.52 301.95,182.28 301.95,183.35 302.99,184.39 310.17,184.39 311.53,183.03 311.53,182.51 312.67,181.36 312.67,178.9 315,176.57 319.93,176.57 322.51,179.15 323.52,179.15 323.95,179.58 326.98,179.58 327.66,178.9 328.28,178.9 v2(328.29,178.92)
  BOTTOM w0.089: 219.59,69 219.55,69.03 218.36,69.03 217.88,69.51 217.88,69.79 217.56,70.11 UH1.C36
  BOTTOM w0.102: v2(328.29,178.92) 329.62,178.92 330.59,179.89 335.6,179.89 336.75,181.04 340.86,181.04 342.04,182.22 344.42,182.22 344.84,182.64 347.07,182.64 349.78,185.34 349.78,185.96 349.82,186 349.82,186.02 350.04,186.24 L110.4 350.04,187.05 R3710.1 ; 219.59,69 220.41,68.18 220.41,67.91 222.88,65.44 222.88,65.44 223.36,64.96 223.36,64.08 223.49,63.95 v2(223.49,63.7)
USBP2-: length 257.5
  IN1 w0.114: v2(224,64.35) 224,64.35 224,64.01 224.4,63.6 225.43,63.6 226.4,64.57 226.4,64.85 228.66,67.11 228.66,67.72 231.5,70.56 234.86,70.56 236.19,69.23 247.76,69.23 248.18,69.65 251.58,69.65 252.8,70.87 252.8,74.53 252.62,74.71 252.62,86.65 257.16,91.2 257.16,93.01 264.32,100.16 264.32,104.59 264.56,104.83 264.56,111.68 264.3,111.95 264.3,130.85 265.14,131.7 265.81,132.36 265.81,136.47 266,136.66 266,138.81 265.4,139.4 265.4,142.37 263.29,144.48 263.29,165.49 263.93,166.13 263.93,173.91 265.93,175.92 265.93,176.68 268.96,179.7 277.19,179.7 278.47,180.98 291.66,180.98 292.74,182.07 294.22,182.07 295.54,180.75 300.1,180.75 301.72,182.37 301.72,183.45 302.89,184.62 310.26,184.62 311.76,183.13 311.76,182.6 312.9,181.46 312.9,178.99 315.1,176.8 319.83,176.8 322.41,179.37 323.42,179.37 323.85,179.81 327.08,179.81 327.75,179.13 327.92,179.13 v2(328.29,179.5)
  BOTTOM w0.089: 219.74,69.15 219.56,69.33 219.44,69.33 219.35,69.24 219.23,69.24 219.15,69.33 219.02,69.33 218.93,69.24 218.85,69.24 218.75,69.34 218.64,69.34 218.54,69.24 218.46,69.24 218.41,69.29 218.41,69.38 218.38,69.41 218.26,69.41 218.2,69.48 218.2,69.62 UH1.A36
  BOTTOM w0.102: v2(224,64.35) 224,64.35 224.11,64.24 224.11,64.05 223.97,63.91 223.86,63.91 223.66,64.11 223.57,64.19 223.57,65.05 223.09,65.52 220.62,68 220.62,68.27 219.74,69.15 ; v2(328.29,179.5) 328.66,179.13 329.53,179.13 330.5,180.1 335.51,180.1 336.66,181.25 340.77,181.25 341.95,182.43 344.33,182.43 344.75,182.85 346.99,182.85 349.57,185.43 349.57,185.73 349.19,186.11 L110.1 349.19,187.05 R3711.1
USBP2_D+: length 19
  IN4 w0.114: JUSB3.3 357.21,196.76 357.09,196.65 356.18,196.65 355.19,195.66 355.19,194.63 354.3,193.74 351.27,193.74 350.46,192.93 350.46,191.33 350.78,191.01 v2(351.57,191.01)
  BOTTOM w0.102: R3710.2 350.04,188.13 L110.3 350.04,188.75 349.77,189.03 349.77,189.36 349.53,189.59 349.53,191.11 349.87,191.45 350.44,191.45 350.6,191.29 D90.2 351.07,190.44 351.57,190.93 v2(351.57,191.01)
USBP2_D-: length 19
  IN4 w0.114: JUSB3.2 357.21,196.33 357.12,196.42 356.27,196.42 355.42,195.56 355.42,194.53 354.4,193.51 351.37,193.51 350.69,192.84 350.69,191.42 350.88,191.24 351.21,191.24 351.56,191.58 v2(351.56,191.74)
  BOTTOM w0.102: v2(351.56,191.74) 351.56,191.81 351,192.37 D90.3 350.6,191.95 350.32,191.66 349.79,191.66 349.32,191.2 349.32,189.5 349.56,189.27 349.56,189.06 349.19,188.69 L110.2 349.19,188.13 R3711.2
USBP3+: length 251.7
  IN1 w0.114: v2(266.09,171.23) 265.81,171.51 265.69,171.51 265.6,171.43 265.6,165.09 264.99,164.48 264.99,145.19 267.36,142.82 267.36,139.94 267.76,139.53 267.76,136 267.5,135.74 267.5,129.17 265.98,127.66 265.98,112.67 266.38,112.27 266.38,110.11 266.77,109.72 266.77,100.24 259.85,93.31 259.85,91.04 254.4,85.59 254.4,84.84 254.4,75.34 254.5,75.23 254.5,70.18 251.85,67.52 235.3,67.52 234.71,68.11 231.52,68.11 230.48,67.06 230.48,66.45 229,64.97 229,63.35 227.2,61.54 224.33,61.54 224.19,61.4 224.19,61.3 v2(224.39,61.1)
  IN2 w0.127: v2(266.09,171.23) 265.37,171.23 263.73,172.87 261.51,172.87 260.73,173.66 256.55,173.66 255.97,173.08 247.36,173.08 246.05,174.38 240.17,174.38 239.06,173.28 236.1,173.28 235.44,172.62 235.44,171.89 234.92,171.37 234.22,171.37 233.96,171.64 233.96,172.16 v2(233.9,172.21)
  BOTTOM w0.089: UH1.C34 217.33,69.34 217.78,69.34 218.26,68.85 218.82,68.85 219.06,68.61 219.08,68.61 219.14,68.55
  BOTTOM w0.102: JDOCK1.72 185.75,187.99 185.9,187.85 185.96,187.85 186.72,187.09 186.72,186.36 186.72,186.19 187.65,185.25 189.72,183.19 189.98,183.19 190.11,183.06 190.13,183.06 190.4,182.78 193.34,182.78 193.61,183.06 202.8,183.06 202.99,182.87 203.93,182.87 205.66,181.13 205.66,180.13 212.84,172.95 220.27,172.95 220.65,172.56 232.3,172.56 232.57,172.83 233.82,172.83 233.9,172.74 v2(233.9,172.21) ; 219.14,68.55 219.59,68.1 219.59,68.04 221.87,65.77 222.88,64.76 222.88,64.59 222.88,64.59 222.88,63.67 224.58,61.96 224.58,61.29 v2(224.39,61.1)
USBP3-: length 251.7
  IN1 w0.114: v2(266.09,171.93) 265.9,171.74 265.59,171.74 265.37,171.53 265.37,165.18 264.77,164.57 264.77,145.09 267.13,142.73 267.13,139.85 267.53,139.44 267.53,136.1 267.27,135.83 267.27,129.27 265.76,127.75 265.76,112.57 266.15,112.18 266.15,110.02 266.54,109.63 266.54,100.33 259.62,93.41 259.62,91.14 254.17,85.69 254.17,84.75 254.17,75.24 254.28,75.14 254.28,70.27 251.75,67.75 235.39,67.75 234.81,68.34 231.43,68.34 230.25,67.16 230.25,66.54 228.77,65.07 228.77,63.44 227.1,61.77 224.23,61.77 224.12,61.66 v2(223.78,61.66)
  IN2 w0.127: v2(266.09,171.93) 266.09,171.75 265.97,171.64 265.89,171.64 265.74,171.49 265.48,171.49 263.84,173.13 261.62,173.13 260.83,173.91 256.45,173.91 255.86,173.33 247.46,173.33 246.15,174.64 240.06,174.64 238.96,173.53 236,173.53 235.19,172.72 235.19,172 234.81,171.63 234.33,171.63 234.21,171.75 234.21,171.92 234.49,172.2 v2(234.49,172.21)
  BOTTOM w0.089: 218.99,68.4 218.74,68.65 218.18,68.65 217.98,68.85 217.92,68.85 217.83,68.76 217.74,68.76 217.63,68.87 UH1.A34
  BOTTOM w0.102: 218.99,68.4 219.38,68.01 219.38,67.96 221.78,65.55 222.66,64.67 222.66,63.58 224.37,61.87 224.37,61.57 224.29,61.49 224.2,61.49 223.83,61.12 223.71,61.12 223.57,61.26 223.57,61.44 v2(223.78,61.66) ; JDOCK1.74 186.25,187.86 186.93,187.18 186.93,186.28 189.8,183.4 190.07,183.4 190.2,183.27 190.22,183.27 190.49,182.99 193.25,182.99 193.53,183.27 202.89,183.27 203.08,183.08 204.01,183.08 205.88,181.22 205.88,180.21 212.93,173.16 220.35,173.16 220.74,172.77 232.22,172.77 232.48,173.04 233.9,173.04 234.12,172.83 234.12,172.59 v2(234.49,172.21)
USBP4+: length 165.3
  IN1 w0.114: v2(221.4,64.34) 220.98,63.91 220.98,63.58 221.42,63.14 221.91,62.65 226.34,62.65 227.44,63.75 227.44,64.49 229.71,66.76 229.71,67.33 231.26,68.87 235.09,68.87 235.72,68.25 251.54,68.25 253.75,70.45 253.75,74.93 253.57,75.1 253.57,86.26 258.12,90.8 258.12,92.61 265.98,100.48 265.98,109.04 265.53,109.49 265.53,112.06 265.26,112.33 265.26,130.28 266.76,131.78 266.76,136.04 266.95,136.23 266.95,139.27 266.53,139.69 266.53,142.61 264.27,144.87 264.27,164.94 264.88,165.55 264.88,173.21 266.97,175.3 266.97,175.3 267.59,175.93 267.78,175.93 268.07,176.21 v2(268.07,176.78)
  BOTTOM w0.089: UH1.D33 216.72,69.37 216.72,68.97 216.91,68.78 217.18,68.78 217.6,68.36 217.8,68.36 218.15,68.01 218.41,68.01 218.5,67.91
  BOTTOM w0.102: JMINI2.38 269.05,178 268.76,177.71 268.76,177.56 268.48,177.28 267.91,177.28 267.74,177.11 267.74,177 267.96,176.78 v2(268.07,176.78) ; 218.5,67.91 218.69,67.73 218.69,67.67 221.5,64.86 221.5,64.43 v2(221.4,64.34)
USBP4-: length 165.9
  TOP w0.102: v1(221.72,63.39) 221.83,63.49 v2(221.83,63.94)
  IN1 w0.114: v2(221.83,63.94) 221.82,63.92 221.32,63.92 221.2,63.81 221.2,63.68 222,62.88 226.25,62.88 227.21,63.84 227.21,64.59 229.48,66.86 229.48,67.42 231.16,69.1 235.19,69.1 235.81,68.48 251.45,68.48 253.52,70.55 253.52,74.83 253.34,75.01 253.34,86.35 257.89,90.9 257.89,92.71 265.76,100.58 265.76,108.94 265.3,109.4 265.3,111.97 265.03,112.23 265.03,130.38 266.53,131.88 266.53,136.14 266.72,136.33 266.72,139.17 266.3,139.59 266.3,142.51 264.04,144.77 264.04,165.04 264.65,165.65 264.65,173.3 266.74,175.39 266.74,175.4 267.5,176.16 267.69,176.16 267.84,176.31 267.84,176.41 267.65,176.59 267.65,176.85 267.52,176.99 267.42,176.99 v2(267.19,176.76)
  BOTTOM w0.089: 218.65,68.06 218.64,68.07 218.63,68.07 218.59,68.12 218.58,68.12 218.49,68.21 218.23,68.21 217.88,68.56 217.68,68.56 217.15,69.09 UH1.B33
  BOTTOM w0.102: JMINI2.36 268.25,178 268.54,177.71 268.54,177.65 268.39,177.49 267.82,177.49 267.53,177.19 267.53,176.98 267.31,176.76 v2(267.19,176.76) ; v2(221.83,63.94) 221.99,63.94 222.17,64.12 222.17,64.3 221.99,64.48 221.84,64.48 221.71,64.61 221.71,64.95 218.9,67.76 218.9,67.81 218.65,68.06
USBP5+: length 235.3
  IN1 w0.089: 221.87,71.28 221.49,71.28 220.23,70.02 218.52,70.02 217.77,69.27 215.82,69.27 215.14,69.94 v2(215.14,70.48)
  IN1 w0.114: 221.87,71.28 223.33,71.28 224.52,72.47 225.13,72.47 230.08,77.41 230.08,78.22 236.83,84.98 242.82,84.98 261.49,103.64 261.49,107.47 261.06,107.9 261.06,111.58 261.43,111.95 261.43,112.85 260.54,113.73 260.54,120.19 261.36,121.01 261.36,132.28 260.27,133.37 260.27,144.77 259.93,145.12 259.93,153.34 260.14,153.56 260.14,173.57 260.59,174.02 260.59,175.27 267.24,181.93 271.15,181.93 271.49,182.27 274.14,182.27 274.49,181.93 276.11,181.93 277.62,183.43 284.95,183.43 285.55,184.03 287.97,184.03 288.04,184.1 299.37,184.1 301.93,186.66 311.28,186.66 312.42,185.52 319.3,185.52 320.3,186.51 320.3,186.52 320.85,187.08 326.6,187.08 327.92,188.4 327.92,189.92 329.94,191.93 331.55,191.93 332.34,192.72 332.34,194.96 332.96,195.58 v2(333.48,195.58)
  BOTTOM w0.089: UH1.G31 215.14,70.14 v2(215.14,70.48)
  BOTTOM w0.102: v2(333.48,195.58) 333.74,195.83 333.93,195.83 334.14,196.03 334.14,196.28 334.7,196.85 336.89,196.85 340.2,200.16 342.59,200.16 343.95,201.52 343.95,201.66 343.95,201.66 343.95,201.76 344.15,201.96 JMINI1.38
USBP5-: length 235.3
  IN1 w0.089: 221.87,71.51 221.86,71.51 221.85,71.49 221.78,71.49 221.77,71.48 221.41,71.48 220.15,70.22 218.44,70.22 217.69,69.47 215.9,69.47 215.56,69.81 v2(215.56,70.06)
  IN1 w0.114: 221.87,71.51 223.24,71.51 224.42,72.69 225.03,72.69 229.85,77.51 229.85,78.32 236.73,85.2 242.73,85.2 261.26,103.74 261.26,107.37 260.83,107.8 260.83,111.68 261.2,112.04 261.2,112.75 260.31,113.64 260.31,120.28 261.13,121.11 261.13,132.18 260.04,133.27 260.04,144.68 259.7,145.02 259.7,153.43 259.91,153.65 259.91,173.67 260.36,174.11 260.36,175.37 267.15,182.16 271.05,182.16 271.39,182.5 274.24,182.5 274.58,182.16 276.02,182.16 277.52,183.66 284.86,183.66 285.45,184.26 287.88,184.26 287.95,184.33 299.28,184.33 301.84,186.89 311.37,186.89 312.51,185.75 319.21,185.75 320.07,186.61 320.07,186.62 320.76,187.31 326.51,187.31 327.69,188.5 327.69,190.01 329.85,192.16 331.46,192.16 332.11,192.82 332.11,195.05 332.87,195.8 333.13,195.8 333.32,196 333.6,196 333.74,196.14 333.74,196.27 333.57,196.43 v2(333.48,196.43)
  BOTTOM w0.089: 215.39,69.54 215.56,69.71 v2(215.56,70.06)
  BOTTOM w0.102: v2(333.48,196.43) 333.48,196.28 333.73,196.04 333.85,196.04 333.93,196.12 333.93,196.37 334.62,197.06 336.8,197.06 340.12,200.38 342.5,200.38 343.74,201.61 343.74,201.75 343.64,201.84 343.45,201.84 343.35,201.95 JMINI1.36
USBP6+: length 226
  TOP w0.102: R1672.2 187.03,184.49 187.03,183.9 187.26,183.67 187.26,183.39 187.43,183.22 188.08,183.22 188.77,183.91 190.57,183.91 191.21,183.26 192.1,183.26 195.38,179.99 195.38,178.96 196.31,178.02 202.58,178.02 202.7,177.91 v2(213.38,177.91)
  IN1 w0.089: v2(214.32,71.31) 214.88,71.31 214.94,71.25 215.19,71.25 216.28,70.16 216.28,70.1 216.48,69.9 216.85,69.9
  IN1 w0.114: v2(262.39,181.32) 262.48,181.23 262.48,180.09 259.62,177.23 259.62,174.4 259.16,173.94 259.16,159.45 258.97,159.26 258.97,144.46 259.29,144.15 259.29,132.87 259.58,132.57 259.58,129.79 260.4,128.98 260.4,127.28 259.58,126.47 259.58,111.33 260.04,110.87 260.04,103.88 242.1,85.94 236.45,85.94 229.12,78.62 229.12,77.88 224.72,73.48 224.08,73.48 222.95,72.35 220.72,72.35 219.45,71.08 218.29,71.08 217.11,69.9 216.85,69.9
  IN2 w0.127: v2(213.38,177.91) 213.38,178.08 213.48,178.18 213.61,178.18 213.69,178.26 213.92,178.26 214.29,177.89 224.57,177.89 225.29,177.17 225.74,177.17 225.74,177.16 234.94,177.16 234.95,177.17 235.23,177.17 237.89,179.83 245.42,179.83 246.24,179.02 253.34,179.02 253.55,179.02 253.92,179.39 258.86,179.39 260.91,181.44 261.75,181.44 262.16,181.85 262.72,181.85 262.83,181.73 262.83,181.61 262.72,181.5 262.72,181.42 262.62,181.32 v2(262.39,181.32)
  BOTTOM w0.089: UH1.L31 214.25,71.23 214.32,71.3 v2(214.32,71.31)
USBP6-: length 226
  TOP w0.102: R1673.2 187.83,184.49 187.83,183.98 187.47,183.61 187.47,183.48 187.52,183.43 187.99,183.43 188.69,184.12 190.65,184.12 191.3,183.47 192.19,183.47 195.59,180.07 195.59,179.04 196.4,178.23 202.67,178.23 202.78,178.12 213.02,178.12 213.41,178.51 v2(213.41,178.61)
  IN1 w0.089: v2(214.75,70.92) 214.88,71.04 215.11,71.04 216.07,70.08 216.07,70.01 216.39,69.7 216.75,69.7 216.76,69.68 216.82,69.68 216.84,69.67 216.85,69.67
  IN1 w0.114: 216.85,69.67 217.2,69.67 218.38,70.85 219.54,70.85 220.81,72.12 223.05,72.12 224.18,73.25 224.82,73.25 229.35,77.79 229.35,78.52 236.54,85.71 242.2,85.71 260.27,103.78 260.27,110.97 259.81,111.42 259.81,126.38 260.63,127.19 260.63,129.07 259.81,129.88 259.81,132.66 259.51,132.96 259.51,144.25 259.2,144.56 259.2,159.16 259.39,159.35 259.39,173.85 259.85,174.31 259.85,177.13 262.71,179.99 262.71,180.84 v2(263.09,181.22)
  IN2 w0.127: v2(213.41,178.61) 213.5,178.51 214.03,178.51 214.4,178.14 224.68,178.14 225.4,177.42 225.84,177.42 225.85,177.42 234.84,177.42 234.84,177.42 235.12,177.42 237.79,180.09 245.53,180.09 246.34,179.27 253.34,179.27 253.45,179.27 253.81,179.64 258.75,179.64 260.81,181.69 261.64,181.69 262.06,182.11 262.82,182.11 263.09,181.84 v2(263.09,181.22)
  BOTTOM w0.089: v2(214.75,70.92) 214.73,70.92 214.71,70.9 214.7,70.9 214.65,70.85 214.17,70.85 UH1.K31
USBP6_R_D+: length 6.7
  TOP w0.102: R1672.1 187.03,185.62 187.03,186.28 187.33,186.57 187.33,186.71 186.96,187.08 186.69,187.08 186.67,187.07 186.12,187.07 186.1,187.08 185.9,187.08 185.62,186.8 184.65,186.8 184.4,187.05 184.4,187.33 v2(184.2,187.54)
  BOTTOM w0.102: JDOCK1.66 184.25,187.95 184.39,187.81 184.39,187.69 184.23,187.54 v2(184.2,187.54)
USBP6_R_D-: length 6.7
  TOP w0.102: v2(184.78,187.54) 184.78,187.53 184.62,187.36 184.62,187.14 184.74,187.01 185.53,187.01 185.81,187.29 v4(186.39,187.29) 187.05,187.29 187.54,186.8 187.54,186.53 187.83,186.24 187.83,185.62 R1673.1
  BOTTOM w0.102: JDOCK1.68 184.75,187.97 184.6,187.81 184.6,187.68 184.74,187.54 v2(184.78,187.54)
USBP7+: length 60.8
  TOP w0.102: JUSH1.18 263.16,80.57 263.1,80.51 259.8,80.51 258.89,79.59 258.89,75.48 256.66,73.25 255.24,73.25 255.22,73.27 254.67,73.27 254.66,73.25 247.63,73.25 244.95,70.57 233.1,70.57 231.47,72.2 230.52,72.2 228.99,73.73 228.99,73.73 228.49,74.23 228.18,74.23 v2(228.05,74.36)
  IN1 w0.089: v2(214.45,69.78) 214.98,69.78 215.72,69.05
  IN1 w0.109: 219.64,69.05 218.96,69.05 218.95,69.05
  IN1 w0.114: 219.64,69.05 220.53,69.05 221.71,70.23 223.49,70.23 224.8,71.54 224.9,71.54 227.63,74.27 227.96,74.27 v2(228.05,74.36) ; 215.72,69.05 218.95,69.05
  BOTTOM w0.089: v2(214.45,69.78) 214.36,69.69 UH1.H29
USBP7-: length 60.6
  TOP w0.102: v2(228.05,73.77) 228.05,73.79 228.28,74.02 228.4,74.02 228.78,73.64 228.78,73.64 230.43,71.99 231.38,71.99 233.01,70.36 245.04,70.36 247.72,73.04 v4(254.95,73.04) 256.75,73.04 259.1,75.39 259.1,79.5 259.89,80.29 262.93,80.29 263.16,80.07 JUSH1.19
  IN1 w0.089: v2(214.91,69.32) 214.97,69.38 215.1,69.38 215.5,68.98 215.5,68.96 215.63,68.84 215.72,68.84 215.73,68.83 215.72,68.83
  IN1 w0.109: 215.72,68.83 215.69,68.83 215.69,68.82 215.72,68.82
  IN1 w0.114: v2(228.05,73.77) 228.05,73.78 227.79,74.04 227.73,74.04 225,71.31 224.89,71.31 223.59,70 221.82,70 220.64,68.82 220.63,68.82 220.63,68.82 219.55,68.82 219.54,68.82 215.72,68.82
  BOTTOM w0.089: v2(214.91,69.32) 214.86,69.27 UH1.G29
USBP8+: length 218.1
  IN1 w0.089: v2(218.06,67.6) 217.75,67.6 217.7,67.55 217.7,67.11
  IN1 w0.114: v2(312.26,178.33) 311.83,178.77 311.83,179.07 312.15,179.39 312.15,181.17 310.76,182.56 308.19,182.56 306.97,183.77 303.27,183.77 302.6,183.1 302.6,182.21 299.98,179.59 280.69,179.59 280.59,179.49 278.23,179.49 277.69,178.96 271.82,178.96 267.55,174.69 267.11,174.69 266.63,174.21 266.63,170.44 266.11,169.92 266.11,165.73 266.99,164.85 266.99,157.57 266.33,156.91 266.33,154.87 267.18,154.02 267.18,150.95 266.26,150.04 266.26,144.65 267.93,142.98 267.93,140.18 268.26,139.85 268.26,135.66 267.99,135.39 267.99,128.75 267.34,128.1 267.34,100.09 260.35,93.09 260.35,90.84 255.41,85.9 255.41,74.55 255.01,74.15 255.01,69.94 252.1,67.03 234.97,67.03 234.42,67.58 231.69,67.58 231,66.88 231,66.13 229.88,65.01 229.88,63.22 227.24,60.58 224.12,60.58 222.61,62.09 221.69,62.09 220.38,63.4 220.38,64.32 219.61,65.09 219.27,65.09 217.7,66.66 217.7,67.11
  BOTTOM w0.089: UH1.C32 216.41,68.99 216.75,68.66 216.75,68.34 217.02,68.06 217.02,68.03 217.45,67.6 v2(218.06,67.6)
  BOTTOM w0.102: JMINI3.38 312.26,178.34 v2(312.26,178.33)
USBP8-: length 218.1
  IN1 w0.114: v2(311.45,178.32) 311.6,178.47 311.6,179.16 311.92,179.48 311.92,181.07 310.66,182.33 308.09,182.33 306.88,183.54 303.37,183.54 302.83,183 302.83,182.11 300.08,179.36 280.79,179.36 280.68,179.26 278.32,179.26 277.79,178.73 271.92,178.73 267.65,174.46 267.21,174.46 266.86,174.11 266.86,170.34 266.34,169.82 266.34,165.82 267.22,164.95 267.22,157.48 266.56,156.82 266.56,154.97 267.41,154.11 267.41,150.86 266.49,149.94 266.49,144.74 268.16,143.08 268.16,140.28 268.49,139.95 268.49,135.57 268.22,135.3 268.22,128.66 267.57,128.01 267.57,99.99 260.57,93 260.57,90.74 255.64,85.81 255.64,74.45 255.24,74.05 255.24,69.85 252.19,66.8 234.88,66.8 234.33,67.35 231.78,67.35 231.22,66.79 231.22,66.03 230.11,64.92 230.11,63.13 227.33,60.35 224.02,60.35 222.51,61.86 221.6,61.86 220.15,63.31 220.15,64.22 219.51,64.86 219.18,64.86 217.47,66.57 217.47,67.84 v2(217.61,67.98)
  BOTTOM w0.089: v2(217.61,67.98) 217.58,67.95 217.37,67.95 217.21,68.12 217.21,68.16 217.34,68.29 217.34,68.37 217.24,68.47 UH1.A32
  BOTTOM w0.102: JMINI3.36 311.46,177.61 311.58,177.72 312,177.72 312.05,177.77 312.05,177.95 311.86,178.14 311.86,178.5 311.74,178.61 311.51,178.61 311.45,178.55 v2(311.45,178.32)
