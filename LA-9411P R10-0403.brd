# Allegro board LA-9411P R10-0403.brd (continued)
## Nets (continued)
WLAN_LED: JLED2.5 R3671.2
WLAN_LED#: JMINI2.44 Q124.1 R718.1
WLAN_RADIO_DIS#: D31.1 R693.1 U46.A48
WLAN_RADIO_DIS#_R: D31.2 JMINI2.20 R693.2 R728.1
WWAN_RADIO_DIS#: JMINI1.20 R774.2 U46.A53
XDP_DBRESET#: JXDP1.48 JXDP2.48 RC35.1 RC52.2 RH66.1 UC3.1
XDP_DBRESET#_R: JCPU1.AP33 RC35.2
XDP_FN0: JXDP2.9 RH3.2
XDP_FN1: JXDP2.11 RH4.2
XDP_FN2: JXDP2.15 RH6.2
XDP_FN3: JXDP2.17 RH7.2
XDP_FN4: JXDP2.27 RH8.2
XDP_FN5: JXDP2.29 RH9.2
XDP_FN6: JXDP2.33 RH17.2
XDP_FN7: JXDP2.35 RH10.2
XDP_FN8: JXDP2.10 RH11.2
XDP_FN9: JXDP2.12 RH13.2
XDP_FN10: JXDP2.16 RH12.2
XDP_FN11: JXDP2.18 RH14.2
XDP_FN12: JXDP2.28 RH16.2
XDP_FN13: JXDP2.30 RH19.2
XDP_FN14: JXDP2.34 RH20.2
XDP_FN15: JXDP2.36 RH22.2
XDP_FN16: JXDP2.4 RH24.2
XDP_FN17: JXDP2.6 RH25.2
XDP_OBS0: JXDP1.21 RC36.2
XDP_OBS0_R: JCPU1.AR30 RC36.1
XDP_OBS1: JXDP1.23 RC37.2
XDP_OBS1_R: JCPU1.AN31 RC37.1
XDP_OBS2_R: JCPU1.AN29 T21.1(TP-1)
XDP_OBS3_R: JCPU1.AP31 T37.1(TP-1)
XDP_OBS4_R: JCPU1.AP30 T38.1(TP-1)
XDP_OBS5_R: JCPU1.AN28 T47.1(TP-1)
XDP_OBS6_R: JCPU1.AP29 T72.1(TP-1)
XDP_OBS7_R: JCPU1.AP28 T88.1(TP-1)
XDP_PRDY#: JCPU1.AR29 JXDP1.5
XDP_PREQ#: JCPU1.AT29 JXDP1.3 RC55.2
XDP_RST#_R: JXDP1.46 RC23.2
XDP_TCLK: JCPU1.AM34 JXDP1.57 RC59.2
XDP_TDI: JXDP1.56 RC32.2 RC54.2
XDP_TDI_R: JCPU1.AM31 RC32.1
XDP_TDO: JXDP1.52 RC34.2 RC57.2
XDP_TDO_R: JCPU1.AL33 RC34.1
XDP_TMS: JCPU1.AN33 JXDP1.58 RC53.2
XDP_TRST#: JCPU1.AM33 JXDP1.54 RC62.2
XTAL25_IN: RH152.2 UH1.AM43
XTAL25_IN_R: CH14.2 RH152.1 RH153.2 YH2.1
XTAL25_OUT: CH13.2 RH153.1 UH1.AL44 YH2.3
XTALI: C471.2 U31.10 Y3.3
XTALIN: CV95.1 RV100.1 UV1.AV33 YV1.1
XTALO: R1144.2 U31.9
XTALOUT: CV94.1 RV100.2 RV125.1 YV1.3
XTALOUT_R: RV125.2 UV1.AU34
Z2805: R574.1 T156.22
Z2806: R573.1 T156.16
Z2807: R572.1 T156.21
Z2808: R571.1 T156.15
Z4012: PD3.2 PR1.2
Z4304: PBATT1.7 PD2.2 PR7.1
Z4305: PBATT1.6 PD2.3 PR8.1
Z4306: PBATT1.5 PD4.2 PR9.1
Z5304: MBATT1.2 PD1.1 PR4.1
Z5305: MBATT1.3 PD1.3 PR3.1
Z5306: MBATT1.4 PD1.4 PR5.1
ZODD_WAKE#: Q76.1 R510.2 U46.A59
N115227: PC8.1 PQ4.4 PQ6.4 PR18.2 PR23.1 PR25.1
N115634: PQ6.1 PQ6.2
N388738: PC612.2 PC624.1 PC678.1 PR640.2 PR646.2 PR650.2 PU600.12
N388758: PC630.2 PC678.2 PR657.2 PR658.2 PU600.13
N392231: PD701.1 PR708.2 PR742.1
N513876: PR718.1 PU700.13
N513898: PC721.2 PC722.1 PR716.3 PR718.2
N514008: PR719.1 PU700.12
N514014: PC722.2 PC723.1 PR716.2 PR719.2
N743839: PR631.2 PR691.1 PU600.2
N841021: PQ610.1 PR692.2 PR693.1 PR696.1 PR697.2
N16790095: T59.1(TP-1) UH1.C26
N16807572: T58.1(TP-1) UH1.BB2
N16845401: T65.1(TP-1) UH1.AW17
N16845569: T67.1(TP-1) UH1.AV17
N16857314: T57.1(TP-1) UH1.BA2
N16858942: T75.1(TP-1) UH1.AB10
N16863974: T62.1(TP-1) UH1.AV43
N16864660: T63.1(TP-1) UH1.AY45
N16864959: T60.1(TP-1) UH1.AV45
N16865260: T61.1(TP-1) UH1.AW44
N16869408: T64.1(TP-1) UH1.AU42
N16869720: T66.1(TP-1) UH1.AU44
N16949390: T71.1(TP-1) UH1.AD10
N16994246: PC709.1 PD702.1 PR715.2
N17068457: T76.1(TP-1) UH1.AD39
N17068936: T77.1(TP-1) UH1.AD38
N17103600: T78.1(TP-1) UH1.BA45
N17104124: T79.1(TP-1) UH1.BC45
N17104650: T80.1(TP-1) UH1.BE43
N17105178: T81.1(TP-1) UH1.BE44
N17139830: T82.1(TP-1) UH1.M33
N17139840: T83.1(TP-1) UH1.L33
N17164171: T84.1(TP-1) UH1.BC30
N17164181: T85.1(TP-1) UH1.BB29
N17205976: JDEG2.1 R864.2
N17220570: RH195.2 UH1.AT8
N17404646: C713.1 R795.2
N17405164: C712.1 R794.2
N17860472: RV108.2 UV4.J13
N18000518: JMINI2.22 R703.2
N18000576: JMINI2.49 R707.2
N18386761: RV118.2 UV3.J13
N18493434: JCPU1.AC7 T2.1(TP-1)
N18642139: Q75.1 R934.1
N18703943: JCPU1.AG8 T3.1(TP-1)
N18894456: PH500.2 PR525.2 PR528.2
N18894554: PC542.1 PR550.1
N18894680: PC543.2 PR554.1
N18894698: PC511.1 PR526.1 PU500.17
N18894707: PR507.2 PU500.28
N18894708: PR512.2 PU500.30
N18894710: PR509.2 PU500.29
N18894766: PC520.2 PR533.1
N18894768: PC519.1 PR532.2
N18894769: PC520.1 PR537.1 PR540.1
N18894780: PC527.2 PR543.1
N18894784: PC526.2 PR539.1
N18894855: PC521.1 PR535.1 PU500.14
N18894856: PC521.2 PR545.2
N18894871: PH501.2 PR551.1
N18894872: PC529.1 PC538.1 PR548.2
N18894895: PC518.1 PR530.1 PU500.16
N18990088: JCPU1.R27 T4.1(TP-1)
N19100797: R3673.2 U90.24
N19228907: R3703.2 U92.24
N19270300: JCPU1.L27 T40.1(TP-1)
N19270310: JCPU1.K27 T39.1(TP-1)
N19270320: JCPU1.T27 T41.1(TP-1)
N19273674: JCPU1.V27 T42.1(TP-1)
N19348815: JCPU1.N26 T43.1(TP-1)
N19355782: JCPU1.AL27 T44.1(TP-1)
N19359234: JCPU1.AK27 T45.1(TP-1)
N19359738: PR100.2 PR102.2 PU100.4
N19359776: PR118.2 PR119.1 PU100.7
N19359778: PR105.1 PU100.5
N19359887: PR101.2 PR104.2 PU100.2
N19359966: PC111.1 PR107.2
N19360011: PR106.1 PU100.1
N19360218: PC112.2 PR108.1
N19438915: JCPU1.E17 T46.1(TP-1)
N19581764: JCPU1.W32 T48.1(TP-1)
N19581774: JCPU1.AL16 T49.1(TP-1)
N19592461: JCPU1.AL13 T51.1(TP-1)
N21489543: JCPU1.AK33 T56.1(TP-1)
N23050350: JCPU1.AR1 T34.1(TP-1)
N23050352: JCPU1.A2 T33.1(TP-1)
N23050370: JCPU1.K6 T29.1(TP-1)
N23050372: JCPU1.F5 T25.1(TP-1)
N23050374: JCPU1.AM2 T27.1(TP-1)
N23050426: JCPU1.C35 T18.1(TP-1)
N23050428: JCPU1.B35 T20.1(TP-1)
N23050430: JCPU1.A34 T8.1(TP-1)
N23050432: JCPU1.A35 T9.1(TP-1)
N23050450: JCPU1.AT2 T5.1(TP-1)
N23050532: JCPU1.E20 T36.1(TP-1)
N23050534: JCPU1.E21 T35.1(TP-1)
N23050555: JCPU1.E18 T30.1(TP-1)
N23050586: JCPU1.D23 T14.1(TP-1)
N23050714: JCPU1.W30 T26.1(TP-1)
N23050732: JCPU1.W31 T28.1(TP-1)
N23050736: JCPU1.W29 T10.1(TP-1)
N23050738: JCPU1.W28 T15.1(TP-1)
N23050778: JCPU1.P10 T32.1(TP-1)
N23050780: JCPU1.U10 T31.1(TP-1)
N23050887: JCPU1.AL25 T23.1(TP-1)
N23050901: JCPU1.AT1 T11.1(TP-1)
N23050918: JCPU1.AM26 T24.1(TP-1)
N23050938: JCPU1.AR33 T19.1(TP-1)
N23050940: JCPU1.AM27 T22.1(TP-1)
N23050958: JCPU1.B23 T7.1(TP-1)
N23050968: JCPU1.C23 T12.1(TP-1)
N23050970: JCPU1.D24 T13.1(TP-1)
N23051071: JCPU1.AL30 T16.1(TP-1)
N23051073: JCPU1.AL29 T17.1(TP-1)
N23051091: JCPU1.AD10 T6.1(TP-1)
N24843313: C704.1 R756.2
N24843502: CE8.1 RE11.2
N24844156: CE9.1 RE12.2
N25368131: RV107.2 UV5.J13
N25669355: RV117.2 UV6.J13
N29179028: R802.2 U46.B18
N31479955: R804.1 U46.B19
N35502990: Q29.5 Q29.6 R508.2
N35569138: C470.2 R1144.1 Y3.1
N35662040: CE3.1 RE5.2
N41576026: PR400.2 PU400.4
N45129141: Q22.1 R423.2
N46595644: T122.1(TP-1) U46.B14
N48324044: JLOM1.13 R1167.2
N48324090: JLOM1.11 R1653.2
N48705646: PL4.1 PQ1.1 PR10.1 PR13.2
N48705653: PQ1.3 PR10.2 PR12.1
N48705663: PQ2.2 PR13.1 PR15.2
N48705666: PQ1.2 PQ2.1 PR14.2 PR16.1
N48711348: PC522.1 PR534.1
N48716673: PR838.2 PU800.28
N48716693: PR850.1 PU800.26
N48716711: PC811.1 PQ811.4 PR821.1
N49342732: Q79.1 R3671.1
N49563382: PC524.2 PR541.1
N49574226: PC508.2 PR513.1
N50215889: Q81.1 R938.1
N50225127: Q81.2 Q84.3
N50261142: D59.2 D62.2 Q74.1 Q84.4 R932.2
N51290432: PC501.1 PR502.1
N51302473: PC502.1 PR501.1 PU501.6 PU501.7
N51922312: PC612.1 PR639.2
N51922324: PC625.2 PR659.1 PU600.14
N51922366: PC600.2 PR600.2 PR607.2 PU600.38
N51922430: PR633.1 PU600.4
N51922457: PC617.1 PR645.1 PU600.16
N51922465: PR632.1 PU600.3
N51922467: PC613.2 PR639.1 PR640.1 PR642.2 PR644.1 PU600.8
N51922471: PC614.2 PR642.1
N51922473: PC609.1 PC611.2 PC613.1 PC614.1 PR637.1 PR638.2 PU600.7
N51922497: PC608.1 PC610.1 PR635.1 PR636.2 PU600.25
N51922501: PC611.1 PR638.1 PU600.6
N51922603: PR627.2 PR629.2 PU600.1
N51922663: PC625.1 PR647.2
N51922671: PH601.1 PR648.2
N51922720: PR641.1 PU600.18
N51922903: PC609.2 PU600.9
N51922909: PH600.2 PU600.5
N51924346: PC618.1 PR643.1 PU600.17
N51924368: PR636.1 PU600.24
N51924378: PH600.1 PR634.1
N53085144: PC206.2 PR200.1
N53085275: PR205.2 PU200.9
N53866851: C747.1 R885.2
N57652826: JCPU1.AT35 T52.1(TP-1)
N57659725: JCPU1.AR35 T53.1(TP-1)
N57663191: JCPU1.AR32 T54.1(TP-1)
N57663201: JCPU1.AL26 T55.1(TP-1)
N60687816: C289.1 R1629.2 U8.1
N61506560: PR722.1 PU700.11
N61513947: PR720.2 PR745.2 PR746.2 PR747.2 PU700.10
N63746311: R884.1 U51.B2
N63746359: R888.1 U51.B8
N70862806: D59.1 Q74.3
N70877887: Q74.6 Q75.2
N70882773: Q79.2 Q100.1
N72304780: T86.1(TP-1) UH1.AY1
N74863185: PD809.1 PQ809.4 PR813.1 PR815.1
N78936752: PQ812.2 PQ812.3 PR816.1
N78945927: PQ805.5 PQ805.6 PR807.2
N78946737: PC807.2 PQ810.4 PR811.2
N78948236: PD817.2 PQ828.1
N78957298: PC809.1 PQ815.1 PQ815.2 PQ815.3 PQ826.1 PQ826.2 PQ826.3 PR818.2
N78957443: PC809.2 PD816.1 PD821.1 PQ815.4 PQ826.4 PR818.1 PR822.1
N78957489: PQ816.1 PR822.2
N78963519: PQ817.1 PR819.1 PU805.2
N78963697: PU805.4 PU806.1
N78964443: PD814.1 PD819.1 PQ816.2
N78967013: PD814.2 PU806.4
N78985854: PQ806.3 PR810.2 PR812.2 PU804.2
N78999867: PD802.1 PD807.1 PQ801.3 PR804.1
N78999869: PQ801.2 PR802.2 PR804.2
N78999885: PQ807.6 PR802.1
N79001628: PQ802.2 PU801.4
N79002783: PD818.1 PQ802.3 PQ802.6 PQ805.2 PQ806.6 PR801.2
N79002827: PQ806.2 PU804.4
N79017925: PR820.1 PU806.2
N79021833: PD814.3 PU807.4
N79023703: PR863.1 PU800.19
N79025276: PQ807.2 PQ807.3 PR808.2
N79026790: PQ818.2 PQ819.3 PQ819.6 PR824.1 PR882.2
N79026826: PQ818.1 PR823.1 PR825.2
N79029876: PR825.1 PU807.2
N79030038: PQ813.2 PQ813.3 PR829.2
N79030087: PQ813.6 PR826.2
N79030091: PQ814.2 PR826.1 PR827.1
N79030745: PD816.2 PQ814.1
N79031357: PQ821.2 PQ821.3 PR849.2
N79031404: PQ821.6 PQ827.1 PR839.2
N79031406: PQ822.2 PR839.1 PR840.1
N79031414: PD816.3 PQ822.1
N79033064: PQ823.3 PR863.2 PR870.1
N79033066: PQ823.2 PR869.1 PR870.2
N79033085: PQ824.6 PR869.2
N79033110: PQ824.2 PQ824.3 PR875.2
N79033126: PQ824.5 PR883.2
N79099120: PC700.2 PQ701.2 PQ702.2 PR702.2
N79099356: PQ703.1 PQ703.3 PR706.2 PR707.2 PR709.1
N79099392: PC704.2 PC705.1 PR705.1 PU700.1
N79099442: PC703.2 PC704.1 PR704.1 PU700.2
N79099542: PC708.1 PR713.1 PR714.1 PU700.6
N79099544: PR717.2 PU700.5
N79100287: PQ701.1 PR701.2
N79100289: PQ702.1 PR701.3
N79100387: PQ700.4 PR700.1
N79108656: PC728.1 PQ707.2 PR723.1 PR725.2 PR749.2 PU701.1
N79108660: PQ709.1 PR730.2
N79108839: PR734.2 PR735.2 PR737.1 PR740.1 PU701.7
N79108872: PC727.1 PR725.1 PR728.2 PU701.3
N79108988: PC729.1 PR732.2 PR734.1 PR738.1 PU701.5
N79109000: PC730.1 PR733.2 PR739.1 PU701.6
N79109047: PC726.1 PR726.2 PR730.1 PR731.1 PU701.2
N79111305: PR715.1 PU700.17
N81870153: R65.2 U19.13
N81907121: R72.2 U19.23
N81942445: R76.1 U19.18
N82972829: R1655.1 U9.4
N85751870: PC306.2 PR301.2
N89358580: JCPU1.J27 T50.1(TP-1)
N90453832: R100.2 U27.2
N90453843: R101.2 U27.12
N91483552: JLVDS1.10 RE32.1
N91583217: C962.1 U74.37
N91583233: C963.1 U74.21
N91583239: R1642.1 U74.22
N91583241: C965.2 U74.34
N91583245: C1107.1 C1214.1 U74.25
N91583249: C1105.1 R1119.1 R1142.1
N91583257: C1106.1 R1120.1 R1141.1
N91583289: Q106.3 R1080.2
N91583291: Q106.6 R1079.2
N91583293: C977.1 R1076.2
N91583295: C978.1 R1077.2
N91814864: RV34.2 UV1.M12
N91814866: RV32.2 UV1.AG12
N91814868: RV28.2 UV1.L27
N91814874: RV31.2 UV1.N12
N91814876: RV36.2 UV1.M27
N92289874: R61.2 U6.8
N93761952: RV163.2 UV8.J13
N93762059: RV162.2 UV7.J13
N93819115: RV171.2 UV10.J13
N93820861: RV169.2 UV9.J13
N106386290: CE1.1 RE1.2
N106390602: CE2.1 RE2.2
N106528709: R1702.1 U38.26
N111614398: RV25.2 UV1.AH16
N111681891: CV129.1 QV1.4 RV85.2
N111719849: R1615.2 R1616.2 U102.3
N111721348: Q80.1 R3672.1
N111722051: Q82.1 R954.1
N111722441: Q86.1 R989.1
N111877798: QC4.2 RC96.2 RC98.2
N114027505: RV298.1 UV1.Y29
N114027546: RV296.1 UV1.Y30
N114040420: RV35.2 UV1.AH12
N114202850: RV42.1 UV1.AW28
N114204212: RV43.1 UV1.AW18
N114204319: RV44.1 UV1.AM39
N114207917: CV204.1 CV206.1 CV211.1 UV1.AP13 UV1.AP14 UV1.AP15 UV1.AT13
N114214511: CV81.2 RV45.1
N114214513: CV82.2 RV46.1
N114518899: D71.2 RV47.2 RV53.2 RV55.1
N114599272: QV4.1 RV56.1 RV58.1 RV60.2 RV77.2
N114599279: CV52.1 QV3.2 RV55.2 RV56.2 RV61.2
N114599731: QV4.2 RV57.2 RV59.1
N114599774: QV3.1 RV59.2
N114600614: CV53.1 QV7.2 RV58.2
N116042141: T146.1(TP-1) U46.A44
N116212675: CV343.1 RV178.1 RV179.2
N116646280: R3754.2 U94.24
N116650187: PBATT1.3 PD4.3
N116870152: PR736.2 PR744.1 PU703.4
N116874102: PR710.2 PR727.2 PU703.6
N117653907: D83.2 JHP1.5 R1100.2 R1676.1
N117654516: Q324.1 R1086.2
N118052171: D64.2 U54.4
N118093465: D65.2 R115.2 U55.4
N118416353: C962.2 U74.35
N119819670: JLOM1.10 R1166.2
N121245733: JMINI1.22 R704.1
N122052446: R657.1 U39.9
N123100505: PR111.2 PU100.19
N123142800: PQ819.2 PR881.1
N123143115: PQ813.5 PR884.1 PR886.1
N123143189: PQ821.5 PR885.1 PR887.1
N123208235: PD7.2 PQ7.1
N123208651: PC17.1 PQ7.2 PR26.2
N123209586: PQ806.5 PR888.2 PU803.4
N123214460: PD811.2 PR815.2
N123214476: PD811.1 PQ812.6
N123257917: PQ710.1 PR748.2 PU704.1
N123258004: PQ707.5 PU704.4
N123885734: PQ802.5 PU802.4
N123891751: PQ825.2 PR872.2
N123898600: PQ910.5 PQ910.6 PR878.2
N123898606: PQ910.3 PR879.1
N123900627: PD812.1 PQ812.5 PR889.1 PR890.1
N123905334: PR821.2 PR891.1 PR892.1
N123911328: PD804.1 PQ808.6
N123911330: PD804.2 PR805.2
N123911332: PQ808.2 PQ808.3 PR800.1
N123911345: PD805.1 PQ803.4 PR803.1 PR805.1
N123911602: PC800.1 PQ804.4 PR809.1
N124176605: PQ828.3 PR830.1 PR894.2 PR895.2
N124178621: PQ828.2 PQ829.1 PR830.2
N124179121: PD820.2 PQ829.2 PR828.1
N124410754: PD821.2 PQ820.1
N124410864: PQ820.2 PR896.2 PR897.1
N124411234: PQ830.1 PR897.2
N124411371: PQ830.2 PU809.4
N124735836: Q4.2 R55.2
N124736450: QV8.2 RV78.2
N126184618: T147.1(TP-1) U46.A23
N126754711: R169.1 U74.46
N126755046: C969.1 U74.31
N126756741: Q327.5 Q327.6 R1084.2
N126942376: D12.1 R210.2
N126942378: D11.1 R209.2
N126978921: T148.1(TP-1) U46.B1
N127053194: C445.1 U100.12
N127053198: C450.1 U100.10
N127053228: R716.1 R1631.2 R1633.2 U100.3
N127056523: C448.1 U101.12
N127056527: C452.1 U101.10
N127058740: C455.1 U102.12
N127058744: C456.1 U102.10
N127061181: C465.1 U103.12
N127061185: C476.1 U103.10
N127066552: R1607.2 R1608.2 R1620.2 U104.5
N127066560: C477.1 U104.12
N127066572: C486.1 U104.10
N127068793: C487.1 U105.12
N127068797: C488.1 U105.10
N127656110: C970.1 Q327.2 R39.2 R40.2
N127916603: C973.2 R1680.1
N127916606: C974.2 R1681.1
N127916609: C975.2 R1682.1
N127916612: C976.2 R1683.1
N129001439: CD47.2 RC109.1
N129001503: CD48.2 RC110.1
N129004419: CD46.2 RC108.1
N129121341: QC1.1 RC15.1
N129121543: RC13.1 RC14.1 UC1.2
N129600569: R3769.2 U95.24
N1320394060: PC666.1 PU602.7

Pads without a net: D23 2; FD1 1; FD2 1; FD3 1; FD4 1; JAPS1 15 16; JBTB1 4 14 22 26 27; JCPU1 A24 A26 A28 A30 AA1 AA2 AC8 AD8 AF9 AG9 B1 B24 B25 B26 B27 B28 B29 B30 B31 C25 C27 C29 C31 D28 D30 D32 D34 E28 E29 E30 E31 E32 E33 E34 E35 F29 F31 F33 F35 L8 L10 M9 M10 P1 P2 P3 R1 U1 U2 V1 V2 Y1 Y2; JDIMM1 77 122 125 198; JDIMM2 77 122 125 198; JEXP1 22; JHDMI1 14; JLOM1 14; JMDC1 2 4; JMINI1 3 5 6 17 19 28 30 32 37 40 44 45 46 47 48 49; JMINI2 3 5 6 8 10 12 28 30 48; JMINI3 3 5 6 20 28 30 32 37 40 42 44 45 46 47 48 49 51; JSATA1 20 21 22; JSF1 3 4; JSIM1 4 8 9; JTP1 4 8; JUSH1 9; JXDP1 55; JXDP2 3 5 21 22 23 24 42 45 47 55; PD1 5 6; PU400 1 7; PU603 1 7; PU700 4; PU702 5 6 7; PU800 20 30 31 36; PU808 16 17 22 23 24 25 26 27 28; RPH6 1 8; RPH7 4 5; RPH8 1 8; RV54 2; RV70 2; RV71 2; RV72 2; RV73 2; RV74 2; RV75 2; U19 36; U21 1; U24 1; U27 23 24 33 34; U32 5; U38 19 39 40 44 46; U39 6 7 12 14; U41 16 18 19 20; U51 B15; U88 2 3; UC2 1; UH1 A28 AB39 AB40 AJ10 AP15 AR13 AR15 AT13 AV36 AW36 BB37 BC12 BC14 BD37 BE12 BE14 C28 F22 F24 F41 G22 G24 H43 H45 Y38 Y39; UV1 A39 AA29 AA31 AA32 AA33 AA34 AC10 AC30 AC31 AC32 AD30 AD32 AF30 AF31 AF32 AF33 AF35 AG21 AG22 AG28 AG36 AG38 AH23 AH24 AH26 AH35 AH37 AJ19 AJ20 AJ21 AJ23 AJ24 AJ26 AJ36 AJ38 AK19 AK20 AK21 AK24 AK26 AK29 AK30 AK35 AK37 AL19 AL27 AL29 AL30 AL31 AL36 AM19 AM20 AM21 AM26 AM27 AM29 AM30 AN20 AN21 AN24 AN26 AN36 AP20 AP21 AP22 AP23 AP24 AP25 AP26 AP34 AP35 AP37 AR1 AR3 AR8 AR14 AR16 AR20 AR22 AR24 AR26 AR30 AR32 AR34 AR35 AR37 AT15 AT17 AT19 AT21 AT23 AT25 AT27 AT29 AT31 AT33 AU8 AU14 AU16 AU18 AU20 AU22 AU24 AU26 AU28 AU30 AU32 AU35 AU39 AV13 AV15 AV19 AV21 AV23 AV25 AV29 AV31 AW1 AW8 AW34 AW35 AW37 AW39 E37 F35 F37 G36 G38 H32 H33 H35 H37 J32 J33 J36 J38 K16 K27 K29 K30 K32 K33 K35 K37 L10 L29 L30 L32 L33 L36 L38 M20 M21 M35 M37 N29 N30 N32 N33 N38 U12 U13 V12 V13 V28 W29 W30 Y31; UV3 A5 A11 A13 B11 B13 E11 E13 F11 F13 M2 M4 N2 N4 R2 T2 T4 U2 U4 U5; UV4 A5 A11 A13 B11 B13 E11 E13 F11 F13 M2 M4 N2 N4 R2 T2 T4 U2 U4 U5; UV5 A5 A11 A13 B11 B13 E11 E13 F11 F13 M2 M4 N2 N4 R2 T2 T4 U2 U4 U5; UV6 A5 A11 A13 B11 B13 E11 E13 F11 F13 M2 M4 N2 N4 R2 T2 T4 U2 U4 U5; UV7 A5 A11 A13 B11 B13 E11 E13 F11 F13 M2 M4 N2 N4 R2 T2 T4 U2 U4 U5; UV8 A5 A11 A13 B11 B13 E11 E13 F11 F13 M2 M4 N2 N4 R2 T2 T4 U2 U4 U5; UV9 A5 A11 A13 B11 B13 E11 E13 F11 F13 M2 M4 N2 N4 R2 T2 T4 U2 U4 U5; UV10 A5 A11 A13 B11 B13 E11 E13 F11 F13 M2 M4 N2 N4 R2 T2 T4 U2 U4 U5

## Via types
v1: diameter 0.305, hole 0.152, TOP to BOTTOM, 1372 vias
v2: diameter 0.457, hole 0.203, TOP to BOTTOM, 8168 vias
v3: diameter 0.406, hole 0.203, TOP to BOTTOM, 136 vias
v4: diameter 0.508, hole 0.254, TOP to BOTTOM, 1862 vias

## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point)
0.75V_DDR_VTT_ON: length 92.7
  TOP w0.254: U46.A60 269.94,46 v2(270.3,45.64) 270.3,45 R790.2 271.72,43.57 273.73,43.57 v3(275.66,41.65) v2(276.64,40.67) ; PR208.1 215.76,12.08 v4(216.77,13.09)
  IN2 w0.254: v2(276.64,40.67) 276.64,40.14 275.55,39.05 275.55,38.81 274.91,38.18 274.25,38.18 273.76,37.68 273.76,34.32 273.25,33.81 272.79,33.81 271.19,32.21 268.07,32.21 267.51,32.77 261.73,32.77 259.12,30.16 v2(256.61,30.16)
  IN3 w0.254: v4(216.77,13.09) 219.22,15.54 244.42,15.54 245.17,14.8 v2(245.17,13.77) ; v2(246.87,19.38) 246.87,19.75 251.1,23.98 251.89,23.98 256.61,28.7 v2(256.61,30.16)
  BOTTOM w0.254: v2(245.17,13.77) 245.33,13.77 245.63,14.06 245.63,19.08 245.93,19.38 v2(246.87,19.38)
1.05V_A_PWRGD: length 176.6
  TOP w0.102: U51.B28 286.47,117.94 286.53,117.87 v2(286.53,117.64)
  TOP w0.254: PU300.1 238.11,6.62 v2(237.39,5.9) 237.09,5.6 236.76,5.6 PR300.1
  IN2 w0.127: v2(286.53,117.64) 286.52,117.64 286.24,117.36 286.24,116.22 284.69,114.67 282.92,114.67 281.4,116.19 280.33,116.19 279.97,115.83 279.97,115.65 279.97,115.28 279.57,114.88 279.42,114.88 279.4,114.87 274.32,114.87 274.14,114.69 259.19,114.69 258.31,113.82 252.34,113.82 252.01,113.49 252.01,112.8 v2(252.12,112.7)
  IN3 w0.127: v2(251.35,23.49) 251.39,23.53 251.91,23.53 257.89,29.51 v2(257.89,31.43)
  BOTTOM w0.102: v2(252.12,112.7) 252.12,110.44 251.29,109.61 251.29,106.82 251.75,106.36 251.75,98.57 251.09,97.91 251.09,96.34 251.29,96.13 251.29,92.37 251.77,91.88 251.77,85.74 252.54,84.98 252.54,62.74 253.44,61.84 253.44,58.5 253.56,58.37 253.56,57.18 257.25,53.5 257.25,52.32 258.15,51.42 258.15,48.66 258.39,48.42 258.39,48.42 258.87,47.94 258.87,47.14 259.02,46.99 259.02,38.04 258.15,37.16 v1(258.15,33.16) 258.15,31.69 v2(257.89,31.43) ; v2(251.35,23.49) 251.08,23.22 251.08,6.01 247.07,2.01 238.23,2.01 237.61,2.63 237.61,5.68 v2(237.39,5.9)
1.05V_RUN_ENABLE: length 8.2
  BOTTOM w0.254: Q63.4 226.55,23.44 227.17,24.07 C773.1 v1(227.95,22.95) R1611.1 227.96,21.68 R930.2 230.46,20.76 230.59,20.89 Q52.3
1.5VSP_FB: length 2.7
  TOP w0.102: v1(231.71,109.93) 231.71,107.84 PR405.1
1.5VSP_LX: length 1.5
  TOP w0.102: PR401.1 v1(239.19,109.85)
1.5VSP_VIN:
  vias: v1(229.98,102.16)
1.8V_PWRGD: length 2.6
  TOP w0.254: PU603.4 282.18,135.32 281.43,136.08 PR685.2
1.8VSP_FB: length 6.1
  TOP w0.102: v1(279.17,132.02) PR689.1
  TOP w0.254: PR689.1 280.53,130.64 PC671.2 PR687.2 282.05,130.39 282.05,131.03 281.68,131.39 PU603.6
1.8VSP_LX: length 1.5
  TOP w0.102: PR686.2 283.62,141.36 v1(283.83,141.57)
1.8VSP_VIN:
  vias: v1(283.83,131.08)
1.35V_B+: length 25.4
  TOP w0.254: PR205.1 v4(216.01,15.13)
  IN3 w0.254: v2(196.12,19.2) 196.17,19.25 205.32,19.25 206.69,20.62 211.74,20.62 213.43,18.94 213.43,15.77 213.74,15.47 215.67,15.47 v4(216.01,15.13)
  vias: v1(199.37,15.25)
1.35V_FB:
  vias: v1(213.15,11.39)
1.35V_SUS_PWRGD: length 433.2
  TOP w0.102: v2(145.32,67.16) 145.08,67.4 RC9.2 ; RC103.2 141.59,56.93 v2(142.11,56.41) v1(142.85,56.41) 142.85,54.61 142.4,54.17 140.26,54.17 138.21,56.22 RC14.2 ; U51.B9 291.69,113.91 291.66,113.88 291.16,113.88 v2(290.72,113.44)
  TOP w0.203: PU200.10 212.49,14.66 212.71,14.87 212.71,15.76 213.09,16.14 PR209.2
  TOP w0.254: v2(213.93,16.76) 213.99,16.7 213.99,16.43 PR209.2
  IN2 w0.127: v2(290.72,113.44) 287.55,113.44 285.71,111.61 284.74,111.61 284.46,111.33 284.06,111.33 284.06,111.33 282.62,111.33 282.28,110.99 280.52,110.99 280.39,110.86 279.62,110.86 279.25,111.23 277.47,111.23 277.27,111.04 277.27,110.76 276.9,110.39 276.47,110.39 275.9,110.96 275.58,110.96 275.49,111.05 274.99,111.05 274.4,111.65 270.09,111.65 269.62,111.18 268.99,111.18 267.31,109.49 266.23,109.49 265.92,109.79 263.57,109.79 263.29,109.51 262.94,109.51 262.93,109.52 262.11,109.52 261.98,109.65 252.81,109.65 252.46,110.01 v2(252.45,110.01)
  IN3 w0.127: v2(213.93,16.76) 213.93,19.23 212.21,20.94 205.38,20.94 204.33,19.89 195.03,19.89 193.98,20.94 188.95,20.94 188.7,20.7 186.76,20.7 186.04,19.98 186.04,18.43 181.53,13.92 163.09,13.92 159.89,10.72 146.83,10.72 144.59,12.97 132.24,12.97 129.76,10.49 129.76,8.06 130.67,7.16 130.67,3.07 130.49,2.9 128.44,2.9 128.21,3.13 123.06,3.13 122.37,3.81 118.72,3.81 118.32,4.21 117.02,4.21 115.16,6.06 115.16,11.13 115.86,11.83 115.86,27.23 116.95,28.33 116.95,45.73 116.47,46.22 116.47,49.18 118.6,51.31 118.6,56.38 120.56,58.33 122.64,58.33 126.03,54.94 140.64,54.94 v2(142.11,56.41) 142.11,60.12 144.95,62.97 144.95,66.79 v2(145.32,67.16)
  IN4 w0.102: v2(271.39,30.17) 271.24,30.02 271.24,27.89 268.17,24.82 265.97,24.82 257.69,16.54 231.71,16.54 231.17,17.08 224.49,17.08 223.78,16.37 214.37,16.37 213.98,16.76 v2(213.93,16.76)
  BOTTOM w0.102: v2(252.45,110.01) 251.65,109.21 251.65,106.78 252.57,105.86 252.57,105.04 252.1,104.57 252.1,98.6 251.32,97.81 251.32,96.43 252.36,95.39 252.36,85.83 253.08,85.1 253.08,62.55 253.67,61.97 253.67,58.59 253.79,58.47 253.79,57.28 257.49,53.58 257.49,52.44 258.1,51.83 258.91,51.83 259.1,51.64 259.1,47.24 259.25,47.08 259.25,38.08 260.71,36.62 260.71,31.78 262.75,29.74 262.75,28.84 263,28.59 264.52,28.59 266.11,30.17 v2(271.39,30.17)
3.3V_RUN_GFX_ON: length 118.5
  TOP w0.102: U46.A55 267.44,46.73 267.24,46.53 267.24,46.11 267.66,45.69 267.88,45.69 268.17,45.4 268.17,42.8 v2(267.67,42.3) ; v2(192.5,59.11) 192.53,59.13 192.53,59.58 193.48,60.53 193.48,60.93 QH3.2 ; v2(264.32,37.34) v1(263.63,37.34)
  IN2 w0.127: v2(264.32,37.34) 264.26,37.4 260.85,37.4 259.62,36.17 256.88,36.17 256.49,35.78 v2(256.27,35.78)
  IN3 w0.127: v2(192.5,59.11) 192.54,59.07 193.56,59.07 194.74,57.89 194.74,55.32 194.52,55.11 193.6,55.11 193.32,54.83 193.32,51.81 199.2,45.93 200.41,45.93 203.8,42.53 211.29,42.53 223.69,30.12 223.69,27.82 228.78,22.73 231.69,22.73 232.82,21.6 243.78,21.6 249.55,27.37 249.55,28.94 251.64,31.02 253.04,31.02 255.05,33.04 255.05,34.56 v2(256.27,35.78) ; v2(267.67,42.3) 267.67,41.33 266.29,39.95 266.29,39.69 264.32,37.72 v2(264.32,37.34)
3V_5V_EN: length 16.5
  TOP w0.254: v4(153.12,4.89) 153.14,4.86 153.14,4.38 151.76,3 v1(147.81,3) 147.33,3 v2(146.29,1.96)
  BOTTOM w0.203: PU100.6 148.79,5.56 148.7,5.47 148.7,5.31 149.13,4.88 149.13,4.39 ; v4(153.12,4.89) 153.12,5.02 152.57,5.56 PU100.20
  BOTTOM w0.254: 149.13,4.39 148.69,3.95 PC120.1 146.35,2.92 PR110.2 146.08,2.65 146.08,2.16 v2(146.29,1.96)
+0.9V_LAN: length 7.4
  BOTTOM w0.254: v2(314.84,196.99) 314.84,196.89 314.72,196.77 U31.8 ; v2(313.55,196.95) 313.52,196.93 U31.11 ; v2(319.39,198.89) 319.19,198.89 319.12,198.82 U31.43 ; v2(313.29,200.42) 313.29,200.42 U31.22 ; U31.16 313.19,198.02 v2(313.4,198.23) ; U31.40 v2(319.5,200.02) ; U31.37 319.35,201.22 v2(319.39,201.18)
  vias: v2(316.67,190.77) v2(317.31,190.77) v2(319.81,196.61) v2(319.81,195.97) v3(312.02,196.46)
+0.675V_DDR_VTT: length 31.8
  TOP w0.102: v2(185.63,40.74) 186.48,40.74 v3(186.77,40.45)
  IN3 w1.016: 187.63,19.42 188.41,19.42 189.91,17.92 196.15,17.92 201.51,12.56
  BOTTOM w1.016: 187.07,19.32 187.56,19.32 189.54,21.3 189.54,23.89 189.17,24.26 189.17,29.26 187.49,30.95
  vias: v2(185.63,41.33) v2(186.67,19.7) v2(186.7,26.64) v2(186.69,19.06) v2(187.09,32.41) v2(187.12,31.79) v2(187.32,26.64) v4(202.67,12.84) v4(202.67,12.2)
+0.675V_P: length 1.2
  BOTTOM w0.102: v4(207.32,11.96) v1(208.54,11.96)
+1.2V_LDO: length 44
  TOP w0.102: v2(254.16,37.55) v3(254.85,37.55)
  TOP w0.203: C1506.2 256.19,42.68 255.89,42.99 255.71,42.99 255.13,43.57 255.13,43.94 254.82,44.24 U38.41 ; C1505.2 249.41,49.09 249.41,48.9 249.8,48.51 249.8,48.49 249.85,48.44 249.85,48.43 249.92,48.36 U38.10
  TOP w0.508: C1505.2 248.57,49.72 248.17,50.13 v2(248.17,50.15) ; C1507.2 248.52,52.11 248.22,52.41 v2(247.93,52.41) ; v2(254.16,37.55) 254.1,37.62 L47.2 ; C1506.2 256.45,41.39 v2(256.29,41.24)
  IN2 w0.508: v2(256.29,41.24) 256.36,41.17 256.36,40.78 255.47,39.89 249.87,39.89 249.4,39.42 v2(249.4,37.6)
  IN4 w0.508: v2(249.4,37.6) 249.41,37.6 249.79,37.22 249.79,36.46 250.25,36 254.06,36 254.64,36.59 254.64,37.2 254.29,37.55 v2(254.16,37.55)
  BOTTOM w0.508: v2(247.93,52.41) 247.93,52.22 247.28,51.57 247.28,50.65 247.77,50.15 v2(248.17,50.15) 248.27,50.15 248.27,39.56 249.41,38.42 249.41,37.62 v2(249.4,37.6)
+1.2V_LDO_OZ: length 25
  TOP w0.203: U38.36 253.52,41.45 253.83,41.14 254.36,41.14 254.77,40.73 C1509.2 ; C562.2 250.12,40.22 250.12,40.98 250.32,41.18 U38.28 ; 251.52,40.02 251.52,40.37 251.67,40.53 251.67,41.05 251.52,41.2 U38.31
  TOP w0.508: C1509.2 254.77,38.98 v2(254.21,38.42)
  BOTTOM w0.508: v2(254.21,38.42) 253.14,38.42 251.8,39.76 250.66,39.76 249.92,40.5 249.92,42.05 250.81,42.94 253.2,42.94 253.65,43.4 v1(253.65,44.59) 253.65,48.12 v2(253.98,48.45)
  vias: v2(251.39,38.06) v2(251.39,37.48)
+1.2V_OZ_AUX_LDO: length 7
  TOP w0.203: U38.12 249.12,48.22
  TOP w0.254: C564.2 246.05,51.76 246.62,51.19 246.62,50.36 C801.2 245.98,49.57 246.28,49.27 246.3,49.27 246.6,48.97 246.6,48.53 v1(246.79,48.34) 249,48.34 249.12,48.22
+1.05V_+1.5V_RUN: length 68.3
  TOP w0.508: 206.79,88.61 206.79,89.09 205.85,90.03 205.85,90.31 205.05,91.11 203.43,91.11 202.22,89.9 202.22,88.59 201.27,87.64 198.42,87.64 197.64,86.87 197.52,86.87 196.21,85.56 196.21,84.03 ; 206.79,88.61 v1(208.52,88.61) 211.1,88.61 211.79,87.91 v2(213.17,87.91) ; 206.79,88.61 206.26,88.07 206.26,86.8 208.13,84.93 CH26.1 208.89,84.29 208.89,83.92 v2(208.86,83.9)
  IN1 w0.508: v2(206.71,75.74) 206.68,75.77 205.82,75.77 205.55,75.5 204.83,75.5 202.77,77.57 202.13,77.57 201.44,78.26 201.44,78.51 v2(200.67,79.28)
  IN3 w0.254: v2(209.44,76.58) 209.08,76.58 208.63,77.03 208.63,77.83 210.85,80.05 211.04,80.05 211.7,80.71 211.7,86.45 v2(213.17,87.91) ; v2(193.24,79.44) 193.24,78.83 193.89,78.17 195.26,78.17 198.29,75.15 198.29,74.4 198.69,74 199.04,74 200.24,72.81 200.85,72.81 v2(201.2,72.45)
  BOTTOM w0.254: UH1.AK28 206.76,75.8 v2(206.71,75.74) 206.65,75.69 UH1.AK26 ; v2(208.86,83.9) 208.82,83.9 208.52,84.2 UH1.BB44 ; UH1.BE22 201.01,78.94 v2(200.67,79.28) ; v2(209.44,76.58) 209.54,76.48 UH1.AF34 ; v2(201.2,72.45) 201.37,72.28 UH1.AN11
  BOTTOM w0.508: CH52.1 195.13,82.96 v2(195.67,82.42) ; RH165.2 213.17,87.43 v2(213.17,87.91)
+1.5V_CARD: length 4.1
  TOP w0.254: U41.13 275.04,35.95 275.42,35.57 v2(275.57,35.57)
  IN4 w0.508: v2(275.57,35.57) 275.75,35.39 275.75,33.16 v2(275.6,33.01)
  vias: v2(274.98,33.01) v2(281.52,31.17) v2(282.18,31.25) v3(282.3,30.39)
+1.05V_M: length 261.2
  TOP w0.102: v4(205.94,34.16) v3(205.94,34.98)
  TOP w0.254: v2(210.02,67.88) 210.16,68.02 210.16,68.74 CH29.1
  TOP w0.508: v2(221.95,83.49) 220.4,83.49 218.44,81.53 218.4,81.53 RH239.1 ; CH30.1 207.93,69.54 207.98,69.54 v2(208.14,69.71) ; v2(207.68,70.17) 207.34,70.17 RH234.1
  IN1 w0.254: v2(209.29,70.86) 209.29,71.6 209.67,71.98 210.64,71.98 210.78,72.12 211.93,72.12 212.35,71.7 212.76,71.7 213.09,72.03 213.09,73.08 215.16,75.15 215.16,76.38 215.37,76.59 215.37,77.43 216.57,78.63 216.57,79.6 220.06,83.1 221.56,83.1 v2(221.95,83.49)
  IN2 w0.508: v2(301.76,129.97) 301.63,129.97 300.53,131.08 290.99,131.08 290.42,130.5 286.06,130.5 285.66,130.1 284.28,130.1 283.65,129.46 283.12,129.46 282.78,129.81 275.2,129.81 273.71,128.31 273.13,128.31 271.23,130.21 262.05,130.21 260.8,128.97 256.71,128.97 256.01,128.27 255.13,128.27 254.8,127.94 v2(254.8,127.69) ; v2(203.94,90.18) 203.94,90.82 207.29,94.16 207.29,94.93 207.12,95.1 207.12,96.06 v2(206.82,96.37)
  IN3 w0.508: 228.75,85.01 228.75,86.11 225.88,88.98 225.88,90.16 225.05,90.98 221.8,90.98 218.28,94.5 210.84,94.5 210.01,93.67 208.95,93.67 207.09,95.53 207.09,96.09 v2(206.82,96.37) ; 228.75,85.01 227.22,83.49 v2(221.95,83.49) ; 228.75,85.01 230.41,85.01 234.26,88.86 240,88.86 241.33,90.2 241.33,94.35 245.83,98.84 247.81,98.84 253.69,104.73 253.69,112.18 256.37,114.86 256.37,126.73 255.66,127.44 255.04,127.44 v2(254.8,127.69) ; v2(301.76,129.97) 301.85,129.88 302.57,129.88 309.48,136.79 312.56,136.79 316.92,141.15 316.92,142.14 321.06,146.28 321.06,151.22 322.16,152.31 322.16,153.57 322.64,154.05 322.64,157.45 322.02,158.08 322.02,162.14 321.57,162.59 321.57,167.46 321.04,168 321.03,168 320.67,168.35 320.67,168.36 320.57,168.47 320.57,171.67 320.96,172.06 320.96,173.49 320.4,174.05 319.77,174.05 318.97,174.85 318.97,175.96 317.24,177.69 317.24,181.57 318.09,182.42 318.09,188.01 v2(317.9,188.2)
  BOTTOM w0.254: UH1.L17 209.95,67.48 209.95,67.82 v2(210.02,67.88)
  vias: v2(208.62,69.23) v4(205.94,33.53) v4(206.57,34.16)
+1.05V_MP: length 28.6
  TOP w0.254: PR306.1 v2(242.17,3.16)
  IN1 w0.254: v2(221.47,9.99) 221.47,9.97 222.97,8.47 222.97,5.16 223.68,4.44 223.68,2.25 224.01,1.92 240.93,1.92 v2(242.17,3.16)
  vias: v1(225.22,13.92)
+1.5V_RUN: length 324.4
  TOP w0.254: U41.12 274.76,35.45 275.15,35.06 275.88,35.06 C635.1
  TOP w0.279: v2(275.57,36.21) 275.33,36.45 U41.14
  TOP w0.508: RH192.1 202.32,80.37 200.68,82 200.68,84.24 200.24,84.68 200.24,85.81 v2(199.12,86.93) ; v2(208.4,83.49) 208.67,83.22 209.23,83.22 210.44,84.43 211.37,84.43 ; v2(201.01,88.28) 200.96,88.33 198.2,88.33 197.36,87.48 197.24,87.48 195.85,86.09 193.81,86.09 191.89,84.18 191.89,77.42 v2(191.99,77.33) 191.99,77.12 RH233.2 ; v2(207.84,92.79) 210.14,90.49 212.12,90.49 213.98,88.63 213.98,87.82 211.38,85.22 211.38,84.45 211.37,84.43 ; v2(194.67,77.6) 195.76,77.6 196.12,77.24 RH98.2 197.22,76.63 RH100.1 ; 211.37,84.43 RH163.2 ; C635.1 v2(276.26,36.14) ; v2(192.74,74.31) 192.94,74.11 192.94,73.68 RH51.1 192.21,72.95
  TOP w1.016: 178.93,191.03 179.29,191.03 179.75,191.49 209.7,191.49 210.41,190.78 219.54,190.78 220.73,189.59 226.45,189.59 227.81,190.94 240.33,190.94 243.05,188.23 247.3,188.23 248.49,189.42 251.1,189.42 252.55,187.97 252.55,182.7 255.42,179.83 255.42,178.5
  IN2 w0.508: v2(201.01,88.28) 200.19,88.28 199.12,87.21 v2(199.12,86.93) ; v2(192.74,74.31) 191.99,75.06 v2(191.99,77.33) 192.27,77.61 194.67,77.61 v2(194.67,77.6)
  IN2 w1.016: 164.08,190.8 164.05,190.83 161.37,190.83 161.17,191.03 158.29,191.03 157.93,190.68 139,190.68 138.36,190.04 131.61,190.04 130.89,189.32 130.89,187.84 129.85,186.8 123.3,186.8 122.07,188.04 120.67,188.04 120.29,187.65
  IN3 w0.508: v2(224.15,89.95) 221.9,89.95 218.18,93.67 210.97,93.67 209.96,92.67 207.96,92.67 v2(207.84,92.79)
  BOTTOM w0.254: UH1.AW40 208.52,83.31 208.4,83.43 v2(208.4,83.49)
  BOTTOM w0.508: RH188.1 199.74,84.61 199.74,87.08 200.94,88.28 v2(201.01,88.28) 201.01,88.39 201.53,88.91 201.53,89.93 203.03,91.43 203.97,91.43 205.56,93.01 206.72,93.01 v2(207.39,92.34)
  BOTTOM w1.016: 118.39,188.01 115.34,188.01 113.2,185.88 107.25,185.88 103.11,190.02 97.68,190.02 96.63,191.07 81.87,191.07 81.15,190.35 72.67,190.35 68.31,194.7 56.84,194.7 56.82,194.73 55.71,194.73 55.69,194.7 54.59,194.7 53.79,195.5 31.45,195.5
  vias: v2(30.06,194.92) v2(30.72,194.93) v2(119.25,188.37) v2(119.25,187.78) v2(177.67,191.26) v2(178.16,191.59) v2(223.12,81.93) v2(223.5,81.42) v2(241.36,39.23) v2(241.78,39.65) v2(241.85,23.55) v2(242.64,23.57) v2(257.87,172.39) v2(257.88,172.97) v3(255.18,174.66) v4(233.02,101.04) v4(232.99,100.41) v4(233.66,101.1) v4(233.66,100.47) v4(234.3,101.1) v4(234.3,100.47)
+1.05V_RUN: length 509.9
  TOP w0.254: v2(213.53,74.23) 213.53,74.95 214.66,76.08 214.86,76.08 215.21,76.43 215.21,76.99 CH47.1
  TOP w0.381: CH36.1 208.19,80.23 208.53,80.23 208.75,80.01 208.75,80.02 208.77,80.05 208.77,80.04 208.78,80.02 v2(208.77,80.02)
  TOP w0.508: v2(127.33,102.93) 127.4,103.01 RC54.1 ; 192.09,74.64 193.08,75.64 RH235.2 ; 192.09,74.64 192.09,75.48 191.26,76.31 191.26,84.59 193.39,86.73 195.58,86.73 197.01,88.15 197.13,88.15 197.94,88.96 201.2,88.96 201.58,89.34 201.58,90.18 203.37,91.97 v2(203.37,96.34) ; 192.09,74.64 190.48,73.04 v2(190.48,72.4) ; v2(181.78,102.32) 181.59,102.32 180.01,100.74 178.3,100.74 177.96,101.08 177.33,101.08 176.67,101.74 RC85.1 ; RC53.1 v2(132.44,121.69) ; v2(272.35,81.86) 272.17,81.86 271.67,82.36 271.67,84.39 271.98,84.7 272.65,84.7 273.03,85.08 273.03,91.64 274.37,92.98 274.55,92.98 275.98,94.4 275.98,95 v2(276.07,95.08) ; RH243.1 218.35,61.91 v2(217.54,61.91) ; R1179.1 279,109.77 v2(278.84,109.6) ; v2(211.59,73.16) 211.31,72.87 211.31,72.8 CH35.1 ; v2(118.26,120.99) 118.59,120.66 v3(125.05,120.66) 127.03,120.66 v2(127.22,120.47) ; v2(194.26,70.42) 194.1,70.57 193.06,70.57 RH206.1 ; v2(128.91,99.21) 128.67,98.97 127.87,98.97 127.3,98.4 127.3,96.26 127.66,95.9 RC86.2 ; RC55.1 130.97,104.61 132.26,105.91 v2(132.82,105.91) ; v2(220.61,84.47) 220.49,84.47 218.18,82.16 218.14,82.16 216.82,80.85 216.48,80.85 216.42,80.91 215.75,80.24 RH244.1 ; v2(279.85,105.97) 279.85,105.74 280.3,105.3 R866.2
  IN1 w0.508: v2(132.44,121.69) 132.44,121.11 131.69,120.36 127.34,120.36 v2(127.22,120.47) ; v2(279.85,105.97) 279.76,105.88 279.76,105.78 279.4,105.41 277.96,105.41 277.14,104.58 277.14,96.08 276.07,95.01 v2(276.07,95.08) ; v2(127.33,102.93) 127.33,104.37 128.19,105.23 131.96,105.23 132.63,105.91 v2(132.82,105.91)
  IN2 w0.254: v2(207.37,93.23) 206.87,92.72 206.87,88.15 205.6,86.88 205.6,82.05 206.26,81.39 206.28,81.39 207.65,80.02 v2(208.77,80.02) ; v2(224.72,74.08) 224.72,72.67 221.71,69.65 216.68,69.65 213.88,72.45 213.65,72.45 213.07,73.03 v2(213.07,73.77)
  IN2 w0.279: 215.65,68.57 214.97,68.57 212.61,70.92 212.61,71.19 211.03,72.77 211.03,73.53 v2(211.13,73.62)
  IN2 w0.508: v2(122.79,117.23) 122.79,118.25 125.01,120.47 v2(127.22,120.47) ; 226.75,73.09 227.38,72.47 233.15,72.47 233.92,73.23 255.61,73.23 256.57,74.19 260.8,74.19 263.64,77.04 269.35,77.04 271.01,78.7 271.01,81.04 271.8,81.83 272.31,81.83 v2(272.35,81.86) ; 226.75,73.09 224.63,70.97 224.63,68.2 v2(224.01,67.58) 223.59,67.16 222.27,67.16 220.53,68.9 215.98,68.9 215.65,68.57 ; 226.75,73.09 226.75,74.4 227.87,75.51 227.87,76.33 225.12,79.08 223.4,79.08 221.84,80.64 221.84,82.55 220.61,83.78 v2(220.61,84.47) ; v4(111.6,154.71) 112.47,153.85 112.47,148.93 115.26,146.14 115.26,122.99 116.94,121.3 117.95,121.3 v2(118.26,120.99) 119.31,119.94 119.31,111.24 121,109.55 123.36,109.55 126.35,106.57 126.35,103.73 127.15,102.93 v2(127.33,102.93) 127.33,102.63 128.91,101.04 v2(128.91,99.21)
  IN3 w0.254: v2(222.83,66.47) 222.63,66.67 221.88,66.67 218.97,69.58 216.73,69.58 213.91,72.4 213.62,72.4 213.22,72.81 213.22,73.19 213.53,73.51 v2(213.53,74.23)
  IN3 w0.508: v2(203.37,96.34) 203.37,97.59 204.06,98.27 208.05,98.27 209.61,96.71 209.61,94.72 v2(209.58,94.69) ; v2(190.48,72.4) 192.28,72.4 v2(194.26,70.42)
  BOTTOM w0.254: v2(213.53,74.23) 213.43,74.33 UH1.U36 ; v2(208.77,80.02) 208.43,79.68 UH1.AN35 UH1.AN34 ; v2(213.07,73.77) 213.01,73.83 UH1.U35
  BOTTOM w0.279: JXDP2.40 272.31,81.83 v2(272.35,81.86)
  BOTTOM w0.508: v2(279.85,105.97) 279.89,106.01 279.89,106.95 278.84,108 v2(278.84,109.6) ; RH246.1 CH38.1 209.7,93.55 209.7,94.58 v2(209.58,94.69) 209.58,96.79 209.08,97.29 207.44,97.29 204.52,100.22 195.03,100.22 193.25,101.99 183.05,101.99 182.72,102.32 v2(181.78,102.32) 181.78,100.29 181.17,99.68 RC105.2 180.41,99.68 180.04,99.31 180.04,98.04 179.33,97.33 175.55,97.33 173.36,95.15 173.36,79.65 169.77,76.06 144.7,76.06 142.76,78 139.54,78 132.48,70.94 124.29,70.94 122.92,72.31 122.92,93.22 v2(128.91,99.21) 129.09,99.39 RC60.1 ; PR527.1 111.84,154.95 v4(111.6,154.71) ; RC27.1 134.41,122.77 134.03,123.15 133.33,123.15 132.44,122.26 v2(132.44,121.69) ; RC99.2 v2(127.22,120.47) ; RC57.1 123.25,117.69 v2(122.79,117.23)
  vias: v2(196.2,79.64) v2(196.71,79.26) v2(197.21,78.75) v2(201.05,76.77) v2(203.06,83.3) v2(203.46,82.77) v2(203.62,75.63) v2(203.82,73.97) v2(204.09,75.17) v2(204.41,73.44) v2(204.54,74.71) v2(205.81,72.04) v2(206.02,74.13) v2(206.26,71.59) v2(206.96,73.19) v2(207.43,72.72) v2(208,73.3) v2(208.57,73.89) v4(217.6,24.82) v4(217.6,24.18) v4(218.23,24.82) v4(218.23,24.18) v4(218.87,24.8) v4(218.87,24.17) v4(219.5,24.8) v4(219.5,24.17) v4(220.14,24.8) v4(220.14,24.17) v4(220.81,24.17) v4(220.96,45.59) v4(220.96,44.96) v4(220.96,44.32) v4(221.6,45.59) v4(221.6,44.96) v4(221.6,44.32) v4(222.37,45.67) v4(222.37,45.03) v4(222.36,44.31) v4(223.01,45.67) v4(223.01,45.03)
+1.05V_RUN_CHG: length 2.5
  BOTTOM w0.102: v1(218.8,20.9) R925.2
  BOTTOM w0.508: Q70.1 218.75,21.98 R925.2
+1.5V_RUN_HDMI: length 13.1
  TOP w0.203: U19.40 28.07,198.64 28.56,198.16 C340.1 ; U19.31 24.47,198.57 24.34,198.44 23.87,198.44 23.2,197.77 23.2,197.17 C342.1 ; C355.1 27.67,205.55 U19.12
  TOP w0.508: C342.1 22.46,197.43 22.33,197.56 v2(22.13,197.56) ; v2(29.24,196.43) C340.1 ; v2(28.81,205.97) C355.1
  BOTTOM w0.102: v2(29.24,196.43) v1(28.68,196.43)
  vias: v2(21.9,206.06) v2(22.51,206.03) v2(30.04,197.22) v2(30.65,197.21)
+1.05V_RUN_VCC: length 1.6
  BOTTOM w0.102: RH241.1 211.25,90.07 v1(212.33,91.15)
+1.5V_RUNP: length 13.5
  TOP w0.254: v4(229.31,103.61) 229.31,104 230.32,105.02 230.77,105.02 PC402.1 PR402.1
  IN3 w0.254: v4(229.31,103.61) 229.31,102.48 232.24,99.54 235.39,99.54 v4(236.6,100.75)
  vias: v1(242.62,101.61)
+1.05VSP_B+:
  vias: v1(227.26,9.91)
+1.8V_MPLL_PVDD: length 7.1
  TOP w0.102: CV219.1 213.89,143.32 v1(214.31,143.74)
  TOP w0.508: CV219.1 213.89,142.58 213.48,142.18 213.21,142.18 v2(213.05,142.02) ; LV17.1 CV215.1 207.25,142.89 v2(207.49,143.13) 207.49,143.8 207.13,144.16 CV216.1
  BOTTOM w0.254: UV1.H8 212.65,141.62 v2(213.05,142.02) 212.68,142.4 UV1.H7
+1.8V_RUN_CARD:
  vias: v1(245.47,37.35) v2(245.73,32.65) v2(246.36,32.65) v2(249.46,7.35) v2(249.47,6.73)
+1.8V_RUN_GFX: length 104.5
  TOP w0.254: v2(225.64,122.45) 225.65,122.45 225.97,122.77 CV116.1 ; 226.32,117.69 226.32,118.97 225.89,119.41 225.89,119.61 225.89,120.61 225.94,120.66 225.94,121.16 225.26,121.84 CV117.1
  TOP w0.508: v2(204.92,142.24) 204.92,142.19 205.24,141.87 LV17.2 ; CV65.1 CV51.1 229.47,119.65 v2(229.24,119.89) ; CV63.1 227.15,119.21 v2(226.62,119.75) ; 226.32,117.69 226.79,117.22 226.79,116.13 226.51,115.85 226.41,115.85 226.07,115.51 RV241.1 ; v2(224.14,121.59) 224.25,121.59 224.51,121.84 CV117.1
  IN2 w0.254: v2(222.77,119.21) 226.08,119.21 v2(226.62,119.75) 226.62,120.6 225.92,121.3 225.92,122.09 225.64,122.37 v2(225.64,122.45) 225,122.45 v2(224.14,121.59)
  IN2 w0.508: v2(247.94,138.82) 248.23,138.82 248.76,139.36 251.14,139.36 252.54,140.75 v2(252.54,143.18) ; v2(238.49,123.24) 238.49,123.01 238.08,122.61 235.36,122.61 234.86,122.1 233.93,122.1 233.55,122.48 232.98,122.48 232.09,121.59 v2(231.85,121.59)
  IN3 w0.508: v2(204.92,142.24) 204.92,141.9 203.41,140.39 203.41,133.78 201.23,131.6 201.23,121.86 199.68,120.31 199.68,118.58 201.91,116.34 206.75,116.34 208.47,114.63 227.59,114.63 229.79,112.43 v2(230.3,112.43)
  BOTTOM w0.254: v2(231.85,121.59) 232.25,121.99 UV1.AM32 ; v2(225.64,122.45) 225.6,122.42 225.6,122.14 224.85,121.38 UV1.AC33 ; v2(222.77,119.21) 222.77,119.11 223.08,118.8 UV1.AB37
  BOTTOM w0.381: LV16.1 237.25,113.73 237.75,114.23 237.75,114.24 238.06,114.55 v2(238.06,114.57)
  BOTTOM w0.508: v2(240.36,134.38) 240.36,134.37 240.61,134.11 240.61,133.76 LV20.1 ; RV68.1 v2(247.94,138.82)
  vias: v2(230.92,112.84) v2(231.25,117.12) v2(231.45,117.8) v2(231.53,112.97) v2(231.73,112.4) v2(236.5,115.73) v2(238.11,113.8) v2(238.74,113.42) v2(238.87,114.06) v2(252.54,145.17) v2(252.54,144.54) v2(252.54,143.9) v3(238.67,115.84)
+1.8V_RUN_GFX_VDDR4: length 11.9
  TOP w0.102: v2(238.72,134.73) v1(237.75,134.73)
  TOP w0.381: v2(227.69,136.69) 227.58,136.69 227.09,136.2 CV61.1
  TOP w0.508: v2(226.5,137.68) 226.53,137.66 226.83,137.66 227.16,137.33 CV60.1
  BOTTOM w0.254: UV1.AG15 228.05,136.34 v2(227.69,136.69) ; v2(227.69,136.69) 228.05,137.05 UV1.AG13 ; v2(227.69,136.69) 227.2,136.2 UV1.AF15
  BOTTOM w0.305: UV1.AF12 UV1.AF11 UV1.AG11
  BOTTOM w0.381: v2(226.5,137.68) 226.99,137.2 UV1.AF13 ; v2(226.5,137.68) 226.05,138.13 UV1.AD12 ; v2(226.5,137.68) 227.02,138.2 UV1.AF12
  BOTTOM w0.508: CV62.1 239,135.01 v2(238.72,134.73) 238.72,134.2 239.09,133.83 239.19,133.83 239.28,133.74 LV20.2
+1.8V_RUNP: length 18.4
  TOP w0.102: v1(286.88,135.5) 286.27,135.5 285.61,136.16
  TOP w0.254: PC674.1 PC671.1 PR687.1 282.1,129.48 282.81,130.19 v2(283.45,130.19)
  IN1 w0.254: v2(289.82,138.49) 289.82,133.18 289.06,132.42 285.81,132.42 283.57,130.19 v2(283.45,130.19)
+1.8V_SPLL_PVDD: length 15
  TOP w0.102: LV18.1 239.43,134.39 v1(239.04,134)
  TOP w0.508: CV220.1 CV222.1 238.92,137.81 v2(238.7,137.59) ; LV18.1 239.14,135.27 238.69,135.71 v2(238.69,136.03) 239.2,136.54 CV221.1
  IN1 w0.508: v2(238.7,137.59) 238.7,136.04 v2(238.69,136.03)
  IN2 w0.508: v2(238.7,137.59) 237.68,138.62 234.02,138.62 233.51,139.13 233.51,139.54 v2(232.67,140.37)
  BOTTOM w0.254: UV1.AM10 232.3,140 232.66,140.36 232.66,140.37 v2(232.67,140.37)
+1.35V_CPU_VDDQ: length 29.4
  TOP w0.508: v2(141.78,77.3) 141.78,77.29 140.9,76.42 138.02,76.42 135.75,74.14 R926.1 ; RC6.1 144.71,63.94 145.3,64.53 145.3,66.14 145.93,66.78 145.93,68.8 146.39,69.25 147.05,69.25 147.46,69.66 147.46,70.87 147.75,71.16
  BOTTOM w0.305: v2(160.73,85.92) JCPU1.N8 ; v2(150.73,83.92) JCPU1.AB5 ; JCPU1.W8 154.26,86.45 v2(154.73,86.92) ; v2(150.73,79.94) 151.2,80.41 JCPU1.AB2 ; v2(150.73,86.92) JCPU1.AB8 ; v2(147.73,80.92) JCPU1.AE2 ; JCPU1.T2 157.2,80.39 v2(156.73,79.92) ; v2(157.73,85.92) JCPU1.T8 ; v2(154.73,80.92) 154.26,80.45 JCPU1.W2 ; v2(154.73,83.92) 154.26,83.45 JCPU1.W5 ; v2(147.73,83.92) JCPU1.AE5 ; v2(157.73,82.92) JCPU1.T5 ; v2(147.73,86.92) JCPU1.AE8
  vias: v2(144.45,91.2) v2(144.71,89.89) v2(145.73,89.92) v2(146.22,92.6) v2(146.73,89.92) v2(147.73,89.92) v2(148,92.66) v2(148.73,89.92) v2(149.78,92.66) v2(149.74,89.85) v2(150.67,89.86) v2(150.73,88.92) v2(151.56,92.66) v2(151.73,89.92) v2(152.73,89.92) v2(152.73,78.92) v2(153.4,92.66) v2(153.73,89.92) v2(153.73,88.92) v2(154.72,89.89) v2(154.7,72.71) v2(154.7,72.12) v2(154.7,71.54) v2(154.7,70.95) v2(155.24,92.66) v2(155.73,89.92) v2(156.74,89.89) v2(156.89,92.66) v2(157.73,89.92) v2(157.73,88.92) v2(158.66,72.5) v2(158.66,71.92) v2(158.66,71.34) v2(158.66,70.75) v2(158.73,89.9) v2(158.92,92.66) v2(159.73,89.92) v2(160.75,89.89) v2(160.96,92.66) v2(161.73,89.92) v2(162.73,89.89) v2(163.05,92.66) v2(163.23,72.44) v2(163.23,71.86) v2(163.23,71.27) v2(163.23,70.69) v2(163.73,89.92) v2(164.96,92.66) v3(144.53,76.82)
+1.35V_CPU_VDDQ_CHG: length 3.3
  TOP w0.508: Q71.1 137.52,68.82 137.16,68.46 v1(136.45,68.46) 135.75,69.16 R926.2
+1.35V_MEM: length 94.3
  TOP w0.508: v2(143.57,92.99) 143.76,92.8 CC23.2 ; v2(152.95,16.26) 152.83,16.38 CD33.1 ; v2(164.73,16.22) 165.21,15.74 RD22.1 ; RD15.1 128.93,28.59 v2(129.02,28.67) 129.21,28.86 129.21,30.71 128.74,31.18 RD19.1 ; v2(150.27,16.24) 150.29,16.26 CD34.1 ; 145.14,18.22 144.37,17.45 RD2.1 ; v2(156.02,16.24) 155.37,16.89 CD32.1
  IN3 w0.508: v2(147.75,28.59) 147.66,28.67 v2(129.02,28.67) ; v2(160.04,16.38) 160.04,16.05 160.68,15.42 162.15,15.42 162.24,15.51 164.37,15.51 164.73,15.86 v2(164.73,16.22)
  IN4 w0.254: 167.28,91.45 173.13,91.45 173.96,92.28 v2(173.96,93.33) 173.71,93.33 173.25,92.87 173.25,92.67 172.97,92.39 167.41,92.39 167.31,92.3 166.43,92.3 167.28,91.45
  IN4 w0.508: 166.43,92.3 165.24,93.48 144.06,93.48 v2(143.57,92.99)
  BOTTOM w0.356: JDIMM2.75 147.5,22.7 v2(147.44,22.63) ; JDIMM1.118 160.4,33.11 v2(160.4,33.11)
  BOTTOM w0.508: v2(143.57,92.99) 143.76,92.8 CC23.2
  vias: v2(145.15,22.63) v2(145.15,21.11) v2(145.15,19.59) v2(145.18,36.16) v2(145.18,34.64) v2(145.18,33.11) v2(145.76,42.84) v2(145.76,41.31) v2(146.79,65.47) v2(146.79,64.72) v2(146.79,64.13) v2(146.79,63.39) v2(147.44,21.11) v2(147.44,19.59) v2(147.72,44.36) v2(147.72,42.84) v2(147.72,41.31) v2(147.72,37.61) v2(147.72,36.16) v2(147.72,34.64) v2(147.72,33.11) v2(147.72,29.3) v2(149.33,65.47) v2(149.33,64.72) v2(149.33,64.13) v2(149.33,63.39) v2(149.3,24.16) v2(149.3,22.63) v2(149.3,21.11) v2(149.3,19.59) v2(150.21,44.36) v2(150.21,42.84) v2(150.21,41.31) v2(150.21,37.61) v2(150.21,36.16) v2(150.21,34.64) v2(150.21,33.11) v2(150.21,28.91) v2(150.21,27.39) v2(150.83,22.63) v2(150.83,21.11) v2(150.83,19.59) v2(152.35,24.16) v2(152.35,22.63) v2(152.35,21.11) v2(152.35,19.59) v2(152.91,37.61) v2(152.98,44.36) v2(152.98,42.84) v2(152.98,41.31) v2(152.98,36.16) v2(152.98,34.64) v2(152.98,33.11) v2(153.04,27.57) v2(154.22,24.16) v2(154.22,22.63) v2(154.22,21.11) v2(154.22,19.59) v2(154.73,36.16) v2(154.73,34.64) v2(154.73,33.11) v2(154.73,29.11) v2(154.88,28.47) v2(155.75,24.54) v2(155.75,22.25) v2(155.75,19.97) v2(155.9,43.22) v2(155.9,40.93) v2(155.94,37.67) v2(156.51,35.02) v2(156.51,32.73) v2(157.52,24.16) v2(157.52,22.63) v2(157.52,21.11) v2(157.52,19.59) v2(157.68,44.36) v2(157.68,42.84) v2(157.68,41.31) v2(157.67,28.97) v2(157.78,36.16) v2(157.78,34.64) v2(157.78,33.11) v2(157.77,27.5) v2(157.78,37.6) v2(160.34,37.61) v2(160.35,27.46) v2(160.4,44.36) v2(160.4,42.84) v2(160.4,41.31) v2(160.4,36.16) v2(160.4,34.64) v2(160.52,24.16) v2(160.52,22.63) v2(160.52,21.11) v2(160.52,19.59) v2(161.67,34.64) v2(161.67,33.11) v2(161.61,29.11) v2(161.61,27.58) v2(162.05,44.36) v2(162.05,42.84) v2(162.05,41.31) v2(162.04,24.16) v2(162.04,22.63) v2(162.04,21.11) v2(185.28,100.39) v2(185.28,99.81) v2(185.86,100.39) v2(185.86,99.81) v2(186.44,100.39) v2(186.44,99.81) v2(187.03,100.39) v2(187.03,99.81) v2(187.61,100.39) v2(187.61,99.81) v3(148.37,57.9)
+1.35V_MEM_GFX: length 491.4
  TOP w0.254: UV7.B14 211.9,156.09 211.5,155.7 v2(211.5,155.64) ; UV5.K12 192.64,116.69 192.26,117.07 v2(192.2,117.07) 191.85,117.42 UV5.L11 ; UV7.F3 v2(208.31,165.3) UV7.G2 ; UV3.H12 v2(193.05,142.5) ; UV7.B1 v2(212.31,166.1) ; UV3.G4 191.85,136.43 v2(192.2,136.08) 192.26,136.08 UV3.H3 ; UV9.G2 v2(228.51,165.3) UV9.H3 v2(228.51,164.5) UV9.G4 ; UV9.G2 v2(229.31,165.3) UV9.F3 ; UV9.G2 v2(229.31,166.1) ; v2(188.65,121.76) UV5.R5 ; UV3.E5 v2(190.25,137.85) ; UV5.L1 191.85,125.5 v2(191.45,125.89) ; UV7.G2 v2(208.31,166.1) ; UV7.G2 v2(207.51,165.3) UV7.H3 v2(207.51,164.5) UV7.G4 ; v2(208.31,166.1) UV7.G1 v2(208.31,166.9) ; v2(208.31,166.1) UV7.F1 v2(209.11,166.1) ; UV9.P2 UV9.P1 223.32,166.51 223.32,167 v2(223.37,167.05) ; v2(204.75,167.14) 204.75,166.78 204.71,166.75 UV7.L1 UV7.L2 ; v2(189.51,126.05) 189.46,126 189.46,125.51 UV5.P1 UV5.P2 ; UV7.P2 UV7.P1 202.31,166.98 v2(202.35,167.02) ; UV9.E10 v2(230.11,159.7) ; UV3.T1 199.05,134.11 v2(199.44,134.49) ; UV5.E10 v2(196.25,118.7) ; v2(229.31,166.9) UV9.G1 v2(229.31,166.1) ; v2(202.7,158.05) 202.33,157.69 202.31,157.69 UV7.P12 ; UV3.G14 191.85,144.49 191.85,144.4 v2(192.16,144.09) 191.85,143.78 UV3.G13 ; UV9.M14 224.93,156.07 v2(224.93,155.59) ; v2(229.31,166.1) UV9.F1 v2(230.11,166.1) ; UV3.C10 v2(188.65,140.76) ; UV5.J1 193.44,125.5 v2(193.05,125.11) ; UV5.T12 188.17,116.37 v2(188.17,116.29) ; v2(231.75,163.68) 232.11,163.31 UV9.C5 ; UV5.P11 v2(189.85,117.9) UV5.N10 ; UV9.D11 231.3,158.49 v2(230.93,158.86) ; UV9.N10 v2(224.11,159.86) ; v2(192.13,133.52) 191.85,133.8 UV3.G1 ; v2(192.26,123.5) 191.86,123.1 UV5.L4 ; UV3.D1 189.49,134.06 v2(189.49,133.55) ; v2(201.13,164.52) 201.09,164.52 UV7.T3 ; UV3.L13 v2(195.45,144.1) ; UV3.L13 v2(194.65,143.3) UV3.K12 v2(194.65,142.5) UV3.L11 ; UV3.L13 v2(195.45,143.3) UV3.M12 ; v2(195.45,144.1) UV3.M14 v2(196.25,144.1) ; v2(195.45,144.1) UV3.L14 v2(195.45,144.9) ; UV5.H12 v2(194.65,116.29) ; UV7.G14 207.91,156.11 v2(208.31,156.51) 208.71,156.11 UV7.F14 ; UV9.D13 231.31,156.89 v2(231.71,157.29) 231.71,157.3 UV9.D12 ; UV9.K3 226.89,164.51 v2(226.89,164.54) ; v2(226.09,163.73) 225.73,164.1 UV9.L4 UV9.M3 ; UV7.N10 v2(203.11,159.85) ; UV5.G13 195.05,115.91 v2(195.45,116.31) ; v2(227.69,166.12) 227.31,166.5 UV9.J1 ; v2(188.25,136.07) 187.88,135.69 UV3.B3 ; v2(222.14,157.31) 221.76,157.69 UV9.T12 ; v2(196.25,121.9) UV5.E5 ; v2(201.11,158.07) 200.74,157.69 UV7.T12 ; UV5.M14 191.05,115.09 v2(191.05,114.59) ; v2(191.35,133.5) 191.17,133.68 191.17,133.98 UV3.F1 ; v2(221.31,166.8) 221.37,166.8 221.67,166.5 UV9.T1 ; UV3.L2 195.05,134.91 v2(195.45,135.31) ; v2(196.25,137.7) UV3.N5 ; UV7.P3 202.32,164.9 v2(202.73,165.3) ; v2(197.85,136.09) UV3.P3 ; UV5.F14 195.85,115.11 v2(195.45,115.51) 195.05,115.11 UV5.G14 ; UV3.P12 v2(197.05,143.3) ; v2(189.49,145.02) 189.45,144.98 UV3.D14 UV3.D13 ; UV3.B1 187.85,133.61 v2(187.77,133.53) ; v2(230.91,165.3) UV9.D3 ; UV7.D12 v2(210.71,158.09) ; v2(197.05,141.7) UV3.P11 ; v2(189.05,123.5) UV5.P3 ; v2(190.69,116.32) 191.05,116.68 UV5.M12 ; UV5.L14 191.88,115.06 191.88,114.66 191.85,114.63 v2(191.85,114.59) ; v2(204.12,155.53) 204.1,155.55 204.1,155.55 203.91,155.74 UV7.M14 ; UV9.L13 v2(225.31,157.29) UV9.M12 ; UV5.D12 v2(197.85,117.1) ; UV3.D11 v2(189.85,141.7) ; UV7.L13 UV7.L14 204.99,155.82 v2(204.99,155.52) ; UV7.T1 200.66,166.5 v2(200.32,166.85) ; v2(221.33,164.53) 221.7,164.9 UV9.T3 ; CV283.1 206.31,171.03 RV177.1 ; v2(193.05,123.5) UV5.K3 ; UV7.C10 211.11,159.3 v2(210.69,159.71) ; v2(230.11,162.9) UV9.E5 ; UV7.H12 UV7.G13 207.91,156.91 v2(208.31,157.31) ; v2(221.63,155.6) 221.63,156.02 UV9.T14 ; v2(190.2,140.76) 190.25,140.81 UV3.E10 ; v2(190.2,121.76) 190.25,121.81 UV5.N5 ; UV3.P1 v2(197.05,134.49) UV3.P2 ; UV9.P11 v2(223.71,158.9) ; v2(191.23,145.03) 191.23,144.68 UV3.F14 ; v2(209.11,159.7) UV7.E10 ; UV3.P14 v2(197.05,144.9) ; UV3.T12 v2(199.45,143.3) ; UV9.R10 v2(222.11,158.9) ; UV5.G2 v2(194.65,124.3) UV5.H3 v2(194.65,123.5) UV5.G4 ; UV5.G2 v2(195.45,124.3) UV5.F3 ; UV5.G2 v2(195.45,125.1) ; v2(197.05,124.3) UV5.D3 ; v2(205.91,166.11) 206.3,166.5 UV7.J1 ; UV9.F14 229.71,156.11 v2(229.31,156.51) 228.91,156.11 UV9.G14 ; UV5.D14 v2(197.05,115.49) UV5.D13 ; v2(202.71,158.9) UV7.P11 ; UV9.C10 v2(231.71,159.7) ; UV9.P14 223.35,156.06 v2(223.35,155.59) ; UV5.P12 189.45,116.69 189.44,116.69 v2(189.06,117.07) ; UV5.L13 191.84,115.89 v2(191.45,115.51) ; UV7.M12 UV7.L11 204.71,158.43 v2(205.06,158.08) 205.12,158.08 UV7.K12 ; UV3.D3 189.45,135.69 189.47,135.69 v2(189.84,136.05) ; v2(193.85,133.69) UV3.J1 ; v2(202.35,155.55) 202.35,156.06 UV7.P14 ; v2(195.45,136.09) UV3.L4 ; v2(196.25,125.1) UV5.F1 v2(195.45,125.1) ; UV7.M1 203.91,167 v2(203.97,167.06) ; v2(203.06,162.76) 203.11,162.81 UV7.N5 ; UV5.B14 199.05,115.11 v2(199.44,115.49) ; UV7.K3 v2(205.91,164.5) ; UV7.E5 v2(209.11,162.9) ; UV7.D3 v2(209.91,165.3) ; UV7.T14 v2(200.71,155.54) ; UV7.D14 v2(209.91,156.49) UV7.D13 ; UV5.F12 v2(196.25,117.1) ; v2(224.51,163.69) 224.11,163.29 UV9.N5 ; UV3.F3 v2(191.45,135.29) UV3.G2 ; v2(189.49,114.56) 189.49,115.06 UV5.P14 ; UV9.L2 225.71,165.71 224.92,166.5 UV9.M1 224.91,166.9 v2(225.08,167.07) 225.09,167.06 225.1,167.06 225.66,166.5 UV9.L1 ; UV3.N10 v2(196.25,140.9) ; v2(201.11,158.9) UV7.R10 ; UV5.T14 187.77,115.02 v2(187.77,114.56) ; v2(187.45,123.5) UV5.T3 ; v2(230.91,166.9) UV9.D1 ; v2(231.75,155.68) 231.33,156.09 UV9.D14 ; v2(195.45,125.1) UV5.G1 v2(195.45,125.9) ; UV3.T3 199.45,136.09 v2(199.54,136.09) ; UV3.R10 v2(198.65,141.7) ; v2(192.32,141.68) 191.91,142.1 UV3.G11 UV3.F12 ; UV5.D11 197.44,117.5 v2(197.04,117.9) ; UV7.M3 UV7.L4 204.71,164.09 v2(205.09,163.72) ; UV9.B14 232.91,156.11 233.3,156.49 v2(233.31,156.49) ; UV7.F12 v2(209.11,158.09) ; v2(223.68,164.5) 223.31,164.87 UV9.P3 ; UV5.M1 191.06,125.5 v2(191.45,125.11) 191.85,124.71 UV5.L2 ; UV5.G11 v2(195.45,117.1) ; UV9.G13 228.91,156.91 v2(229.31,157.31) ; v2(225.73,155.57) 225.73,156.08 UV9.L14 ; UV5.R10 v2(188.25,117.9) ; v2(233.31,166.1) UV9.B1 ; UV7.C5 v2(211.51,163.7) ; v2(190.65,123.5) UV5.M3 ; v2(187.73,145.02) 187.85,144.91 UV3.B14 ; UV5.B1 v2(198.65,125.9) ; v2(222.92,158.07) 223.3,157.69 223.31,157.69 UV9.P12 ; UV9.K12 226.5,157.69 226.12,158.07 v2(226.06,158.07) 225.71,158.42 UV9.L11 ; v2(187.75,126.05) 187.86,125.93 187.86,125.51 UV5.T1 ; UV3.B12 v2(187.45,142.5) ; UV5.C10 v2(197.85,118.7) ; UV7.D1 v2(209.91,166.9) ; UV3.T14 v2(199.45,144.1) ; v2(209.91,158.9) UV7.D11 ; v2(227.72,157.29) 227.72,157.3 UV9.H12 UV9.G11 ; UV3.D12 v2(189.05,142.5) ; v2(230.11,158.09) UV9.F12 ; v2(188.25,136.9) UV3.C5 ; v2(199.45,124.3) UV5.B3 ; UV5.B12 v2(198.65,117.1) ; v2(196.25,136.09) UV3.M3 ; v2(197.05,125.9) UV5.D1 ; UV7.R5 v2(201.51,162.76) ; v2(222.51,162.76) UV9.R5 ; UV7.B12 v2(211.51,158.09) ; UV7.B3 v2(212.31,165.3) ; UV3.R5 v2(198.65,137.7) ; v2(198.65,122.7) UV5.C5 ; v2(208.31,158.09) UV7.G11 ; v2(233.31,165.3) UV9.B3 ; UV9.B12 v2(233.31,158.09) ; v2(194.65,135.29) UV3.K3
  TOP w0.33: UV3.M1 195.85,134.11 v2(195.45,134.51) 195.05,134.11 UV3.L1
  TOP w0.381: CV237.1 222.45,139.64 RV155.1 222.57,138.69 v2(222.64,138.69) 222.69,138.69 RV153.1 ; RV31.1 216.25,139.57 215.88,139.94 v2(215.88,139.99) ; RV148.1 214.03,131.78 212.09,131.78 211.77,131.46 v2(211.77,131.21) ; RV145.1 215.65,135.4 v2(215.65,134.68) ; CV170.1 218.13,138.36 218.35,138.15 218.97,138.15 v2(219.49,138.67)
  TOP w0.508: RV185.1 v2(182.13,126.63) ; CV48.1 231.77,170.13 CV301.1 231.76,170.04 231.57,169.85 231.57,169.54 v2(231.5,169.48) ; CV333.1 RV191.1 204.1,143.36 204.41,143.67 v2(204.71,143.67) ; RV3.1 CV19.1 v2(217.66,158.13) ; CV168.1 217.85,138.18 CV170.1 ; v2(185.96,108.67) 185.96,108.56 185.53,108.13 RV182.1 ; v2(205.04,124.73) 204.66,124.35 RV140.1 ; v2(182.11,146.2) 182.38,145.94 RV197.1 ; v2(181.97,139.01) 182.16,138.82 RV119.1 CV209.1 ; CV319.1 222.87,153 v2(222.51,153) 222.14,153 CV318.1 ; CV188.1 185.61,111.59 v2(184.93,112.27) ; CV153.1 183.64,111.89 183.64,112.9 183.88,113.14 v2(183.88,113.49) ; CV40.1 RV27.1 224.8,171.03 v2(224.79,171.02) ; CV176.1 184.26,134 v2(184.51,133.74) 184.51,133.36 184.26,133.11 CV147.1 ; CV155.1 CV139.1 ; CV155.1 202.81,119.27 v2(202.48,118.94) ; CV155.1 CV182.1 ; v2(206.99,169.28) 206.99,169.89 CV283.1 ; CV305.1 225.66,153.92 225.75,154.01 225.75,154.04 225.76,154.04 v2(225.77,154.04) ; CV295.1 CV296.1 214.49,169.68 v2(214.87,169.3) ; RV32.1 226.67,138.47 v2(226.49,138.64) ; v2(205.6,121.03) 205.6,121.76 205.05,122.31 CV325.1 ; CV310.1 CV280.1 216.98,171.61 v2(217.03,171.67) ; CV309.1 235.29,153.73 v2(235.42,153.73) ; CV199.1 215.63,165.24 v2(214.74,164.35) ; CV178.1 v2(184.48,128.66) ; v2(184.69,147.01) 184.77,147.09 CV192.1 CV145.1 ; v2(184.69,144.6) 183.96,144.6 183.7,144.86 CV191.1 ; CV293.1 v2(215.12,166.51) ; CV146.1 v2(184.69,143.9) ; v2(232.7,153.59) 232.72,153.59 233.28,153.03 CV316.1 ; CV44.1 184.26,131.97 v2(184.64,132.35) ; v2(181.66,148.72) 181.92,148.98 CV354.1 ; CV294.1 205.19,169.58 v2(205.34,169.43) ; v2(214.11,138.36) 214.25,138.5 214.27,138.5 214.5,138.73 CV163.1 ; v2(215.25,156.6) 215.76,156.1 RV21.1 CV36.1 ; v2(215.52,129.6) 215.78,129.6 216.24,129.15 CV218.1 ; CV284.1 203.36,169.48 v2(203.31,169.43) ; v2(204.82,151.22) 204.87,151.22 205.34,151.69 CV28.1 RV12.1 ; CV281.1 CV297.1 v2(211.44,169.43) ; CV159.1 184.26,136.03 v2(184.51,135.78) 184.51,135.51 184.02,135.01 CV144.1 ; CV34.1 RV19.1 229.22,151.43 229.55,151.1 229.55,150.79 230.13,150.22 v2(230.21,150.22) ; v2(184.51,131.2) 184.01,130.7 CV154.1 ; RV6.1 211.64,151.63 v2(211.64,150.94) ; CV304.1 CV307.1 218.44,167.53 v2(219.16,166.8) ; v2(229.73,171.77) RV209.2 RV210.2 ; CV138.1 184.76,110.63 185.35,110.03 v2(185.35,109.98) 184.97,109.6 CV41.1 ; RV8.1 v2(217.66,161.18) ; CV18.1 194.28,160.91 v2(193.24,159.87) ; v2(210.42,151.08) CV21.1 ; CV133.1 v2(184.69,142.89) ; v2(212.31,126.41) 212.31,126.38 212.86,125.83 213.89,125.83 214.27,125.45 RV28.1 ; v2(200.45,169.41) 200.36,169.49 200.36,169.68 200.1,169.95 CV46.1 199.58,170.79 198.99,170.79 198.75,171.03 RV10.1 CV26.1 ; CV177.1 v2(184.48,129.68) ; RV1.1 v2(193.78,162.94) ; CV24.1 v2(217.66,162.19) ; v2(182.13,123.58) CV322.1 CV330.1
  IN1 w0.508: v2(200.45,169.41) 200.45,169.63 200.92,170.1 202.64,170.1 v2(203.31,169.43) ; v2(224.79,171.02) 228.98,171.02 v2(229.73,171.77)
  IN2 w0.508: v2(193.78,162.94) 194.61,162.1 194.61,161.24 v2(193.24,159.87)
  IN4 w0.508: v2(229.73,171.77) 229.73,171.26 v2(231.5,169.48)
  BOTTOM w0.178: UV7.M3 203.91,164.73 203.51,164.34 203.51,163.7 UV7.N5
  BOTTOM w0.254: v2(191.45,125.89) 191.85,125.5 UV5.L1 ; v2(205.91,164.5) UV7.K3 ; UV3.T12 v2(199.45,143.3) ; v2(188.17,116.29) 188.17,116.37 UV5.T12 ; v2(201.13,164.52) 201.09,164.52 UV7.T3 ; UV7.P14 202.31,155.59 v2(202.35,155.55) ; UV9.L13 225.64,156.82 225.64,156.17 UV9.L14 225.71,155.55 225.73,155.53 v2(225.73,155.57) ; UV9.P14 223.31,155.63 v2(223.35,155.59) ; UV5.P11 v2(189.85,117.9) UV5.N10 ; UV3.D12 v2(189.05,142.5) ; UV9.C10 v2(231.71,159.7) ; UV9.E10 v2(230.11,159.7) ; v2(221.31,166.8) 221.36,166.8 221.67,166.5 UV9.T1 ; UV9.G2 v2(228.51,165.3) UV9.H3 v2(228.51,164.5) UV9.G4 ; UV9.G2 v2(229.31,165.3) UV9.F3 ; UV9.G2 v2(229.31,166.1) UV9.G1 ; v2(229.31,166.9) UV9.F1 v2(230.11,166.1) ; UV3.G4 191.85,136.43 v2(192.2,136.08) 192.59,135.69 UV3.H3 ; v2(187.77,114.56) 187.77,114.58 187.85,114.66 UV5.T14 ; UV3.D1 189.45,133.59 v2(189.49,133.55) ; v2(202.7,158.05) 202.33,157.69 202.31,157.69 UV7.P12 202.39,157.61 202.39,156.98 UV8.D13 ; UV6.D13 v2(197.05,143.3) UV3.P12 ; UV7.T12 201.08,158.07 v2(201.11,158.07) ; v2(231.71,157.29) 231.71,157.3 UV9.D12 ; UV5.G1 v2(195.45,125.1) UV5.G2 ; v2(198.65,144.9) UV3.T14 v2(199.45,144.1) ; v2(226.06,158.07) 226.06,158.08 ; 226.06,158.08 225.71,158.43 UV9.L11 ; 226.06,158.08 226.45,157.69 UV9.K12 ; v2(189.05,123.5) UV5.P3 ; v2(190.2,121.76) 190.25,121.81 UV5.N5 ; UV9.D11 231.3,158.49 v2(230.93,158.86) ; UV3.B12 v2(187.45,142.5) ; v2(209.11,166.1) UV7.F1 v2(208.31,166.9) ; UV1.G23 211.85,129.47 212.07,129.7 v2(212.07,129.94) ; UV1.G17 211.62,133.96 v2(211.62,133.64) ; UV1.L7 215.28,142.4 v2(215.73,141.95) ; UV5.B12 v2(198.65,117.1) ; v2(197.04,117.9) 197.05,117.9 UV5.D11 ; v2(188.25,136.9) UV3.C5 ; UV7.D14 v2(209.91,156.49) ; UV1.G26 211.85,126.87 v2(212.31,126.41) ; UV5.M12 191.05,116.68 v2(190.69,116.32) ; v2(222.51,162.76) UV9.R5 ; v2(231.75,155.68) 231.33,156.09 UV9.D14 ; v2(233.31,165.3) UV9.B3 ; UV7.F3 v2(208.31,165.3) UV7.G2 ; UV5.F3 v2(195.45,124.3) UV5.G2 ; UV5.C10 v2(197.85,118.7) ; UV1.AD11 226.05,139.08 v2(226.49,138.64) ; UV7.K12 205.45,157.69 v2(205.06,158.08) 204.71,158.43 UV7.L11 ; v2(224.93,155.59) 224.93,156.07 UV9.M14 ; v2(188.25,136.07) 188.22,136.07 UV3.B3 ; UV1.L12 214.85,138.2 214.45,137.8 UV1.K13 214.25,138.22 v2(214.11,138.36) 214.25,138.5 UV1.K11 ; UV5.G4 v2(194.65,123.5) UV5.H3 v2(194.65,124.3) UV5.G2 ; v2(196.25,136.09) UV3.M3 ; UV9.T3 221.7,164.9 v2(221.33,164.53) ; UV3.R10 v2(198.65,141.7) ; v2(211.63,137.29) 211.85,137.07 UV1.G14 ; v2(226.89,164.54) 226.89,164.51 UV9.K3 ; UV3.L1 195.05,134.11 v2(195.45,134.51) 195.85,134.11 UV3.M1 ; UV3.T3 199.45,136.09 v2(199.54,136.09) ; v2(233.31,166.1) UV9.B1 v2(232.51,166.9) ; v2(204.99,155.52) 204.99,155.82 UV7.L14 204.64,156.17 204.64,156.82 UV7.L13 UV7.M12 ; v2(220.59,142.02) 220.42,142.02 UV1.U7 ; UV5.R10 v2(188.25,117.9) ; v2(203.97,167.06) 203.91,167 UV7.M1 ; v2(189.84,136.05) 189.47,135.69 189.45,135.69 UV3.D3 189.53,135.61 189.53,134.98 UV6.P2 ; UV3.P14 v2(197.05,144.9) ; v2(195.45,125.9) UV5.F1 v2(196.25,125.1) ; v2(205.09,163.72) 204.71,164.09 UV7.L4 ; UV5.H12 v2(194.65,116.29) UV5.G13 195.05,115.91 v2(195.45,116.31) ; UV7.C10 211.11,159.3 v2(210.69,159.71) ; v2(230.11,158.09) UV9.F12 ; UV5.D12 v2(197.85,117.1) ; UV9.B14 232.91,156.11 233.3,156.49 v2(233.31,156.49) ; v2(229.01,142.47) 229.02,142.47 229.09,142.4 UV1.AJ7 ; UV7.B3 v2(212.31,165.3) ; UV3.E10 190.25,140.81 v2(190.2,140.76) ; UV3.G13 191.85,143.78 v2(192.16,144.09) 191.85,144.4 UV3.G14 ; UV9.P3 223.31,164.87 v2(223.68,164.5) ; UV3.P11 v2(197.05,141.7) ; UV7.P1 202.31,166.97 202.35,167.01 v2(202.35,167.02) ; v2(230.91,166.9) UV9.D1 ; v2(187.77,133.53) 187.85,133.61 UV3.B1 ; UV9.M1 225.04,166.63 225.04,166.71 225.08,166.75 v2(225.08,167.07) ; UV5.T1 187.85,125.9 187.75,126 v2(187.75,126.05) ; UV5.K12 192.59,116.69 192.2,117.08 ; UV7.N10 v2(203.11,159.85) ; UV9.P11 v2(223.71,158.9) ; UV3.L13 v2(194.65,143.3) UV3.K12 v2(194.65,142.5) UV3.L11 ; UV3.L13 v2(195.45,144.1) UV3.L14 ; UV3.L13 v2(195.45,143.3) UV3.M12 ; UV7.P11 v2(202.71,158.9) ; v2(223.11,142.76) 223.11,142.69 222.82,142.4 UV1.Y7 ; UV7.G4 v2(207.51,164.5) UV7.H3 v2(207.51,165.3) UV7.G2 ; UV3.G2 191.78,134.82 191.78,134.17 UV3.G1 192.13,133.82 v2(192.13,133.52) ; v2(189.49,145.02) 189.49,145.01 189.45,144.97 UV3.D14 ; UV7.F14 208.71,156.11 v2(208.31,156.51) 207.91,156.11 UV7.G14 ; UV3.F14 191.05,144.85 v2(191.23,145.03) ; v2(229.01,140.36) 228.65,140 UV1.AG10 ; UV9.L4 225.69,164.1 v2(225.32,163.73) ; v2(225.31,157.29) UV9.M12 ; UV1.G11 211.85,139.16 v2(211.44,139.58) ; v2(224.51,163.69) 224.11,163.3 UV9.N5 ; v2(211.51,166.9) UV7.B1 v2(212.31,166.1) ; UV1.J7 UV1.K8 214.25,141.58 213.46,140.8 UV1.J9 UV1.H10 v2(212.25,140.4) ; v2(197.85,136.09) UV3.P3 ; v2(231.75,163.68) 232.11,163.31 UV9.C5 ; UV7.G1 v2(208.31,166.1) UV7.G2 ; v2(211.77,131.21) 211.88,131.32 211.88,131.77 UV1.G20 ; UV7.H12 UV7.G13 207.91,156.91 v2(208.31,157.31) ; v2(209.91,158.9) UV7.D11 ; UV5.D14 v2(197.05,115.49) ; v2(190.65,123.5) UV5.M3 ; UV5.P1 189.45,125.97 189.51,126.02 v2(189.51,126.05) ; UV7.F12 v2(209.11,158.09) ; v2(188.65,121.76) UV5.R5 ; v2(221.63,155.6) 221.63,155.62 221.71,155.7 UV9.T14 ; UV7.P3 202.32,164.9 v2(202.73,165.3) ; UV9.B12 v2(233.31,158.09) ; v2(225.41,142.53) 225.38,142.51 224.96,142.51 UV1.AC7 ; v2(229.31,157.31) 228.91,156.91 UV9.G13 ; v2(222.14,157.31) 221.76,157.69 UV9.T12 ; v2(196.25,121.9) UV5.E5 ; UV7.T14 v2(200.71,155.54) ; v2(227.89,142.23) 227.72,142.4 UV1.AF7 ; UV1.R11 UV1.N11 UV1.M11 215.85,139.4 215.85,139.96 v2(215.88,139.99) ; UV9.R10 v2(222.11,158.9) ; v2(204.12,155.53) 203.95,155.7 203.95,156.06 UV7.M14 ; UV5.L2 191.85,124.71 v2(191.45,125.11) 191.06,125.5 UV5.M1 ; 192.2,117.08 191.85,117.43 UV5.L11 ; 192.2,117.08 v2(192.2,117.07) ; v2(189.06,117.07) 189.44,116.69 189.45,116.69 UV5.P12 UV4.D13 ; UV1.AK8 UV1.AL9 231.48,140.8 v2(231.86,141.18) ; v2(200.32,166.85) 200.33,166.83 200.33,166.83 200.67,166.5 UV7.T1 ; v2(209.11,159.7) UV7.E10 ; UV3.C10 v2(188.65,140.76) ; v2(196.25,137.7) UV3.N5 ; UV5.G14 195.05,115.11 v2(195.45,115.51) 195.85,115.11 UV5.F14 ; UV7.B14 211.9,156.09 211.5,155.7 v2(211.5,155.64) ; UV5.F12 v2(196.25,117.1) ; v2(196.25,144.1) UV3.M14 v2(195.45,144.9) ; v2(191.85,114.59) UV5.L14 191.93,115.18 191.93,115.81 UV5.L13 ; v2(219.49,138.67) 220.02,139.2 UV1.U11 ; UV1.P7 217.5,142.4 v2(217.04,142.86) ; UV9.N10 v2(224.11,159.86) ; UV9.P1 223.31,166.97 223.37,167.02 v2(223.37,167.05) ; v2(198.65,122.7) UV5.C5 ; v2(203.06,162.76) 203.11,162.81 UV7.N5 ; UV7.D12 v2(210.71,158.09) ; UV5.E10 v2(196.25,118.7) ; UV1.L26 214.7,127.54 v2(214.7,127.7) ; v2(187.45,123.5) UV5.T3 ; UV1.G29 211.85,124.37 v2(211.41,123.93) ; v2(195.45,135.31) 195.05,134.91 UV3.L2 v2(194.65,135.29) UV3.K3 ; v2(230.11,162.9) UV9.E5 ; v2(187.73,145.02) 187.73,145.01 187.85,144.9 UV3.B14 ; UV5.B14 199.05,115.11 v2(199.44,115.49) ; UV7.C5 v2(211.51,163.7) ; UV5.D3 v2(197.05,124.3) UV4.P2 ; UV5.P14 189.45,114.59 v2(189.49,114.56) ; v2(208.31,158.09) UV7.G11 ; v2(225.84,167.08) 225.79,167.08 225.79,166.6 225.71,166.52 UV9.L1 UV9.L2 225.48,165.7 224.91,165.12 UV9.M3 ; v2(191.45,135.29) UV3.F3 ; v2(193.05,123.5) UV5.K3 ; v2(191.05,114.59) 191.05,115.09 UV5.M14 ; UV3.F1 191.05,133.8 v2(191.35,133.5) ; v2(204.75,167.14) 204.75,166.78 204.71,166.75 UV7.L1 UV7.L2 ; UV7.E5 v2(209.11,162.9) ; v2(197.05,134.49) UV3.P1 ; UV8.P2 v2(209.91,165.3) UV7.D3 ; UV7.R5 v2(201.51,162.76) ; UV7.B12 v2(211.51,158.09) ; UV9.G14 228.91,156.11 v2(229.31,156.51) 229.71,156.11 UV9.F14 ; UV3.D11 v2(189.85,141.7) ; UV3.H12 v2(193.05,142.5) ; UV3.F12 191.05,142.89 191.85,142.1 UV3.G11 191.91,142.1 v2(192.32,141.68) ; v2(195.45,136.09) UV3.L4 ; v2(192.26,123.5) 191.86,123.1 UV5.L4 ; UV9.D3 v2(230.91,165.3) UV10.P2 ; UV10.D13 UV9.P12 223.31,157.69 223.3,157.69 v2(222.92,158.07) ; UV3.R5 v2(198.65,137.7) ; v2(197.05,125.9) UV5.D1 ; UV3.T1 199.05,134.11 v2(199.44,134.49) ; UV3.N10 v2(196.25,140.9) ; UV9.G11 UV9.H12 227.72,157.3 v2(227.72,157.29) ; UV5.G11 v2(195.45,117.1) ; UV3.E5 v2(190.25,137.85) ; UV5.B1 v2(198.65,125.9) ; UV7.D1 v2(209.91,166.9) ; v2(199.45,124.3) UV5.B3 ; v2(201.11,158.9) UV7.R10
  BOTTOM w0.305: v2(222.64,138.69) 222.13,139.2 UV1.Y11
  BOTTOM w0.381: v2(215.52,129.6) 215.11,129.2 UV1.L23 ; v2(215.64,130.73) 215.18,131.2 UV1.L21 ; UV1.L16 215.15,135.2 215.67,134.68 v2(215.65,134.68)
  BOTTOM w0.508: CV45.1 213.19,171.51 CV291.1 212.64,171.03 v2(212.12,171.55) 211.84,171.83 211.02,171.83 210.42,171.23 CV292.1 CV285.1 RV208.2 RV206.2 ; CV149.1 v2(196.2,131.61) ; v2(198.75,151.38) 198.14,151.38 197.52,150.76 RV190.2 ; CV141.1 184.01,130.7 v2(184.51,131.2) ; CV137.1 v2(184.48,127.65) ; CV38.1 237.09,148.18 236.72,147.82 v2(235.45,147.82) 234.7,147.82 234.04,148.48 RV23.1 ; RV185.1 v2(182.13,126.63) ; v2(185.96,108.67) 185.96,108.93 185.31,109.58 185.31,109.94 v2(185.35,109.98) ; v2(200.45,169.41) 200.52,169.47 200.52,170.52 201.02,171.03 CV286.1 ; v2(184.64,132.35) 184.51,132.47 CV43.1 ; CV311.1 CV312.1 v2(220.34,170.12) ; v2(181.97,139.01) 181.97,139 182.15,138.82 RV119.1 CV209.1 ; v2(199.25,131.64) CV185.1 ; v2(192.13,131.29) CV148.1 ; RV197.1 182.38,145.94 v2(182.11,146.2) ; v2(188.76,130.37) 188.48,130.64 CV189.1 CV143.1 ; CV298.1 231.26,152.74 CV315.1 231.28,153.38 v2(230.22,154.43) ; CV309.1 235.29,153.73 v2(235.42,153.73) 236.08,153.07 CV320.1 ; v2(204.61,138.42) 204.22,138.8 CV352.1 RV195.1 ; CV297.1 v2(211.44,169.43) ; v2(200.02,149.36) 200.47,149.81 RV189.2 ; CV316.1 233.28,153.01 v2(232.7,153.59) 232.27,153.16 CV306.1 ; v2(218.04,171.67) RV16.1 ; v2(191.12,131.31) CV181.1 ; CV30.1 228.96,171.55 229.18,171.77 v2(229.73,171.77) ; v2(199.96,112.55) 200.52,112.55 201.02,112.04 CV151.1 CV179.1 ; CV354.1 181.92,148.98 v2(181.66,148.72) ; CV303.1 224.77,171.03 v2(224.79,171.02) 224.8,171.03 RV14.1 ; CV142.1 CV140.1 187.83,111.61 v2(187.83,112.47) ; CV133.1 v2(184.69,142.89) ; v2(193.89,128.96) 193.89,129.36 194.1,129.58 CV134.1 CV162.1 ; CV202.1 CV287.1 v2(204.33,169.43) ; RV183.1 v2(197.98,109.96) ; CV200.1 v2(206.36,169.3) ; CV322.1 v2(182.13,123.58) ; CV302.1 CV299.1 231,169.99 v2(231.5,169.48) 232.47,169.48 232.77,169.79 CV47.1 ; v2(197.21,131.64) CV180.1 ; v2(197.25,109.98) 196.96,110.27 CV328.1 ; CV178.1 v2(184.48,128.66) ; v2(195.18,131.6) CV150.1 ; CV42.1 184.27,111.82 v2(184.27,112.48) 184.76,112.97 185.2,112.97 185.78,112.38 CV188.1 ; CV156.1 v2(184.51,133.74) ; CV130.1 v2(184.48,129.68) ; v2(217.03,171.67) CV32.1 ; v2(203.31,169.43) CV135.1 CV288.1 ; CV146.1 v2(184.69,143.9)
  vias: v2(186.65,137.7) v2(186.63,136.87) v2(187.45,136.9) v2(187.4,120.61) v2(187.66,120.03) v2(187.66,119.44) v2(187.98,120.62) v2(188.25,120.03) v2(188.25,119.44) v2(188.58,120.61) v2(188.83,120.03) v2(188.83,119.44) v2(189.16,120.61) v2(190.95,109.13) v2(190.99,108.52) v2(190.99,107.94) v2(191.54,109.14) v2(191.58,108.52) v2(191.58,107.94) v2(192.14,109.13) v2(192.16,108.52) v2(192.16,107.94) v2(192.72,109.13) v2(192.74,108.52) v2(192.74,107.94) v2(193.33,108.52) v2(193.33,107.94) v2(193.94,108.51) v2(193.94,107.92) v2(194.27,109) v2(194.56,108.5) v2(194.57,107.91) v2(195.18,108.5) v2(195.18,107.91) v2(195.72,108.17) v2(205.82,113.13) v2(206.18,113.61) v2(206.66,113.96) v3(194.57,106.54)
