# Allegro board LA-9411P R10-0403.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
+3.3V_RUN_GFX_VDDR3: length 38.4
  TOP w0.102: CV59.1 v1(241.35,111.07)
  TOP w0.254: LV30.2 241.4,112.46 CV59.1 241.35,113.66 CV58.1 241.36,114.88 v2(241,115.24)
  TOP w0.381: v2(227.55,128.57) 227.77,128.35 CV50.1
  TOP w0.457: CV49.1 227.99,129.01 v2(227.55,128.57)
  IN1 w0.254: v2(227.56,127.83) 227.14,127.42 227.14,120.63 227.92,119.85 v2(227.96,119.85)
  IN2 w0.254: v2(228.34,115.75) 228.27,115.82 228.27,119.54 v2(227.96,119.85) ; v2(227.56,127.83) 227.55,127.84 v2(227.55,128.57)
  IN3 w0.254: v2(228.34,115.75) 228.91,115.18 235.25,115.18 236.29,116.22 239.97,116.22 240.5,115.68 240.95,115.24 v2(241,115.24)
  BOTTOM w0.254: UV1.AG23 228.05,129.09 227.55,128.59 ; 227.55,128.59 227.5,128.59 227.05,129.04 UV1.AF23 ; 227.55,128.59 v2(227.55,128.57) ; UV1.AG24 227.92,128.2 v2(227.56,127.83)
  BOTTOM w0.381: UV1.AF24 227.05,128.19 227.41,127.83 v2(227.56,127.83)
+3.3V_RUN_HDD: length 0.7
  TOP w0.102: 114.38,49.42 v3(114.38,50.13)
  vias: v2(113.9,48.53) v2(113.9,47.76) v2(114.41,48.15)
+3.3V_RUN_HDD_R: length 4.7
  TOP w0.102: v2(110.61,46.7) v1(109.91,46.7)
  TOP w0.508: R516.2 R1635.2 111.85,46.7 v2(110.61,46.7)
  BOTTOM w0.508: JSATA1.10 v2(110.61,46.7)
+3.3V_RUN_OZVCC: length 17.4
  TOP w0.203: 249.54,39.61 249.69,39.76 249.69,41.08 249.92,41.31 U38.27
  TOP w0.508: C575.1 249.66,39.61 v2(250.12,39.15)
  BOTTOM w0.762: v2(250.12,39.15) 249.16,40.12 249.16,49.39 250.58,50.82 v1(250.58,51.57) v2(250.58,52.36)
+3.3V_RUN_TPM:
  vias: v1(294.33,129.65) v2(293.39,129.23) v2(294.03,129.22) v2(295,138.86) v2(295.6,138.86) v2(295.8,124.64) v2(296.65,124.68) v2(296.79,129.16) v2(297.38,129.15) v2(297.95,138.91) v2(298.56,138.91)
+3.3V_SPI: length 51.9
  TOP w0.254: v2(195.03,25.6) 194.42,26.21 R3664.1 ; U52.8 190.99,38.58 v2(190.36,39.22) C746.1 190.46,40.07 R3668.1 ; U53.8 197.34,38.9 v2(197.28,38.96) 198.83,40.51 v3(199.25,40.51) 199.73,40.51 C1216.1 R3666.1 ; R3665.1 v2(201.79,25.54)
  BOTTOM w0.254: v2(190.36,39.22) 190.61,38.96 v2(197.28,38.96) 197.79,38.46 201.4,38.46 201.54,38.59 ; 201.54,38.59 202.68,39.73 JSPI1.15 202.68,41.55 202.51,41.72 202.51,42.93 202.17,43.27 RH185.2 ; 201.54,38.59 201.79,38.34 v2(201.79,25.54) 199.92,27.41 196.83,27.41 v2(195.03,25.6)
+3.3V_SUS: length 275.4
  TOP w0.279: U41.17 272.9,39.43 C633.1
  TOP w0.508: R731.1 R732.1 v3(278.24,29.35) 274.76,29.35 v2(274.47,29.06) ; C633.1 273.71,39.51 v2(273.91,39.31)
  IN1 w0.508: v2(274.47,29.06) 274.18,29.35 274.18,38.06 273.91,38.33 v2(273.91,39.31)
  IN2 w0.508: v2(273.91,39.31) 273.11,39.31 272.28,38.48 269.22,38.48 269.03,38.29 258.49,38.29 258.05,37.85 256.52,37.85 254.21,35.53 246.85,35.53 245.18,37.2 v2(245.18,38.34)
  IN2 w1.016: 243.82,105.17 243.82,101.74 248.56,97 v2(252.33,97) 253.82,97 257.28,100.47 269.22,100.47 269.71,100.95
  IN3 w0.508: v2(245.18,38.34) 245.23,38.39 245.23,38.72 246.11,39.6 246.11,40.84 246.77,41.5 247.54,41.5 247.99,41.95 247.99,49.46 247.51,49.95 247.51,51.28 247.99,51.76 248.14,51.76 248.53,52.16 248.53,53.67 249,54.14 249,57.91 248.29,58.62 248.29,60.43 249.13,61.26 249.13,66.6 252.78,70.25 252.78,81.53 251.4,82.9 251.4,85.65 249.79,87.26 249.79,93.36 252.33,95.9 v2(252.33,97)
  IN3 w1.016: 243.34,105.37 243.34,104.15 242.02,102.83 234.07,102.83 231.45,105.45 227.64,105.45 227.01,104.81 223.6,104.81 218.08,110.34 216.34,110.34 214.52,112.15 205.34,112.15 204.33,113.17 200.94,113.17 200.67,113.44 199.53,113.44 198.81,112.72 196.66,112.72 196.13,112.2 189.8,112.2 189.14,111.54 187.43,111.54 185.28,113.7 185.28,121.08 183.6,122.75 183.6,146.7 182.46,147.84 180.78,147.84 175.95,152.67 175.95,160.44 174.79,161.61
  BOTTOM w1.016: 269.07,99.91 269.07,99.05 269.07,98.39 269.43,98.03 269.43,94.53
  vias: v2(173.93,161.94) v2(173.95,161.33) v2(243.72,106.82) v2(243.73,106.18) v2(265.43,83.59) v2(265.44,82.99) v2(268.66,93.31) v2(269.2,93.59) v2(270.44,100.46) v2(270.8,100.98)
+3.3V_TP: length 28.4
  TOP w0.102: R1161.2 262.4,95.58 v3(263.14,94.84)
  TOP w0.254: C755.1 257.86,97.03 JTP1.5
  TOP w0.508: v2(270.7,95.29) 269.53,96.46 R903.1 ; v2(270.1,99.78) 269.97,99.66 R902.1 ; R1161.2 R1162.2 260.46,95.77 v2(259.77,96.46) 259.27,95.95 C755.1
  IN2 w0.508: v2(270.7,95.29) 270.7,96.44 269.72,97.42 260.74,97.42 v2(259.77,96.46)
  BOTTOM w0.508: v2(270.7,95.29) 270.52,95.47 270.52,99.36 v2(270.1,99.78)
+3.3V_VCCPRTCSUS: length 54.2
  TOP w0.508: v2(215.64,86.58) 215.64,86.59 216.3,87.25 RH247.2 216.38,86.94 217.71,85.61 RH240.2 ; CH53.1 212.91,81.23 212.91,82.58 213.36,83.02 213.36,83.36 212.53,84.18 v1(212.53,84.82) 212.53,85.4 v2(213.1,85.97)
  IN2 w0.508: v2(213.1,85.97) 213.69,86.55 215.62,86.55 v2(215.64,86.58)
  IN3 w0.508: v2(215.64,86.58) 216.07,86.58 218.68,83.97 218.68,80.09 221.74,77.03 221.74,76.28 221.23,75.77 v2(221.23,75.79)
  IN4 w0.254: 207.88,66.1 207.88,64.51 v2(207.75,64.38)
  IN4 w0.381: 207.88,66.1 207.88,66.76 208.58,67.46 208.58,68.17 207.16,69.6 207.16,70.39 207.82,71.06 208.36,71.06 209.01,71.71 209.01,72.31 209.56,72.86 209.56,74.66 210.29,75.39 210.42,75.39 211.9,76.87 213.13,76.87 213.7,77.44 215.02,77.44 218.19,74.27 219.5,74.27 220.97,75.73 221.16,75.73 221.23,75.81 v2(221.23,75.79)
  BOTTOM w0.254: UH1.K8 207.22,64.38 v2(207.75,64.38)
+3.3V_VTR: length 14.1
  TOP w0.254: R837.2 R834.2 283.27,124.29 282.84,123.86 282.53,123.86 v2(282.2,123.53) ; v2(287.98,120.78) 287.83,120.94 C739.1 C775.1 288.72,121.13 288.62,121.04 v1(288.62,120.47) 288.62,119.87 288.72,119.78 U51.A22
  IN2 w0.508: v2(282.2,123.53) 282.85,123.53 283.21,123.89 284.53,123.89 285.01,123.41 285.18,123.41 285.97,122.61 286.86,121.73 287.56,121.73 288.1,121.2 288.1,120.89 v2(287.98,120.78)
+3.3V_VTR_ADC: length 4.9
  TOP w0.254: U51.A58 v1(288.22,107.27) 287.47,106.53 C736.1
  TOP w0.305: R839.2 289.35,105.35 288.44,106.26 C757.1
  TOP w0.381: C757.1 C736.1
+3.3V_WLAN: length 22.2
  TOP w0.508: v2(270.98,174.93) 270.98,173.25 v2(271.48,172.75) 271.86,172.36 v2(273.86,172.36) ; v2(274.71,177.43) 274.71,177.34 v3(273.08,175.71) 272.4,175.03 v2(272.4,174.99)
  IN2 w0.508: v2(270.98,174.93) 272.33,174.93 v2(272.4,174.99)
  BOTTOM w0.457: v2(271.48,172.75) 271.41,172.75 270.87,172.21 Q124.2
  BOTTOM w0.508: R718.2 271.89,175.5 v2(272.4,174.99) 272.91,175.5 R720.2 ; v2(273.86,172.36) 274.01,172.21 Q89.2 ; R729.2 R728.2 R725.2 265.12,173.09 265.36,173.33 265.36,176.31 265.06,176.62 C607.2 ; Q124.5 270.9,173.83 270.9,174.85 v2(270.98,174.93) 270.9,175.01 270.9,175.68 R705.2
  vias: v2(269.4,190.53) v2(270.01,190.51) v2(270.63,190.51)
+3VALWP: length 26.7
  IN4 w0.254: v4(148.19,1.28) 148.19,1.55 147.73,2.01 147.14,2.01 146.35,1.22 132.05,1.22 131.72,1.55 131.72,8.41 131.94,8.62 v4(131.94,10.05)
  BOTTOM w0.254: PR100.1 v4(148.19,1.28)
  vias: v1(131.81,10.81) v4(130.41,10.05) v4(130.41,9.28) v4(130.56,8.56) v4(131.17,9.92) v4(131.17,9.28) v4(131.2,8.56) v4(132.7,9.92) v4(132.7,9.28) v4(132.7,8.62) v4(133.46,11.19) v4(133.46,10.43) v4(133.46,9.66) v4(133.46,8.9) v4(134.09,11.19) v4(134.09,10.43) v4(134.09,9.66) v4(134.22,8.78)
+5V_ALW: length 432.2
  TOP w0.102: v2(217.33,10.82) 217.33,10.76 v3(217.79,10.3)
  TOP w0.203: U101.4 324.8,199.12 324.47,198.79 v2(324.47,198.56) ; v2(170.38,165.25) 170.35,165.28 170.35,165.32 170.4,165.37 U104.4 ; v2(247.86,143.62) 247.76,143.52 U103.4
  TOP w0.254: JBTB1.18 54.5,199.18 54.38,199.06 54.38,199.03 54.21,198.86 54.21,198.04 54.5,197.75 54.5,197.67 C998.1
  TOP w0.508: PR635.2 303.45,162.45 302.89,161.89 302.89,160.25 303.39,159.75 303.9,159.75 305.54,158.11 307.63,158.11 309.23,156.51 v4(309.23,156.22) ; 345,216.36 344.33,217.03 332.06,217.03 330.56,215.53 v2(330.49,215.53) 329.61,216.41 326.7,216.41 325.76,215.47 323.81,215.47 323.11,214.77 v2(319.9,214.77) ; v2(54.72,198.39) 55.1,198.01 55.1,197.32 C998.1 ; v2(322.63,161.61) 323.41,161.61 324.86,163.06 Q79.3 ; Q86.3 58.67,191.89 58.19,191.4 v2(57.26,191.4) 56.13,192.53 Q82.3 ; PU701.8 97.7,167.78 97.1,168.38 v2(97.1,168.99) ; v2(53.83,194.07) 53.59,193.83 Q80.3 ; v2(93.39,168.99) 93.2,169.18 91.65,169.18 91.21,168.73 90.86,168.73 90.33,168.2 PR723.2 ; Q75.3 327.14,156.37 322.08,156.37 v2(321.76,156.69) ; PR520.2 126.54,152.92 v4(126.79,152.67) ; PC724.1 101.24,168.55 v2(101.24,169) ; PR843.2 147.18,174.95 v4(147.35,175.13)
  IN1 w0.508: v2(308.85,149.11) 308.85,147.35 305.2,143.7 286.39,143.7 282.42,147.68 v2(282.39,147.68) ; v2(217.33,10.82) 216,12.15 214.1,12.15 212.38,13.88 212.38,15.32 211.12,16.57 v4(211.12,16.65) ; v4(224.26,35.06) 226.28,37.08 226.28,43.97 228.52,46.22 v2(228.81,46.22)
  IN2 w0.508: v2(223.58,50.46) 223.58,50.23 224.19,49.62 225.61,49.62 228.81,46.42 v2(228.81,46.22) ; v2(93.39,168.99) 94.01,168.36 95.5,168.36 96.12,168.99 v2(97.1,168.99) 97.7,168.39 100.86,168.39 101.24,168.77 v2(101.24,169) ; v4(309.23,156.22) 310.35,157.34 316.28,157.34 317.08,158.14 320.49,158.14 321.76,156.87 v2(321.76,156.69) ; v2(324.47,198.56) 324.47,195.62 322.58,193.73 310.04,193.73 308.55,192.24 305.54,192.24 303.16,189.85 v2(301.6,189.85) ; v2(264.4,132.84) 266.86,132.84 267.22,133.2 269.08,133.2 270.91,135.03 272.31,135.03 273.07,134.26 273.07,133.3 273.41,132.96 275.39,132.96 275.68,133.25 278.47,133.25 278.75,133.53 v2(278.79,133.53)
  IN3 w0.508: v2(330.49,215.53) 330.49,209.69 328.02,207.23 328.02,202.81 324.79,199.57 324.79,198.88 v2(324.47,198.56) ; v4(309.23,156.22) 309.6,156.22 309.96,155.85 309.96,155.74 309.99,155.71 309.99,154.44 310.88,153.56 310.88,151.14 v2(308.85,149.11) ; v2(170.38,165.25) 169.85,165.25 169.42,165.68 167.41,165.68 166.34,164.61 166.34,163.21 161.96,158.83 v2(161.96,158.27) ; v2(301.6,189.85) 300.44,191 294.78,191 292,188.23 286.49,188.23 286,187.73 286,182.93 285.27,182.2 v2(284.76,182.2)
  IN4 w0.508: v2(57.26,191.4) 57.26,193.18 56.37,194.07 v2(53.83,194.07) ; v2(322.63,161.61) 322.04,161.02 322.04,156.97 v2(321.76,156.69) ; v2(34.53,192.8) 35.57,193.84 53.6,193.84 v2(53.83,194.07) ; v2(53.83,194.07) 53.83,196.74 54.72,197.62 v2(54.72,198.39) ; v4(147.35,175.13) 147.35,173.91 145.64,172.2 145.64,170.24 146.41,169.47 146.41,167.01 147.07,166.35 147.07,159.38 147.89,158.57 160.32,158.57 v2(160.64,158.25)
  BOTTOM w0.203: v2(284.76,182.2) 284.76,182.21 284.72,182.17 U100.4 ; U102.4 301.66,189.92 v2(301.6,189.85)
  BOTTOM w0.254: C715.1 320.11,217.07 U2.5
  BOTTOM w0.508: v4(147.35,175.13) 147.35,175.5 148.51,176.66 150.9,176.66 151.33,176.22 151.33,175.77 151.44,175.65 ; 151.44,175.65 v2(150.91,175.12) 150.86,175.07 PR14.1 ; 151.44,175.65 PU1.5 ; v2(247.86,143.62) 249.11,143.62 251.28,145.8 263.17,145.8 264.98,143.98 264.98,139.15 266.11,138.02 266.11,137.05 265.45,136.39 265.45,134.68 264.4,133.63 v2(264.4,132.84) 263.85,132.84 R752.1 ; v2(322.63,161.61) 322.63,161.92 322.87,162.17 322.87,164.34 322.98,164.45 322.98,165.58 322.92,165.65 322.92,165.76 322.39,166.29 322.39,168.97 322.89,169.48 326.37,169.48 327.34,168.52 328.74,168.52 v2(328.98,168.76) ; v2(278.79,133.53) 278.8,133.54 278.8,135.48 280.64,137.32 280.64,143.29 281.43,144.08 281.43,146.71 v2(282.39,147.68) ; R1629.1 219.62,52.79 220.1,52.31 222.13,52.31 223.07,51.37 223.07,50.96 v2(223.58,50.46) ; v2(101.24,169) 101.23,168.99 101.23,168.57 PC724.1 ; v4(126.79,152.67) 128.28,154.15 128.28,158.29 126.34,160.24 PR530.2 ; R1614.2 319.71,214.01 319.92,214.22 319.92,214.74 v2(319.9,214.77) 319.08,214.77 R816.2 C715.1 ; v4(309.23,156.22) PR645.2 ; R957.2 v2(330.49,215.53)
  vias: v2(33.89,191.53) v2(34.53,192.16) v2(34.53,191.53) v2(160.02,157.61) v2(160.64,157.62) v2(161.27,158.25) v2(161.27,157.62) v2(161.91,157.62) v2(240.36,11.44) v2(348.34,208.06) v2(348.34,207.44) v2(349.11,208.04) v2(349.11,207.44) v2(349.66,222.26) v2(349.66,221.63) v2(349.74,208.29) v2(350.25,222.26) v2(350.25,221.63) v2(350.88,222.26) v2(350.88,221.63) v2(351.52,222.26) v2(351.52,221.63) v3(199.55,101.99) v3(349.16,202.02) v4(165.91,2.96) v4(165.96,2.29) v4(166.62,2.96) v4(166.68,2.26) v4(167.28,2.97) v4(167.34,2.27) v4(168,3.04) v4(168.02,2.29) v4(168.58,5.7) v4(168.56,5.05) v4(168.69,3) v4(168.77,2.3) v4(169.22,5.69) v4(169.22,5.02) v4(170.8,3.06) v4(171.43,3.06) v4(172.19,3.06) v4(172.96,3.06) v4(173.72,3.06) v4(174.35,3.06) v4(174.39,3.85) v4(187.09,4.87) v4(187.75,4.17) v4(187.79,4.86) v4(188.44,4.85) v4(188.45,4.18) v4(188.45,3.51) v4(188.45,2.82) v4(195.36,101.26) v4(196.07,101.26) v4(196.74,101.26) v4(197.43,101.26) v4(198.18,101.26) v4(198.88,101.26) v4(199.53,101.26) v4(222.36,35.06) v4(222.61,34.43) v4(222.99,35.06) v4(223.25,34.43) v4(223.63,35.06) v4(223.88,34.43) v4(224.52,34.43) v4(226.87,11.69) v4(226.9,12.38) v4(227.55,12.37) v4(227.57,11.7) v4(228.19,12.37) v4(228.2,11.7)
+5V_ALW2: length 1.4
  BOTTOM w0.102: PC118.1 v3(152.17,10.11)
+5V_HDD: length 3.1
  TOP w0.508: R506.1 v3(112.84,37.68) 112.86,37.71 112.86,39.43 112.84,39.46 112.89,39.51
  vias: v2(113.9,41.69) v2(113.9,41.03) v2(113.9,40.27) v2(113.93,39.55)
+5V_HDMI_DDC: length 6.1
  TOP w0.102: v1(21.4,193.64) R67.2
  TOP w0.254: D2.1 24.07,193.64 R67.2 22.72,194.11 23.15,194.54 23.15,195.19 R69.1 R70.1
+5V_MOD: length 5
  TOP w0.102: JSATA2.10 231.95,43.06 v3(229.95,41.06)
+5V_RUN: length 418.7
  TOP w0.203: U6.16 187.74,173.91 188.12,174.29 188.97,174.29 C30.1
  TOP w0.305: C52.1 266.16,86.63 265.3,86.63 264.74,86.07 JUSH1.7 262.65,86.07 v2(262.5,85.92)
  TOP w0.508: PR501.2 157.21,158.55 v4(158.58,159.92) ; 38.46,196.28 35.84,193.65 33.6,193.65 31.32,191.37 D2.2 24.07,191.37 R67.1 ; v2(188.68,175.15) 188.68,174.97 189.12,174.52 C30.1
  TOP w1.016: 22.21,211.59 23.1,212.48 30.97,212.48 36.81,206.64 36.81,198.18 37.83,197.17
  IN1 w0.508: v2(187.18,166.69) 186.46,165.96 182.32,165.96 181.26,164.91 179.52,164.91 179.23,165.2 v2(179.23,166.71) 179.23,167.33 178.53,168.03 178.53,168.33 178.52,168.34 178.52,169.14 177.55,170.1 v2(176.07,170.1) ; v2(188.68,175.15) 187.94,174.41 187.94,171.46 188.86,170.55 v2(188.86,169.38)
  IN2 w0.508: v2(188.68,175.15) 188.68,175.74 189.66,176.72 190.56,176.72 192.57,178.73 192.93,178.73 193.53,179.32 195.14,179.32 195.65,178.82 195.65,178.41 196.02,178.04 198.47,178.04 199.49,177.03 202.46,177.03 v2(202.61,176.87) ; v2(188.86,169.38) 188.86,167.75 187.79,166.69 v2(187.18,166.69) ; 267.44,116.47 268.05,115.86 v2(278.41,115.86) ; v2(179.23,166.71) 177.86,168.08 176.08,168.08 174.94,169.23 173.39,169.23 172.7,168.54 172.7,168.03 171.43,166.76 168.89,166.76 165.31,163.18 v2(165.35,163.18)
  IN3 w0.508: 96.52,159.71 101.99,159.71 105.02,156.68 114.28,156.68 114.69,157.09 117.39,157.09 118.33,156.15 123.02,156.15 123.73,156.86 125.27,156.86 127.47,154.66 132.43,154.66 132.99,155.22 132.99,156.2 134.25,157.45 134.96,157.45 135.09,157.59 135.35,157.85 151.37,157.85 151.73,158.2 154.72,158.2 155.64,159.13 157.79,159.13 v4(158.58,159.92) 160.55,161.89 164.05,161.89 v2(165.35,163.18)
  IN3 w1.524: 113.94,85.76 112.59,87.11 112.59,87.3 108.23,91.67 108.23,111.61 109.53,112.91 112.62,112.91 113.75,114.05 113.75,123.22 112.24,124.72 112.24,137.88 106.85,143.27 106.85,145.49 105.04,147.31 105.04,147.54 105.01,147.56 105.01,151 101.43,154.58 98.81,154.58 96.52,156.88 96.52,159.71 93.39,162.84 89.29,162.84 82.1,170.03 78.67,170.03 77.36,171.34 75.29,171.34 75.19,171.44 74.26,171.44 74.25,171.42 74.23,171.44 73.31,171.44 73.21,171.34 70.18,171.34 68.29,169.44 61.74,169.44 60.54,170.65 60.54,174.04 63.27,176.77 63.27,183.64 56.09,190.82 56.09,193.46 52.64,196.91
  IN4 w0.508: v4(308.08,155.71) 307.96,155.84 307.96,156.6 308.21,156.86 309.49,156.86 309.86,156.49 309.96,156.38 309.96,154.6 310.75,153.81 313.29,153.81 313.77,153.33 v2(313.77,153.07) 314.13,153.43 321.8,153.43 322.33,152.9 322.33,151.41 321.88,150.95 318.74,150.95 314.08,146.29 314.08,135.55 v2(313.55,135.01)
  BOTTOM w0.381: C365.1 178.13,170.74 178.13,171.48 178.5,171.85 U24.5 ; U21.5 201.37,175.85 201.86,176.34 C369.1
  BOTTOM w0.508: C369.1 202.46,177.03 v2(202.61,176.87) ; C365.1 176.49,170.52 v2(176.07,170.1) ; PR641.2 307.2,156.6 v4(308.08,155.71)
  vias: v2(51.42,198.06) v2(51.67,198.69) v2(52.05,198.06) v2(114.55,84.24) v2(114.58,83.55) v2(114.59,82.84) v2(115.17,84.25) v2(115.16,83.53) v2(115.17,82.82) v2(116.25,41.26) v2(116.25,40.55) v2(116.25,39.83) v2(116.25,39.13) v2(116.19,38.44) v2(116.19,37.73) v2(249.92,84.01) v2(250.16,84.57) v2(250.17,83.45) v2(262.33,83.57) v2(262.33,82.98) v2(266.43,117.11) v2(266.43,116.47) v2(266.43,115.84) v2(275.4,136.4) v2(275.4,135.76) v2(275.4,135.13) v2(313.5,134.4) v2(314.16,134.7) v2(334.03,157.04) v2(333.98,156.29) v2(334.55,156.58) v2(342.73,181.11) v2(343.29,181.5) v2(343.3,180.91) v3(48.22,196.15) v4(217.03,29.35) v4(217.69,29.31) v4(217.69,28.68) v4(218.04,28.08) v4(218.32,29.31) v4(218.32,28.68) v4(218.96,29.31) v4(218.96,28.68) v4(219.31,28.08) v4(219.59,29.31) v4(219.59,28.68) v4(220.33,28.59) v4(223.76,45.35) v4(223.76,44.72) v4(224.39,45.35) v4(224.39,44.72) v4(225.03,45.35) v4(225.03,44.72)
+5V_USB_CHG_PWR:
  vias: v2(344.66,224.17) v2(344.66,223.53) v2(345.3,224.17) v2(345.3,223.53) v3(336.86,222.8)
+5V_USB_PWR2_3:
  vias: v3(349.59,191.6) v4(350.13,210.93) v4(350.13,210.3) v4(350.77,210.93) v4(350.77,210.3) v4(353.65,192.9) v4(353.65,192.27) v4(354.29,192.9) v4(354.29,192.27)
+5V_USB_PWR4: length 3.8
  TOP w0.102: JUSB4.1 16.7,186.6 v3(18.02,185.28)
+5VALWP: length 34.6
  TOP w0.102: v4(151.24,1.28) 151.37,1.28 v1(152.26,2.17)
  IN1 w0.254: v4(151.24,1.28) 152.08,2.12 154.25,2.12 154.91,1.46 169.45,1.46 170.04,2.04 170.04,5.26 v2(170.42,5.64)
  IN4 w0.508: v4(151.24,1.28) 151.77,1.82 151.77,7.1 151.3,7.57 v4(151.3,8.9)
  BOTTOM w0.203: PU100.14 151.13,8.73 v4(151.3,8.9)
  BOTTOM w0.508: PR101.1 v4(151.24,1.28)
+AVCC33: length 1
  TOP w0.203: v2(171.71,138.61) 171.77,138.66 U27.5
  vias: v1(171.18,139.71)
+DVCC33: length 0.9
  TOP w0.203: U27.18 175.42,134.31 v2(175.55,134.19)
  vias: v1(179.94,134.38) v2(177.21,134.2) v2(177.82,134.19)
+DVDD_CORE: length 5.1
  TOP w0.102: v1(334.58,177.23) 334.97,176.83 C954.1
  TOP w0.254: 336.9,174.56 337.38,174.09 U74.1
  TOP w0.508: 336.9,174.56 336.86,174.56 335.77,175.65 C954.1
+VCC_CORE:
  vias: v2(124.06,129.93) v2(124.06,127.9) v2(124.82,131.08) v2(124.82,129.04) v2(125.84,127.9) v2(126.09,131.71) v2(126.09,130.31) v2(126.09,128.92) v2(127.49,127.9) v2(129.27,127.9) v2(129.65,132.47) v2(130.41,128.92) v2(130.54,131.58) v2(130.54,130.06) v2(130.79,127.9) v2(131.68,130.82) v2(131.81,128.79) v2(132.7,131.71) v2(132.95,130.06) v2(133.71,127.65) v2(134.73,128.66) v2(134.86,127.65) v2(136,130.7) v2(136.38,131.71) v2(136.51,128.92) v2(137.14,127.65) v2(137.78,130.7) v2(138.35,122.06) v2(138.46,128.27) v2(139.3,131.84) v2(139.3,130.06) v2(139.3,128.92) v2(141.05,128.03) v2(141.08,118.25) v2(142.27,118.06) v2(142.73,127.96) v2(142.73,102.92) v2(142.71,101.1) v2(143.62,128.92) v2(143.75,131.71) v2(143.75,130.19) v2(143.68,117.34) v2(143.68,116.2) v2(143.68,115.06) v2(143.73,113.92) v2(143.73,112.92) v2(143.73,111.92) v2(143.73,110.92) v2(143.73,109.92) v2(143.73,108.92) v2(143.73,107.92) v2(143.73,106.92) v2(143.73,105.92) v2(143.73,104.92) v2(143.73,103.92) v2(143.73,102.92) v2(143.84,118.16) v2(144.13,100.47) v2(144.25,102.12) v2(144.68,118.29) v2(144.68,117.34) v2(144.68,116.2) v2(144.68,115.06) v2(144.73,113.92) v2(144.73,112.92) v2(144.73,111.92) v2(144.73,110.92) v2(144.73,109.92) v2(144.73,108.92) v2(144.73,107.92) v2(144.73,106.92) v2(144.73,105.92) v2(144.73,104.92) v2(144.73,103.92) v2(144.73,102.92) v2(144.89,128.41) v2(144.89,102.12) v2(145.78,127.39) v2(145.73,112.92) v2(145.73,110.92) v2(145.73,108.92) v2(145.73,106.92) v2(145.73,104.92) v2(145.73,102.92) v2(145.78,102.12) v2(146.16,100.47) v2(146.54,102.12) v2(146.68,118.29) v2(146.68,117.34) v2(146.68,116.2) v2(146.68,115.06) v2(146.73,113.92) v2(146.73,112.92) v2(146.73,111.92) v2(146.73,110.92) v2(146.73,109.92) v2(146.73,108.92) v2(146.73,107.92) v2(146.73,106.92) v2(146.73,105.92) v2(146.73,104.92) v2(146.73,103.92) v2(146.73,102.92) v2(147.73,112.92) v2(147.73,110.92) v2(147.73,108.92) v2(147.73,106.92) v2(147.73,104.92) v2(147.73,102.92) v2(147.94,102.12) v2(148.32,100.47) v2(148.68,118.29) v2(148.68,117.34) v2(148.68,116.2) v2(148.68,115.06) v2(148.73,113.92) v2(148.73,112.92) v2(148.73,111.92) v2(148.73,110.92) v2(148.73,109.92) v2(148.73,108.92) v2(148.73,107.92) v2(148.73,106.92) v2(148.73,105.92) v2(148.73,104.92) v2(148.73,103.92) v2(148.73,102.92) v2(148.7,102.12) v2(149.73,112.92) v2(149.73,110.92) v2(149.73,106.92) v2(149.73,104.92) v2(149.73,102.92) v2(150.1,102.12) v2(150.22,100.47) v2(150.75,118.29) v2(150.75,117.34) v2(150.75,116.2) v2(150.68,115.06) v2(150.73,113.92) v2(150.73,112.92) v2(150.73,111.92) v2(150.73,110.92) v2(150.73,109.92) v2(150.73,108.92) v2(150.73,107.92) v2(150.73,106.92) v2(150.73,105.92) v2(150.73,104.92) v2(150.73,103.92) v2(150.73,102.92) v2(150.73,102.16) v2(150.99,128.54) v2(151.29,98.16) v2(151.73,112.92) v2(151.73,110.92) v2(151.73,108.92) v2(151.73,106.92) v2(151.73,104.92) v2(151.73,102.92) v2(151.73,102.16) v2(151.93,98.16) v2(152.13,131.84) v2(152.13,130.19) v2(152.26,129.17) v2(152.26,100.47) v2(152.55,98.16) v2(152.74,115.06) v2(152.73,113.92) v2(152.73,112.92) v2(152.73,111.92) v2(152.73,110.92) v2(152.73,109.92) v2(152.73,108.92) v2(152.73,107.92) v2(152.73,106.92) v2(152.73,105.92) v2(152.73,104.92) v2(152.73,103.92) v2(152.73,102.92) v2(152.88,118.29) v2(152.88,117.34) v2(152.88,116.2) v2(152.89,102.12) v2(153.2,128.63) v2(153.73,105.92) v2(153.73,104.92) v2(153.73,102.92) v2(154.03,102.12) v2(154.29,100.47) v2(154.57,117.85) v2(154.72,128.65) v2(154.73,104.92) v2(154.73,103.92) v2(154.73,102.92) v2(154.73,102.16) v2(154.95,115.34) v2(155.27,116.45) v2(155.74,104.92) v2(155.73,103.92) v2(155.73,102.92) v2(155.97,117.91) v2(156.03,115.37) v2(156.07,102.12) v2(156.32,100.47) v2(156.57,131.97) v2(156.57,130.06) v2(156.59,128.98) v2(156.73,103.92) v2(156.73,102.92) v2(156.83,102.12) v2(157.73,103.92) v2(157.73,102.92) v2(158.1,102.12) v2(158.35,100.47) v2(158.73,103.92) v2(158.74,102.92) v2(158.86,102.12) v2(159.73,103.92) v2(159.73,102.92) v2(160.13,102.12) v2(160.38,100.47) v2(160.73,103.92) v2(160.73,102.92) v2(160.89,102.12) v2(161.73,103.92) v2(161.73,102.92) v2(162.16,102.12) v2(162.29,100.47) v2(162.73,104.92) v2(162.73,103.92) v2(162.73,102.92) v2(162.92,102.12) v2(163.73,104.92) v2(163.73,103.92) v2(163.73,102.92) v2(164.32,102.12) v2(164.45,100.47) v2(164.61,103.89) v2(164.73,102.92) v2(165.08,102.12) v2(166.73,103.92) v3(134.7,131) v4(138.79,120.92) v4(138.92,119.27) v4(139.49,122.25) v4(139.68,121.42) v4(141.08,121.42) v4(142.22,121.42) v4(142.92,121.08) v4(142.98,119.27) v4(143.11,123.84) v4(143.11,122.57) v4(145.65,122.92) v4(145.65,118.87) v4(145.74,120.57) v4(145.91,125.74) v4(145.91,124.73) v4(147.94,123.33) v4(148.06,128.41) v4(148.06,126.5) v4(148.19,119.27) v4(148.56,123.2) v4(148.95,126.5) v4(149.21,123.33) v4(150.73,123.08) v4(151.02,120.87) v4(151.11,127.14) v4(151.11,123.84) v4(152.64,126.25) v4(153.4,124.35) v4(155.18,121.42)
+VCCADAC: length 8.3
  TOP w0.102: 221.85,80.15 222.84,79.16 v1(223.27,79.16)
  TOP w0.508: v2(217.48,76.68) 217.96,77.16 218.8,77.16 219.28,77.64 219.28,77.85 CH19.1 CH18.1 220.91,79.47 CH20.1 221.61,80.15 LH1.2
  BOTTOM w0.254: v2(217.48,76.68) 217.48,76.68 217.27,76.46 UH1.P45
+VCCIO2PCH: length 65.6
  TOP w0.254: CH61.1 199.28,69.79 199.71,69.79 199.95,69.54 200.37,69.54 202.08,71.25 202.56,71.25 v2(202.67,71.14)
  TOP w0.508: v2(188.2,76.72) 189.02,77.55 189.08,77.55 190.1,78.56 190.1,80.15 188.83,81.42 v1(188.83,82.69) 188.83,84.9 185.36,88.37 v2(185.36,95.01) ; CH61.1 198.45,68.96 CH62.1 197.84,67.63 CH60.1 198.17,67.28 198.17,66.74 197.77,66.34 197.77,65.97 v2(197.94,65.8)
  IN1 w0.508: v2(197.94,65.8) 197.66,66.08 195.75,66.08 195.39,66.43 195.39,66.72 194.99,67.12 194.31,67.12 v2(194.06,67.36)
  IN2 w0.508: v2(188.2,76.72) 188.95,75.97 188.95,74.82 192.69,71.07 192.69,68.73 v2(194.06,67.36)
  IN4 w0.508: v2(185.36,95.01) 183.35,95.01 180.04,98.31 180.04,102.69 v2(180.51,103.16)
  BOTTOM w0.254: UH1.AJ14 203.67,71.23 203.4,70.96 UH1.AJ12 202.85,70.96 v2(202.67,71.14)
  BOTTOM w0.508: v2(180.51,103.16) 180.79,102.88 RC105.1 180.37,101.08 179.08,99.78 CC137.1 179.07,99.64 RC106.2
+VCCIO2PCH_R: length 9.1
  BOTTOM w0.102: v1(179.45,98.34) 179.36,98.25 RC106.1
  BOTTOM w0.508: RC106.1 177.1,98.25 175.59,99.76 175.59,100.62 174.76,101.45 JCPU1.A23
+VCCIO_OUT: length 406.8
  TOP w0.508: v2(277.76,110.65) 277.27,110.17 276.28,110.17 275.12,111.34 270.7,111.34 270.52,111.52 251.95,111.52 251.1,112.37 251.1,113.08 251.85,113.83 251.85,119.09 250.05,120.89 246.21,120.89 242.68,124.42 242.68,128.43 242.12,128.99 241.38,128.99 240.77,129.6 240.77,130.67 242.07,131.97 RV78.1 ; v2(128.82,96.72) 129.33,96.21 RC86.1 RC87.1 ; v2(111.65,114.1) 111.65,112.88 112,112.53 v1(112.12,112.53) CC18.1 ; v2(278.34,125.34) 278.34,125.97 278.89,126.52 280.39,126.52 280.5,126.4 R55.1 ; v2(130.3,100.27) 130.5,100.27 130.81,99.96 RC90.1 ; RC28.1 133.4,120.99 133.14,121.25 133.14,121.67 v2(133.12,121.69) ; v2(117.57,148.44) 115.2,150.81 v4(113.75,150.81) ; v2(165.11,123.47) 164.77,123.13 RC74.2 ; RC29.1 v2(129.4,125.13)
  IN1 w0.508: v2(121.56,115.43) 122.12,115.99 122.12,118.38 121.23,119.27 121.23,122.47 120.74,122.96 v2(120.71,122.96) ; v2(133.12,121.69) 133.08,121.73 133.08,121.95 132.55,122.49 132.55,123.7 133.6,124.75 v2(133.6,125.27) ; v2(139.73,113.92) 139.73,114.35 139.37,114.71 137.45,114.71 134.88,112.14 v2(134.88,111.68)
  IN2 w0.508: v2(174.35,123.84) 174.29,123.9 167.94,123.9 167.51,123.47 v2(165.11,123.47) ; v2(134.88,111.68) 134.32,111.12 134.32,103.7 133.92,103.29 132.43,103.29 131.54,102.4 131.54,100.91 130.83,100.2 130.36,100.2 v2(130.3,100.27) 130.3,99.96 131.33,98.93 131.33,96.55 130.96,96.18 129.37,96.18 v2(128.82,96.72) ; v2(129.4,125.13) 129.4,125.11 128.72,124.43 126.54,124.43 125.08,122.97 120.73,122.97 v2(120.71,122.96) 120.71,122.99 119.93,123.76 119.93,129.37 118.09,131.22 118.09,141.22 119.93,143.07 119.93,144.25 118.77,145.41 118.77,148 118.96,148.18 v4(118.96,148.32) 118.96,148.91 118.63,149.24 117.81,149.24 117.57,149 v2(117.57,148.44) ; v2(212.25,100.85) 214.46,103.06 217.69,103.06 219.08,104.46 219.59,104.46 220.33,105.19 220.33,111.42 222.28,113.37 223.5,113.37 224.54,114.41 228.25,114.41 228.85,115.01 236.8,115.01 239.23,117.44 239.23,119.14 241.02,120.93 252.13,120.93 253.69,122.49 266.02,122.49 266.61,123.08 271.02,123.08 271.76,123.81 275.76,123.81 276.98,125.03 278.04,125.03 v2(278.34,125.34)
  IN3 w0.508: v2(174.35,123.84) 174.85,123.34 174.85,122.58 174.33,122.06 174.33,113.78 174.63,113.47 174.63,109.14 177.53,106.25 v2(177.53,106.24)
  IN4 w0.508: v2(129.4,125.13) 129.45,125.08 133.41,125.08 v2(133.6,125.27) 134.26,125.93 136.99,125.93 139.71,123.22 141.35,123.22 142.65,121.91 143.39,121.91 143.59,121.7 149.09,121.7 149.5,121.3 150.25,121.3 150.45,121.5 150.81,121.5 152.04,122.73 153.01,122.73 153.32,122.42 164.05,122.42 v2(165.11,123.47) ; v2(121.56,115.43) 121.56,115.2 121.29,114.93 119.15,114.93 118.11,113.89 111.86,113.89 v2(111.65,114.1) ; v2(177.53,106.24) 178.67,106.24 181.31,103.59 181.31,102.88 180.75,102.32 180.75,98.74 181.59,97.9 182.35,97.9 182.71,98.26 182.71,99.07 182.18,99.61 182.18,100.88 186.6,105.3 198.29,105.3 203.37,100.21 206.29,100.21 206.92,99.59 208.64,99.59 209.9,100.85 v2(212.25,100.85)
  BOTTOM w0.279: JXDP1.43 112.75,114.9 111.95,114.1 v2(111.65,114.1) ; 122.31,115.43 121.77,114.9 JXDP1.44
  BOTTOM w0.305: v2(139.73,113.92) JCPU1.AN35
  BOTTOM w0.381: 139.09,114.56 v2(139.73,113.92)
  BOTTOM w0.508: v4(118.96,148.32) 118.96,148.84 PR500.2 ; PC548.2 115.01,150.02 114.71,150.32 PR504.2 113.83,150.89 v4(113.75,150.81) ; PR503.2 117.19,148.82 v2(117.57,148.44) ; 139.09,114.56 139.01,114.56 139,114.57 137.53,114.57 137.05,115.05 136.74,115.05 135.44,116.35 133.78,118.01 133.78,118.73 133.12,119.39 v2(133.12,121.69) ; v2(278.34,125.34) 277.99,124.98 277.99,124.09 277.48,123.58 277.02,123.58 275.95,122.52 275.95,120.78 276.96,119.77 278.62,119.77 279.1,119.29 279.1,113.07 278.95,112.91 278.95,111.85 v2(277.76,110.65) ; v2(121.56,115.43) 122.31,115.43 CC17.1
+VCCST: length 23.6
  IN1 w0.254: v2(142.73,109.94) 142.45,109.94 142.01,110.39 135.44,110.39 v2(135.36,110.46)
  BOTTOM w0.102: v1(128.13,117.49) RC99.1
  BOTTOM w0.254: v2(142.73,109.94) 143.2,109.47 JCPU1.AK31
  BOTTOM w0.508: RC99.1 128.23,119.18 CC47.1 CC48.1 131.43,116.04 135.49,111.98 135.49,110.59 v2(135.36,110.46)
+VDD_MEM15_REFDA: length 5.4
  TOP w0.102: v2(214.55,133.6) 214.32,133.6 v1(214.04,133.88)
  TOP w0.381: v2(214.55,133.6) 214.82,133.87 CV275.1
  TOP w0.508: CV275.1 215.31,134.11 214.99,134.42 214.99,135.02 214.71,135.31 RV145.2 214.71,135.78 215.23,136.31 RV146.1
  BOTTOM w0.254: v2(214.55,133.6) 214.96,133.2 UV1.L18
+VDD_MEM15_REFDB: length 4.3
  TOP w0.102: CV279.1 v1(221.01,137.09)
  TOP w0.381: RV152.1 220.19,139.23 220.79,139.23 220.79,139.23 RV155.2 221.12,139.12 v2(221.61,138.63)
  TOP w0.457: v2(221.61,138.63) 221.1,138.12 CV279.1
  BOTTOM w0.381: UV1.Y12 222.05,138.2 v2(221.61,138.63)
+VDD_MEM15_REFSA: length 4.6
  TOP w0.102: 215.36,131.2 216.02,131.2 v1(216.09,131.27)
  TOP w0.381: RV147.1 215.36,131.2 215.59,131.43 v2(215.59,131.73) 215.31,132.02 CV274.1 214.93,132.98 RV148.2
  BOTTOM w0.381: UV1.L20 215.13,132.2 v2(215.59,131.73)
+VDD_MEM15_REFSB: length 5
  TOP w0.102: v1(222.99,137.26) CV278.1
  TOP w0.381: RV154.1 224.04,137.3 CV278.1 224,138.19 v2(223.59,138.59) 224.11,139.11 RV153.2
  BOTTOM w0.381: UV1.AA12 223.16,138.2 223.51,138.54 223.54,138.54 v2(223.59,138.59)
+VDDA_AVDD: length 0.8
  TOP w0.127: v2(347.43,180.81) v1(347.43,181.6)
  vias: v2(347.42,180.23) v2(349.17,169.42) v2(349.17,168.78)
+VDDA_AVDD2: length 4.7
  TOP w0.254: v2(344.41,175.65) 343.89,175.65 343.48,175.25 U74.38
  BOTTOM w0.102: v2(344.41,175.65) v1(344.41,174.94)
  BOTTOM w0.508: v2(344.41,175.65) 345.09,176.34 C968.1 C956.1
+VDDA_PVDD:
  vias: v1(338.82,175.91) v2(339.47,176.21) v2(339.75,175.69) v2(343.39,175.91) v2(343.64,176.54)
+VDDC_CT: length 27.5
  TOP w0.102: v3(239.96,130.05) 239.33,129.41 LV19.2
  TOP w0.381: v2(226.57,127.83) 227.04,127.36 CV55.1
  TOP w0.508: v2(241.66,128.31) 241.21,127.85 CV54.1 240.89,127.84 CV56.1 239.63,128.61 LV19.2
  IN4 w0.508: v2(226.57,127.83) 226.57,127.51 227.75,126.32 v2(227.75,125.67) 227.75,125.47 228.15,125.07 229.56,125.07 230.23,125.74 232.85,125.74 232.87,125.76 233.5,125.76 233.6,125.65 239.01,125.65 v2(241.66,128.31)
  BOTTOM w0.254: UV1.AG27 228.05,126.16 227.75,125.85 v2(227.75,125.67)
  BOTTOM w0.381: UV1.AF26 227.05,127.35 v2(226.57,127.83) ; UV1.AF26 UV1.AG26 ; UV1.AF26 UV1.AF27
GND: length 6186.4
  TOP w0.102: v2(206.54,103.94) 205.61,103.94 v3(205.6,103.95) ; C576.2 250.76,49.92 ; v3(85.34,185.42) 84.41,185.42 PC707.2 ; v2(18.4,195.85) 18.4,196.58 v3(18.45,196.63) ; v3(218.55,93.18) 218.7,93.03 v2(218.7,92.23) ; UV3.D10 189.38,141.3 v2(189.04,141.64) ; v2(206.71,158.9) UV7.J10 ; v2(209.91,159.7) UV7.D10 ; R1702.2 248.6,39 ; v2(197.85,141.7) UV3.P10 ; C53.2 267.32,83.54
  TOP w0.127: v2(193.65,140.78) 193.45,140.98 UV3.J10
  TOP w0.203: v2(325.23,201.07) 324.8,201.5 U101.11 ; U6.31 182.4,172.71 182.8,173.11 v2(184.26,173.11) ; U19.15 26.47,204.88 v2(26.51,204.92) ; v2(182.88,173.66) 182.62,173.91 U6.28 ; v2(185.86,172.54) 185.9,172.54 186.26,172.18 U6.11 ; U19.35 26.07,198.2 v2(25.97,198.09) ; U27.6 173.54,138.26 173.74,138.06 v2(174.61,138.06) ; U103.11 v2(247.76,141.87) ; PU808.15 164,176.05 v4(164.35,176.41) ; v2(29.66,202.56) U19.8 ; U6.3 183.06,172.45 v2(183.03,172.48) ; U104.11 v2(172.19,165.37)
  TOP w0.254: UV7.A3 v2(213.11,165.3) ; v2(198.66,136.11) 198.56,136 UV3.R3 ; UV5.L5 v2(191.85,121.77) ; UV5.C13 v2(198.65,116.29) UV5.C12 ; UV7.N3 203.09,164.9 v2(202.7,164.5) ; UV7.U1 199.58,166.5 v2(199.41,166.33) ; UV5.H2 v2(194.65,125.1) UV5.H1 v2(194.65,125.9) ; JBTB1.17 54.5,203.5 v2(54.54,203.5) ; UV5.A1 199.49,125.13 v2(199.46,125.13) ; v2(199.94,155.56) 199.94,156.07 UV7.U14 ; UV9.A12 234.1,158.08 v2(234.11,158.08) ; UV9.B5 232.91,162.99 v2(232.7,162.78) ; v2(198.65,142.5) UV3.R12 ; v2(187.85,121.57) UV5.T5 ; UV5.R3 v2(188.25,123.5) ; v2(223.73,165.28) 224.11,164.9 UV9.N3 ; v2(188.25,142.5) UV3.C12 ; v2(204.77,159.82) 204.71,159.76 UV7.L10 ; UV3.A3 186.6,135.69 v2(186.51,135.6) ; UV5.F10 v2(195.45,118.7) UV5.G10 ; PU800.5 151.75,164.06 151.55,163.86 151.55,163.44 v4(151.57,163.42) ; UV3.L5 v2(195.45,137.7) UV3.M5 ; v2(290.24,110.11) 290.24,110.06 290.47,109.84 U51.B66 ; UV7.N12 203.11,157.75 203.51,158.15 203.51,158.73 203.91,159.13 UV7.M10 v2(203.91,159.83) ; UV7.C11 v2(210.71,158.9) ; v2(201.42,166.99) 201.51,166.9 UV7.R1 ; UV3.R1 v2(197.85,134.49) ; UV9.N1 224.12,166.51 224.12,166.96 224.21,167.05 v2(224.2,167.05) ; v2(222.51,155.59) UV9.R14 ; v2(201.92,164.5) 201.91,164.5 UV7.R3 ; v2(232.51,158.06) 232.55,158.06 232.11,158.49 UV9.C11 ; UV3.E1 190.25,133.73 v2(190.4,133.58) ; UV9.J10 227.15,159.46 v2(227.15,159.88) ; U51.B54 284.47,109.54 284.74,109.82 284.74,110.23 285.4,110.88 v2(285.61,110.88) ; UV5.N14 190.25,114.6 v2(190.29,114.55) ; UV5.R4 v2(188.25,122.7) ; v2(205.64,167.03) 205.51,166.9 UV7.K1 205.37,166.35 205.37,165.84 UV7.K2 ; UV7.H2 v2(207.51,166.1) UV7.H1 v2(207.51,166.9) ; v2(208.31,162.9) UV7.G5 ; JBTB1.21 v2(53.5,205.45) ; JEXP1.4 v2(285.96,28.06) ; UV9.R1 222.52,166.51 222.52,166.98 v2(222.5,167) ; v2(220.47,157.46) 220.71,157.69 UV9.U12 ; U51.B60 287.47,109.55 287.31,109.7 v2(287.31,110.03) ; v2(222.46,159.84) 222.26,159.84 UV9.T10 ; UV5.N1 190.26,125.51 190.26,125.96 190.35,126.05 v2(190.34,126.05) ; UV9.N12 224.11,157.75 224.51,158.15 224.51,158.92 224.89,159.3 UV9.M10 v2(224.91,159.83) ; JEXP1.25 287.83,33.56 v2(287.59,33.31) ; UV3.E3 190.25,135.86 190.65,136.26 190.65,136.73 191.05,137.13 UV3.F5 v2(191.05,137.83) ; UV7.F10 v2(208.31,159.7) UV7.G10 ; UV9.E3 v2(230.11,164.5) ; v2(200.24,115.49) 199.85,115.11 UV5.A14 ; v2(193.05,133.69) UV3.H1 192.54,134.2 192.54,134.79 UV3.H2 ; v2(233.31,166.9) UV9.A1 ; v2(225.77,159.82) 225.71,159.76 UV9.L10 ; UV3.R4 v2(197.85,136.9) ; UV9.F10 v2(229.31,159.7) UV9.G10 ; v2(191.91,137.82) 191.85,137.76 UV3.G5 ; UV5.H13 194.26,115.89 v2(194.66,115.49) 194.26,115.09 UV5.H14 ; UV9.R12 v2(222.11,158.09) UV9.R11 ; v2(188.25,141.7) UV3.C11 ; v2(212.31,158.09) UV7.A12 ; UV9.C13 v2(232.51,157.29) UV9.C12 ; v2(203.2,167.02) 203.11,166.93 UV7.N1 ; v2(226.96,166.94) 226.51,166.5 UV9.K1 ; UV5.C3 v2(198.65,123.5) ; U51.B11 291.71,114.91 v2(291.35,114.56) ; JBTB1.7 v2(57,203.35) ; UV3.R11 v2(197.85,142.5) ; UV3.C3 188.65,135.69 v2(189.02,135.32) ; UV9.C3 232.12,164.9 v2(231.71,165.31) ; v2(211.51,164.5) UV7.C3 ; v2(287.57,32.25) 287.63,32.25 287.81,32.06 JEXP1.19 ; v2(200.24,134.49) 199.85,134.11 UV3.U1 ; v2(188.62,126.05) 188.66,126.01 188.66,125.51 UV5.R1 ; v2(203.14,155.55) 203.14,155.7 203.11,155.73 UV7.N14 ; UV3.N14 v2(196.25,144.9) ; UV7.U3 200.31,164.5 v2(200.32,164.5) ; UV7.E14 209.51,156.11 v2(209.12,156.49) ; UV3.F10 v2(191.05,140.77) ; v2(186.65,123.5) UV5.U3 ; v2(232.55,155.68) 232.53,155.68 232.11,156.09 UV9.C14 ; CV61.2 228.15,136.21 228.15,136.9 228.07,136.98 CV60.2 ; PU800.23 151.75,172.36 v4(151.68,172.43) ; v2(197.85,115.49) UV5.C14 ; UV3.H14 192.62,144.46 192.62,143.73 UV3.H13 192.62,143.7 v2(192.2,143.27) ; v2(222.89,165.26) 222.52,164.9 UV9.R3 ; UV3.K1 v2(194.65,134.49) UV3.K2 ; v2(222.92,164.49) 222.52,164.1 UV9.R4 ; UV9.K13 226.43,156.81 226.43,156.18 UV9.K14 226.53,156.08 226.53,155.38 226.56,155.35 v2(226.54,155.35) ; v2(212.3,155.69) 212.71,156.09 UV7.A14 ; UV9.A14 233.71,156.11 234.1,156.49 v2(234.11,156.49) ; UV7.U12 199.95,157.69 v2(200.32,158.07) ; v2(201.11,163.7) UV7.R4 ; v2(209.91,158.09) UV7.E12 ; v2(197.85,144.1) UV3.R14 v2(197.85,144.9) ; UV5.G5 v2(195.45,121.9) ; v2(198.65,118.7) UV5.B10 ; UV9.E14 230.5,156.09 230.13,155.73 v2(230.13,155.73) ; UV5.L10 191.85,118.76 v2(191.91,118.82) ; UV7.T5 v2(200.71,162.57) ; UV7.H13 v2(207.51,156.49) UV7.H14 ; v2(200.25,124.3) UV5.A3 ; JBTB1.25 v2(52.5,203.53) ; v2(285.91,32.18) 285.78,32.06 JEXP1.20 ; UV5.K1 192.65,125.5 v2(192.24,125.91) ; v2(196.25,141.7) UV3.M10 ; v2(221.71,162.57) UV9.T5 ; UV3.A1 186.71,133.75 v2(186.71,133.59) ; UV9.D10 v2(230.91,159.7) ; UV9.H2 v2(228.51,166.1) UV9.H1 v2(228.51,166.9) ; UV5.U12 187.05,116.69 v2(186.65,116.29) ; v2(196.25,142.5) UV3.N12 ; v2(211.51,157.29) UV7.C12 ; UV3.A12 v2(186.65,142.5) ; v2(200.36,136.25) 200.36,136.13 199.92,135.69 UV3.U3 ; UV3.E12 v2(190.65,142.5) ; v2(199.45,141.7) UV3.T10 ; UV7.R11 201.53,158.49 v2(201.91,158.12) 201.51,157.72 UV7.R12 ; v2(286.88,28.07) 287.86,29.06 JEXP1.7 ; UV5.R12 v2(188.25,117.1) UV5.R11 v2(189.05,117.9) UV5.P10 ; UV3.N3 v2(197.05,136.09) ; v2(205.77,155.57) 205.77,155.57 205.51,155.83 UV7.K14 205.4,156.2 205.4,156.79 UV7.K13 ; UV7.B10 211.51,159.69 v2(211.51,159.71) ; v4(147.68,167.43) 147.78,167.53 PU800.32 ; v2(210.71,166.1) UV7.C1 v2(210.71,166.9) ; v2(291.97,118.83) 291.64,118.83 291.47,118.66 U51.B18 ; v2(196.25,125.9) UV5.E1 ; UV7.R14 v2(201.51,155.55) ; UV7.C4 v2(210.71,164.5) ; UV9.U14 220.89,156.09 220.55,156.43 v2(220.55,156.45) ; v2(190.31,144.99) 190.25,144.94 UV3.E14 ; UV5.B5 v2(199.45,122.7) ; JBTB1.13 v2(55.5,205.48) ; UV5.K13 192.57,115.81 192.57,115.18 UV5.K14 192.65,114.64 192.73,114.56 192.73,114.56 v2(192.74,114.56) ; v2(220.54,166.09) 220.54,166.13 UV9.U1 ; v2(232.51,159.7) UV9.B10 ; v2(209.11,163.7) UV7.F5 ; v2(234.11,165.3) UV9.A3 ; v2(188.35,144.91) 188.65,144.61 UV3.C14 UV3.C13 ; v2(191.85,140.77) UV3.G10 ; UV5.J10 v2(193.05,117.9) ; UV3.A14 v2(186.65,144.9) ; v2(204.71,162.77) UV7.L5 ; UV3.C4 188.67,136.5 v2(189.05,136.12) ; U7.6 325.27,129.72 325.4,129.59 325.4,129.25 325.17,129.02 v2(324.49,129.02) ; v2(186.65,125.9) UV5.U1 ; v2(231.71,164.5) UV9.C4 ; v2(224.91,162.77) UV9.M5 ; UV9.U3 220.9,164.9 v2(220.49,164.49) ; UV9.E12 v2(230.91,158.09) ; JEXP1.13 287.68,30.56 v2(287.59,30.47) ; UV9.F5 v2(230.11,163.7) ; U74.7 v2(336.8,171.09) ; v2(226.92,166.1) 226.51,165.7 UV9.K2 ; v2(197.85,125.9) UV5.C1 v2(197.85,125.1) ; UV3.U12 v2(200.25,143.3) ; v2(197.85,123.5) UV5.C4 ; UV3.U14 v2(199.45,144.9) ; v2(197.05,117.1) UV5.E12 ; v2(188.65,133.55) UV3.C1 ; PU800.14 v4(155.77,167.53) ; v2(196.26,115.49) 196.65,115.11 UV5.E14 ; UV5.R14 v2(188.65,114.56) ; v2(197.85,117.9) UV5.C11 ; UV5.D10 v2(197.05,118.7) ; UV3.N1 196.65,134.11 v2(196.26,134.49) ; v2(222.91,158.9) UV9.P10 ; UV5.E3 v2(196.25,123.5) ; UV7.E1 v2(209.11,166.9) ; UV9.H13 228.06,156.89 227.68,156.51 ; v2(195.45,140.9) UV3.L10 ; v2(212.31,163.7) UV7.B5 ; v2(227.71,156.51) 227.68,156.51 ; 227.68,156.51 227.68,156.51 228.1,156.09 UV9.H14 ; UV7.T10 v2(201.1,159.68) ; v2(230.11,166.9) UV9.E1 ; v2(224.17,155.6) 224.12,155.64 224.12,156.08 UV9.N14 ; UV9.G5 v2(229.31,162.9) ; v2(199.45,117.1) UV5.A12 ; UV7.C13 v2(210.71,156.49) UV7.C14 ; UV3.B10 v2(187.85,140.57) ; UV5.F5 v2(196.25,122.7) ; v2(209.11,164.5) UV7.E3 ; v2(191.05,118.83) UV5.M10 ; UV3.T5 v2(199.45,137.7) ; UV5.T10 v2(187.45,118.7) ; UV7.M5 v2(203.91,162.77) ; v2(186.71,114.59) 186.71,114.75 UV5.U14 ; v2(191.05,121.77) UV5.M5 ; v2(194.65,144.9) UV3.K14 v2(194.65,144.1) UV3.K13 ; UV7.A1 v2(212.31,166.9) ; UV7.P10 v2(201.91,158.9) ; v2(231.71,166.9) UV9.C1 ; UV9.L5 v2(225.71,162.77) ; v2(190.65,117.15) 190.25,116.75 UV5.N12 ; v2(187.45,137.7) UV3.B5 ; v2(192.25,125.1) UV5.K2 ; v2(190.65,124.3) UV5.N3
  TOP w0.279: v2(267.73,56.52) 267.7,56.56 267.7,57.22 U46.B27 ; v2(272.64,32.52) 272.49,32.52 271.9,33.11 U41.7
  TOP w0.305: v2(258.09,99.48) 257.63,99.03 JTP1.1 ; JUSH1.3 262.81,88.07 v2(262.31,88.57) JUSH1.2 ; v2(304.3,114.44) JAPS1.8 ; v2(304.35,115.44) JAPS1.10 ; v2(262.33,79.79) 262.77,79.79 263,79.57 JUSH1.20 ; JUSH1.17 264.62,81.07 v2(265.41,80.28) ; JAPS1.14 303.94,117.44 304.31,117.07 v2(304.31,116.44) JAPS1.12
  TOP w0.356: JBTB1.1 58.56,205.53 v2(58.66,205.63) ; JEXP1.29 287.98,34.62 287.63,34.97 v2(287.63,35.03) ; v2(58.78,198.64) 58.56,198.86 JBTB1.2 ; v2(172.93,156.1) 173.23,155.8 U55.3 ; v2(350.38,197.75) 349.83,198.3 U93.1 ; JEXP1.1 287.97,27.5 v2(287.57,27.1) ; v2(242.71,88.33) 242.71,87.81 242.14,87.25 PQ807.4 ; v2(285.73,34.3) 285.42,34.62 JEXP1.30 ; JSF1.2 322.28,145.1 v2(321.55,144.36) ; JBTB1.29 v2(51.44,203.41)
  TOP w0.381: PQ806.4 54.86,188.72 55.15,188.43 v2(55.41,188.43) ; v2(227.57,129.82) 227.08,129.32 CV49.2 ; v2(55.53,180.43) 55.53,179.39 55.24,179.1 PQ821.4 ; v2(350.81,213.96) 350.4,214.37 U91.1 ; v2(183.68,151.37) 183.36,151.37 182.88,150.89 U54.3 ; U39.4 298.8,138.09 v2(299.16,138.44) 299.45,138.15 U39.3 ; PQ813.4 56.98,175 57.19,174.8 57.19,173.17 v2(56.78,172.76) ; v2(242.41,178.46) 242.24,178.46 241.94,178.76 241.94,178.9 ; v2(207.46,68.09) 207.27,68.09 207.17,67.99 206.65,67.99 ; v2(298.8,130.01) U39.25 ; CH31.2 202.35,78.01 v2(202.35,78.18) ; PC927.2 221.04,132.2 v2(221.55,131.7) ; PC956.2 224.02,134.26 v2(223.43,133.67) ; U39.1 300.75,137.96 v2(300.35,138.37) 300.1,138.12 U39.2 ; CH34.2 v2(205.14,70.43) 205.04,70.33 204.43,70.33 CH49.2 ; v2(57.89,186.19) 57.89,186.07 57.4,185.57 PQ805.4 ; PQ707.1 93.44,158.94 93.92,159.42 v2(93.92,159.42) 94.74,160.24 PQ707.4 ; CV214.2 219.87,125.38 v2(219.52,125.73) 219.4,125.73 218.82,125.15 CV70.2 ; PC967.2 224.67,128.76 v2(224.64,128.74) ; PC928.2 221.19,130.04 v2(221.54,129.7) ; RV152.2 219.19,139.21 v2(218.68,138.71) 218.11,139.28 CV170.2 ; CV168.2 218.77,137.02 v2(218.49,136.74) 218,136.25 PCV172.2 ; UC1.3 139.95,62.46 140.17,62.24 v2(140.46,62.24) ; CH41.2 204.28,81.72 204.38,81.62 204.38,80.92 v2(204.76,80.53) ; PCV175.2 220.13,135.18 v2(220.63,134.67) ; v2(170.13,173.29) 170.38,173.05 170.38,172.79 170.84,172.33 PQ825.3 ; v2(238.37,81.7) 238.37,81.18 238.62,80.94 239.11,80.94 239.24,81.06 PQ808.4 ; v2(256.27,181.41) 256.26,181.41 JSIM1.17 ; PQ802.4 54.61,184.4 54.84,184.16 v2(55.14,184.16) ; PQ807.1 237.89,88.55 237.21,89.23 v2(237.21,90.44) ; PU809.3 v2(35.9,174.05) ; v2(222.67,134.71) 222.22,134.25 PC955.2 ; JSIM1.13 241.94,187.36 v2(241.11,188.19) ; v2(296.34,138.35) 296.34,138.2 296.2,138.06 U39.8 ; v2(294.14,132.71) 294.25,132.6 U39.18 ; PQ802.1 v2(53.31,182.12) ; v2(89.07,161.63) 89.07,161.99 89.24,162.15 PC733.1 ; v2(254.16,185.72) 254.26,185.83 254.26,186.29 255.46,187.48 ; PU704.3 92.31,159 91.98,159.33 v2(91.98,159.82) ; v2(294.25,138.35) U39.11
  TOP w0.406: PU805.3 75.66,172.76 v2(75.93,172.49) ; PQ819.1 64.88,175 65.69,174.19 66.21,174.19 66.67,174.65 66.67,177.45 65.9,178.23 v2(65.9,178.23) ; PU801.3 49.02,182.48 v2(49.5,182) ; v2(49.27,186.5) 49.27,186.5 PU803.3 ; v2(61.96,177.35) 61.96,176.47 62.12,176.3 PQ819.4 ; PQ806.1 v2(53.56,186.4) ; PU804.3 52.07,186.73 v2(52.21,186.59) ; v2(63.14,170.93) 62.62,171.45 PU807.3 ; PQ805.1 v2(56.1,182.12) ; v2(276.68,122.34) 276.6,122.34 276.19,122.75 U50.3 ; 255.46,187.48 255.91,187.48 256.26,187.13 JSIM1.16 ; PQ813.1 54.2,176.3 54.11,176.39 54.11,176.72 54.48,177.09 v2(54.49,177.08) ; PU802.3 51.81,183.06 v2(52.22,183.46) ; 241.94,178.9 241.94,178.91 JSIM1.12 ; PU806.3 71.09,173 70.93,172.83 v2(70.52,172.83) ; UH3.3 186.31,66.25 186.73,66.25 v2(187.37,66.89)
  TOP w0.432: QC4.4 140.38,72.21 v2(140.46,72.29) ; v2(141.78,69.96) 142.17,70.36 QC4.1
  TOP w0.457: PD2.1 v2(119.21,185.9) ; v2(176.21,173.23) 176.21,173.55 176.51,173.85 177.99,173.85 C27.2 ; CV237.2 222.6,141.06 223.06,140.6 v2(223.06,140.55) ; C742.2 298.04,114.53 297.77,114.8 v2(297.77,115.1) 297.77,115.12 298.3,115.65 298.43,115.65 ; v2(116.8,185.51) 116.86,185.45 PD4.1 ; CV93.2 229.31,121.9 228.99,121.58 v2(228.9,121.58) ; CH53.2 211.49,81.23 v2(210.76,80.51) ; v2(174.84,162.92) 174.96,162.92 175.7,163.66 C486.2 ; v2(279.79,138.82) 280.36,138.25 PC676.2
  TOP w0.508: C1510.1 252.84,39.29 C561.1 253.58,38.82 v2(254.01,39.26) ; PC950.2 223.97,130.24 223.45,129.73 v2(223.44,129.73) ; v2(178.09,190.22) 178.06,190.19 178.06,190.18 177.56,189.67 R758.2 ; v2(130.62,82.83) 130.67,82.83 131.03,83.2 RC63.2 ; v2(219.47,137.7) 219.89,138.12 CV279.2 ; PR542.1 114.71,156.65 v4(114.03,155.97) ; v2(213.72,169.3) 214.49,168.54 CV304.2 CV307.2 ; PR525.1 v2(134.65,142.33) ; v2(225.42,123.28) 225.06,123.64 CV116.2 ; 201.28,66.67 200.67,67.27 200.67,68.06 200.9,68.29 v2(201.02,68.29) ; CH80.2 228.1,66.5 228.1,65.71 CH79.2 227.76,64.92 v2(228.16,64.52) ; ME1.1 213.01,57.23 213.01,57.25 213.24,57.47 v2(213.42,57.47) ; v2(328.07,133.92) 327.31,133.92 C400.2 C412.2 ; CH68.2 CH70.2 ; CH70.2 214.12,78.7 CH58.2 ; CH70.2 213.36,79.07 212.73,79.07 v2(212.44,79.36) ; C26.2 178.04,172 178.04,172.94 178.21,173.11 C27.2 ; C44.2 299.53,138.81 v2(299.16,138.44) ; RD24.2 134.41,18.99 v2(134.79,19.36) ; v2(230.31,127.7) 229.18,127.7 228.92,127.44 228.71,127.44 ; JSIM1.5 247.74,178.03 v2(247.24,178.54) ; RV9.2 CV25.2 v2(196.45,171.77) ; v2(147.79,16.24) 147.79,16.26 147.7,16.34 CD35.2 ; v2(209.7,50.91) 210.69,50.91 RH18.2 ; v2(121.85,31.42) 122.09,31.18 RD18.2 ; CH19.2 CH18.2 221.21,78.48 CH20.2 222.38,78.02 v2(223.15,78.02) ; R812.1 280.36,110.24 280.68,110.55 280.68,110.56 v2(280.69,110.56) ; JSPK1.5 108.8,1.85 108.44,2.21 v2(108.44,2.93) ; CD11.2 152.57,29.57 v2(152.78,29.36) ; C562.1 250.73,38.62 v2(250.15,38.04) 249.49,38.7 C575.2 ; v2(237.23,119.63) CV113.2 ; CV13.2 194.39,161.92 v2(193.73,161.26) ; C616.2 247.12,174.18 248.04,175.09 v2(248.04,175.4) ; v2(208.02,124.47) 206.89,123.33 CV327.2 ; R1685.2 v2(328.04,128.98) ; C762.2 176.96,167.84 176.34,168.47 C298.2 176.94,168.8 v2(177.01,168.86) ; JKB1.8 v2(317.02,131.62) 317.22,131.81 R1689.2 ; D37.1 262.73,99.16 v2(263.18,99.61) 263.2,99.63 264.5,99.63 C749.2 ; CV55.2 226.05,127.3 v2(225.58,127.76) ; v2(176.22,187.52) 176.22,187.81 176.39,187.97 C696.2 ; v2(222.69,126.71) 222.27,126.29 PC948.2 ; CD29.2 160.23,26.49 159.63,27.09 159.63,28.47 160.14,28.98 v2(160.35,28.98) ; CD12.2 CD3.2 150.27,29.55 v2(150.25,29.52) ; 228.71,127.44 229.36,126.8 RV63.2 ; 228.71,127.44 CV50.2 ; C550.2 293.99,127.25 v2(293.34,126.61) 293.12,126.82 293.12,127.02 292.97,127.18 C552.2 ; CD15.2 CD16.2 164.49,24.02 164.69,23.81 v2(164.94,23.81) ; v2(278.87,52.03) 278.25,52.03 278.23,52.01 R793.2 ; v2(313.22,187.06) 312.53,186.37 C626.2 ; JKB1.10 315.13,129.62 v2(314.85,129.34) ; R1142.2 330.61,170.57 C977.2 v2(329.75,170.62) ; C402.2 v2(110.66,47.89) ; R775.1 265.67,43.14 v2(265.48,42.95) ; JEXP1.32 v2(285.15,25.36) ; v2(182.99,177.77) 183.13,177.63 C28.2 C29.2 ; CV145.2 CV192.2 v2(184.77,149.91) ; v2(296.02,129.18) CE3.2 ; RV24.2 CV39.2 227.69,171.25 v2(228.16,171.72) ; v2(247.81,36.86) 247.51,37.16 C566.1 ; PC810.1 73.52,172.29 74.01,172.78 ; PC803.2 129.78,169.93 v4(129.78,169.93) ; RD21.2 166.43,15.79 v2(166.43,16.29) ; PQ5.3 v2(129.8,6.43) ; JAPS1.18 306.56,121.76 v2(305.93,122.39) ; v2(138.35,73.09) 138.21,73.23 137.37,73.23 136.87,72.73 Q71.3 ; PC801.1 v2(51.62,191.44) ; v2(182.01,141.81) 182.01,141.83 182.79,141.06 CV210.2 ; PC919.2 144.25,121.98 143.99,122.25 v2(143.99,122.39) ; C702.2 166.87,180.48 v2(166.68,180.67) ; C781.2 R869.1 v2(278.49,114.19) ; v2(197.11,179.3) 197.23,179.18 D33.1 ; U1.1 v2(7.9,217.12) ; PR111.1 151.54,5.11 PC114.1 v4(152.45,4.97) ; PR305.2 243.19,3.26 v2(243.16,3.24) ; 239.3,141.74 239.01,141.74 238.36,142.39 v2(238.36,142.49) ; CV67.2 217.05,125.37 216.56,125.87 v2(216.53,125.87) 217.01,126.34 RV36.1 ; PC951.2 226.06,130.23 v2(225.5,129.67) ; CH23.2 204.53,72.63 v2(204.88,72.98) 204.99,72.98 CH24.2 ; v2(130.21,98.64) 130.51,98.95 RC78.2 ; PC929.2 221.1,126.03 221.42,125.72 v2(221.59,125.72) ; v2(155.88,35.14) 155.88,35.27 156.21,35.6 156.21,35.67 157.08,36.55 CD4.2 ; v2(331.15,174.29) 331.15,174.18 331.63,173.7 C978.2 CH9.2 ; PC968.2 224.02,132.27 v2(223.48,131.72) ; R836.2 C735.2 290.25,99.25 ; PC946.2 224,128.27 223.43,127.69 v2(223.42,127.69) ; PR521.2 v4(113.9,153.94) ; C606.1 270.38,188.4 C608.2 270.87,186.05 v2(271.05,185.88) ; R1069.2 C747.2 R880.1 284.27,126.68 v2(284.42,126.83) ; CV159.2 182.23,136.03 v2(181.97,135.78) ; v2(255.63,41.08) 255.63,40.3 C1509.1 256.37,40.25 257.36,41.24 C1506.1 257.36,43.19 C574.2 ; v2(192.34,64.49) 192.35,64.49 192.79,64.93 RH226.2 ; v2(204.28,67.74) 204.15,67.87 ; 204.15,67.87 204.13,67.88 203.32,67.88 CH59.2 ; 204.15,67.87 204.15,68.8 CH46.2 ; v2(240.34,86.54) 240.34,85.97 PR806.2 ; RH76.2 189.97,60.1 v2(189.38,60.1) ; JKB1.11 v2(315.8,141.62) ; CV41.2 182.63,109.6 182.34,109.89 v2(182.34,110.2) 182.77,110.63 CV138.2 ; v2(320.75,133.45) 320.39,133.81 R1687.2 319.15,133.82 C758.2 ; CV177.2 v2(182.14,129.68) ; CV53.2 v2(246.03,110.38) ; v2(182.1,131.1) 182.51,130.7 CV154.2 ; CV139.2 204.12,118.25 v2(204.76,118.9) 204.4,119.27 CV155.2 CV182.2 ; 74.01,172.78 74.53,172.26 PC808.1 ; 74.01,172.78 v2(74.01,172.76) ; v2(47.52,188.21) 47.33,188.4 PC805.1 46.8,188.35 PC802.1 ; RV4.2 CV20.2 v2(217.66,159.14) ; CH60.2 196.97,67.18 196.48,67.18 v2(196.44,67.14) 196.04,67.54 RH227.2 ; CV44.2 182.84,132.45 CV147.2 182.48,133.11 v2(182.1,133.49) ; v2(243.48,173.94) 243.49,173.94 243.75,173.68 C639.2 245.23,173.68 C636.2 ; CE10.2 v2(279.08,28.33) ; v2(130.25,97.84) 130.34,97.93 RC76.2 ; R1640.2 267.22,88.87 266.14,89.95 v2(265.26,89.95) ; PC1.2 238.4,71.98 PC2.2 239.19,71.39 v2(239.43,71.15) ; CH48.2 210.23,69.92 v2(210.23,69.92) 210.07,69.76 209.4,69.76 CH29.2 ; C465.2 249.04,138.61 249.7,137.95 ; v2(255.2,45.52) 255.23,45.54 256,45.54 CE759.2 ; CV206.2 238.3,139.14 238.77,139.61 v2(238.77,139.62) ; C395.2 v2(110.54,41.54) ; R104.2 v2(173.07,131.51) ; v4(279.98,131.17) 279.76,130.95 PC674.2 ; PR729.1 106.74,163.39 105.84,164.29 v2(105.84,164.78) ; CV222.2 CV220.2 240.86,138.82 241.4,139.36 v2(241.4,139.76) ; CV188.2 185.82,110.68 186.11,110.39 v2(186.11,109.99) ; v2(231.06,132.45) 231,132.39 RV88.1 ; v2(267.67,42.94) 267.68,42.96 C707.2 ; v2(86.1,162.55) 86.1,162.52 85.97,162.65 PQ710.3 ; R726.2 v2(325.97,197.64) ; R169.2 337.68,179.62 v2(337.32,179.97) ; CV211.2 CV204.2 234.87,138.81 234.46,139.22 v2(234.46,139.34) 234.38,139.34 234.02,138.97 RV45.2 ; v2(326.69,206.12) 326.64,206.12 326.3,205.78 C451.2 ; CD10.2 158.29,30.21 v2(157.69,29.62) ; CV284.2 v2(202.45,169.42) ; v2(146.79,70.64) 145.77,70.64 145.4,71.01 CC136.2 RC143.2 ; 249.7,137.95 C760.2 ; 249.7,137.95 249.83,137.95 v2(250.43,137.35) ; CH16.2 222.55,74.27 223.1,73.72 ; PC4.2 124.38,186.83 123.07,188.14 v2(123.07,188.37) ; PC933.2 219.81,131.31 v2(219.41,131.71) ; v2(235.34,151.33) 235.33,151.35 234.78,151.35 CV309.2 ; R831.2 245.02,36.38 244.78,36.62 244.78,36.65 v2(244.71,36.72) ; v2(332.6,221.65) 333.23,222.29 C654.2 ; v2(184.03,33.88) 184.21,33.88 185.03,33.06 CD42.2 ; v2(27.54,194.86) C31.2 ; CV178.2 v2(182.16,128.66) ; v2(207.37,56.4) 207.37,56.02 207.6,55.8 CH4.1 ; C45.2 299.93,140.6 300.4,140.13 300.4,138.42 v2(300.35,138.37) ; C25.2 183.42,168.59 183.16,168.33 v2(183.16,167.92) ; U52.4 194.8,29.4 195.18,29.02 v2(195.18,28.52) ; v2(208.04,127.94) 208.65,127.33 CV73.2 ; 187.72,68.1 187.72,68.11 187.72,68.69 v2(187.97,68.94) ; CE11.2 279.6,35.45 v2(279.01,34.86) ; v2(128.16,100.02) 128.43,100.29 RC83.2 ; 207.84,78.07 207.84,78 v2(207.17,77.32) ; v2(215.65,75.94) 215.75,75.94 216.19,76.38 RH97.1 ; v2(231.86,122.39) 232.21,122.39 232.59,122.02 CV69.2 ; v2(181.06,105.04) 181.06,104.19 181.62,103.63 QV2.3 ; JUSH1.21 261.64,77.42 v2(262.01,77.05) ; v2(290.23,127.72) 290.2,127.7 289.97,127.7 289.56,127.28 Q45.3 ; RV146.2 215.35,136.99 214.81,136.99 RV34.1 214.21,136.81 v2(213.84,137.18) ; CV219.2 214.8,142.9 215.1,143.19 v2(215.1,143.85) ; C709.2 276.47,50.91 276.91,51.35 276.94,51.35 277,51.41 277.01,51.41 277.43,51.84 277.43,51.84 R793.2 ; v2(155.06,27.84) 154.48,27.25 CD31.2 ; CV58.2 239.95,113.18 CV59.2 v2(239.95,111.45) ; PR814.1 119.87,172.38 118.98,171.49 v4(118.98,170.7) ; v2(184.73,150.67) 185.2,150.67 185.61,150.27 185.77,150.27 186.13,149.91 186.13,149.77 186.57,149.33 RV118.1 ; C622.2 306.69,177.42 v2(307.32,178.05) 307.7,177.67 C624.1 ; Q88.3 317.82,122.76 317,123.58 316.72,123.58 316.19,124.12 v2(316.19,124.22) ; R101.1 v2(168.3,134.51) ; C109.2 172.13,128.09 171.74,127.7 v2(171.67,127.7) ; v2(218.39,64.88) 218.29,64.78 218.29,64.08 218.09,63.88 CH66.2 ; C625.1 294.75,176.01 295.37,175.39 295.37,175.31 v2(295.46,175.22) ; CH67.2 210.68,75.04 v2(210.19,74.56) 209.26,74.56 209.13,74.43 ; CH43.2 CH25.2 207.7,71.79 v2(208.36,71.79) 208.73,72.16 208.73,72.5 ; v4(127.63,187.73) 127.63,186.41 PR817.2 ; RV180.1 229.04,139.49 228.36,140.18 v2(227.81,140.18) ; v2(216.53,138.63) 216.66,138.5 PCV183.2 ; RC58.2 RC61.2 130.51,84.98 130.15,84.61 v2(130.15,84.42) ; v2(34.45,200) 34.45,199.83 33.89,199.28 R75.2 ; JSD1.6 254.34,30.84 254.26,30.92 254.26,32.31 254.68,32.73 R493.2 C802.1 255.84,33.27 v2(256.37,33.81) ; v2(126.39,29.43) 126.39,30.03 125.84,30.58 RC109.2 ; QC1.3 138.96,67.56 138.38,68.14 v2(138.38,68.47) ; v2(176.84,156.01) 177.78,155.08 R1137.2 ; v2(178.05,156.26) C40.2 C41.2 ; C628.2 249.16,173.67 C630.2 250.05,173.23 251.39,171.88 252,171.88 252.4,172.28 252.4,174.52 C629.2 252.32,174.89 252.74,175.31 v2(252.74,175.32) ; RC108.2 126.68,24.88 v2(126.41,24.61) ; v4(195.08,88.86) 195.15,88.79 196.87,88.79 197.47,89.39 PC667.2 ; PC969.2 218.06,132.29 v2(217.52,131.76) ; CH26.2 208.49,86.67 207.26,86.67 v2(207.12,86.8) ; CV301.2 v2(231.76,171.68) 232.88,171.68 CV48.2 ; v2(306.56,110.64) JAPS1.17 ; v2(241.6,191.01) 242.3,191.71 JSIM1.14 ; v2(258.68,49.76) 259.25,49.76 R3.1 259.39,49.9 C710.2 ; v2(168.21,141.41) 168.41,141.62 R100.1 ; C1557.2 C1559.2 347.23,192.67 347.57,192.33 v2(347.61,192.33) ; R789.1 274.43,62.22 v2(274.3,62.34) ; v2(246.35,178.56) 246.34,178.56 JSIM1.10 ; v2(164.94,20.76) 165.12,20.59 RD28.2 ; PC17.2 v2(107.37,181.62) ; PC209.2 v4(210.93,8.65) ; v2(92.48,164.35) 92.86,163.97 PU701.4 ; v2(229.18,117.41) 229.47,117.7 CV51.2 ; CH37.2 206.16,75.17 v2(206.13,75.17) 205.74,75.56 CH50.2 ; 199.36,68.58 199.84,69.05 v2(199.87,69.05) ; 199.36,68.58 199.36,67.99 CH62.2 ; 199.36,68.58 CH61.2 ; v2(226.44,153.37) 226.44,152.25 226.02,151.83 CV305.2 ; PC724.2 102.42,168.45 101.9,168.97 v2(101.9,169.02) ; PC730.2 102.84,164.22 v2(103.26,164.64) ; v2(155.39,28.87) 156.02,29.49 CD26.2 ; v2(56.61,170.41) 56.33,170.69 PQ827.3 ; v2(291.27,127.14) 291.19,127.06 R407.2 C284.2 ; CD38.2 v2(164.04,16.22) ; v2(244.08,46.11) R1701.2 ; CD2.2 CD1.2 123.63,37.35 v2(123.74,37.46) ; v2(264.8,39.87) 265.47,39.87 265.67,40.06 C716.2 ; PC213.2 211.07,19.27 v4(211.07,19.99) ; CV72.2 213.62,124.31 v2(213.62,125.19) ; R677.1 253.04,50.74 v2(253.83,51.54) 254.01,51.36 C1508.1 ; C476.2 246.78,138.59 C771.2 246.25,137.96 245.7,137.41 v2(245.44,137.41) ; CD39.2 CD40.2 CD41.2 185.03,28.17 185.39,28.53 v2(185.78,28.53) ; C646.2 C645.2 v2(277.05,31.38) ; v2(277.78,122.26) 278.38,122.26 278.63,122.01 C782.2 279.38,121.3 C777.2 ; v2(208,171.67) 207.44,171.67 207.22,171.45 CV283.2 ; CD21.2 187.56,43.32 v2(187.16,43.73) 186.55,43.12 CD22.2 ; v2(189.09,72.44) 189.09,72.08 RH248.2 ; R114.1 177.73,126.68 v2(178.04,126.38) ; R879.1 289.34,101.88 289.4,101.94 289.4,102.8 ; v2(226.47,136.67) 225.87,137.27 RV154.2 ; v2(289.06,104.43) 289.06,104.44 288.36,105.14 C757.2 C736.2 ; JSD1.20 262.2,30.09 v2(262.59,30.49) ; v2(209.98,72.47) 210.35,72.84 CH35.2 ; v2(268.54,101.45) 268.54,101.31 268.08,100.85 C751.2 ; C643.2 277.67,37.82 v2(278.18,37.31) ; v2(244.71,51.57) C1504.1 244.95,50.63 C801.1 ; v2(29.83,208.36) C32.2 ; CV353.2 RV198.2 v2(181.97,146.95) R1139.2 ; v2(150.25,36.92) 149.56,36.92 CD6.2 ; v2(57.89,186.19) 57.89,186.45 57.46,186.88 PC804.1 ; RD30.2 125.27,27.25 125.48,27.47 v2(126.27,27.47) ; RV147.2 214.63,130.29 v2(214.36,130.02) 214.36,129.73 215.3,128.79 CV218.2 ; v2(291.32,105.52) 291.75,105.09 C743.2 ; CC18.2 114.89,112.53 115.32,112.97 115.32,113.12 v2(115.48,113.28) ; PC214.2 v4(211.95,8.65) ; CV64.2 236.08,113.74 v2(236.24,113.91) ; RV17.2 232.27,151.46 v2(232.72,151) 233.28,151.56 CV316.2 ; C573.2 253.55,53.75 C578.2 257.15,54.24 258.33,55.42 v2(258.64,55.42) 258.8,55.57 R767.1 ; SW1.3 343.63,208.51 v2(343.96,208.84) ; RV82.1 183.32,108.33 183.32,106.55 v2(183.44,106.42) 183.14,106.12 QV11.3 ; R88.2 v2(25.76,211.09) 25.87,211.19 26.51,211.19 26.78,210.92 R81.2 ; v2(229,141.04) 229.03,141.02 229.47,141.02 RV46.2 ; 289.4,102.8 R876.2 ; 289.4,102.8 289.19,102.8 288.7,103.29 v2(288.7,103.87) ; v2(252.6,180.58) 253.8,179.38 JSIM1.18 ; v2(295.3,107.01) 295.3,107.92 C734.2 295.33,107.96 C733.2 ; CH2.2 274.89,80.4 v2(274.81,80.33) ; C614.2 338.95,203.16 339.24,203.45 339.24,203.73 339.71,204.2 v2(339.71,204.27) ; CD27.2 154.85,18.19 154.45,17.79 154.22,17.57 CD33.2 153.84,17.03 v2(153.84,16.24) ; v2(149.06,16.26) 149.06,16.45 149.28,16.68 CD28.2 ; v2(215.79,140.59) 215.77,140.61 215.65,140.61 215.28,140.24 215.28,140.17 215.25,140.14 215.25,139.51 CV163.2 ; v2(188.4,160.72) 188.7,161.02 C1206.2 C1207.2 ; v2(314.16,187.19) 313.83,186.85 313.83,185.28 C621.2 ; CV56.2 239.9,126.44 240.39,126.94 CV54.2 240.9,126.35 v2(240.62,126.07) ; C1539.2 v2(353.3,189.62) ; CD37.2 162.66,14.67 162.47,14.86 v2(162.47,16.13) ; v2(244.58,138.01) 244.31,138.01 243.42,137.12 CV358.2 ; v4(121.97,170.51) 121.76,170.31 121.76,168 PQ816.3 ; v2(222.67,128.72) 222.23,128.28 PC947.2 ; v2(219.45,133.7) 219.45,133.71 219.79,134.04 PC932.2 220.12,134.01 220.94,134.01 PC930.2 ; v2(204.91,121.06) 204.67,121.3 RV181.2 ; C1515.2 C1513.2 v2(325.28,188.02) C1514.2 ; v2(323.07,183.27) 323.07,184.51 C1512.2 ; v2(147.76,27.7) 148.75,26.71 CD25.2 ; v2(269.18,40.13) 268.71,40.6 R878.1 ; CH36.2 208.67,79.41 209.27,79.41 v2(209.41,79.27) ; v2(202.95,179.41) 202.95,180.06 202.73,180.29 C703.2 201.87,180.29 201.47,179.88 CE6.2 ; 171.18,144.62 171.18,145.92 v2(170.86,146.24) ; PR404.2 v4(233.28,109.11) ; C46.2 15.86,210.11 v2(15.81,210.16) ; CV74.2 208.56,123.39 v2(207.99,122.82) ; RV69.2 224.9,118 v2(225.41,117.49) ; C1.2 v2(11.27,217.69) ; CV310.2 CV280.2 216.06,171.6 v2(216.01,171.65) ; C52.2 C51.2 267.7,85.57 v2(268.03,85.24) ; R517.1 169.73,157.91 169.07,157.25 C726.2 v2(168.07,156.86) ; CC19.2 v3(136.48,60.21) 136.48,43.66 v2(136.42,43.6) ; v2(243.04,178.46) 243.04,177.33 243.43,176.94 JSIM1.11 ; v2(102.37,161.52) 102.42,161.57 PR738.2 ; RC68.2 175.7,92.47 175.15,91.92 v2(171.73,91.92) ; v2(156.32,152.82) 156.41,152.73 PC502.2 ; CV144.2 182.49,135.01 v2(182.06,134.58) 182.65,134 CV176.2 ; RC56.2 v2(137.52,124.54) ; 290.25,99.25 289.64,98.64 JTAG1.2 ; 290.25,99.25 290.25,97.7 v2(290.17,97.61) ; v4(159.41,165.75) 159.1,165.44 PC817.2 158.76,164.64 PC816.2 ; CD8.2 152.07,36.97 v2(152.92,36.97) ; RC110.2 169.17,16.42 v2(168.88,16.13) ; v2(237.17,123.27) 237.17,123.28 236.61,123.84 CV342.2 ; v2(50.66,196.53) 50.86,196.33 C1001.2 ; CV57.2 248.01,110.38 v2(247.81,110.58) 248.11,110.87 QV7.3 ; v2(296.71,111.02) 296.57,110.88 C774.2 ; PR874.2 159.11,171.2 v2(159.63,170.68) ; v2(210.57,54.01) 210.57,55.48 211.54,56.45 CH6.1 ; PC728.2 97.87,158.32 v2(98.14,158.58) ; v2(184.03,42.08) 183.56,42.08 183.33,41.84 183.33,41.68 183.3,41.66 183.3,40.94 183.71,40.54 CD19.2 CD20.2 ; JEXP1.31 v2(285.39,36.76) ; CE1.2 194.48,43.21 194.65,43.21 195.18,42.67 v2(195.66,42.67) ; PC406.2 v4(232.27,109.11) ; v2(205.34,39.4) 204.34,40.4 CE2.2 ; v2(143.44,63.22) 143.37,63.3 RC16.2 ; C713.2 266.55,61.99 v2(265.67,62.88) ; v2(123.31,183.74) 123.53,183.53 PC5.2 ; RC75.2 164.12,129.34 165.26,128.19 v2(165.26,127.71) 164.34,126.79 QC3.3 ; C355.2 28.81,208.25 v2(28.85,208.29) ; RV11.2 207.37,151.73 206.83,151.18 v2(206.8,151.18) 206.36,151.63 CV27.2 ; CV68.2 216.79,122.98 v2(216.91,123.11) ; C1501.1 244.46,48.15 244.13,48.48 243.99,48.48 v2(243.96,48.5) ; C954.2 332.66,175.65 v2(332.41,175.91) 332.35,175.86 C989.2 ; v2(270.89,42.98) 270.73,43.14 R790.1 ; v2(192.23,61.49) 192.23,60.34 QH3.3 ; CV117.2 224.85,120.16 v2(225.17,119.85) ; v2(335.22,190.13) 335.3,190.21 C1558.2 C1538.2 ; C18.2 R843.1 281.03,123.24 281.3,123.51 v2(281.47,123.51) ; v2(192.44,19.7) 192,20.13 Q72.3 ; v2(241.46,137.88) 241.46,137.74 240.84,137.12 CV221.2 ; v2(233.28,112.92) 232.76,112.92 232.01,113.66 RV111.1 ; C30.2 190.05,174.46 v2(190.05,175.22) ; CV201.2 234.04,113.17 v2(234.3,112.92) ; v2(222.67,132.72) 222.67,132.72 222.23,132.27 PC944.2 ; v2(298.95,117.09) 298.93,117.09 298.71,116.88 296.63,116.88 295.83,116.08 C776.2 ; v2(247.76,113.87) 247.48,113.87 246.95,113.33 RV60.1 ; RD7.1 184.07,37.28 v2(184.03,37.23) 184.07,37.18 RD6.1 ; CV332.2 RV192.2 204.11,142.34 204.68,142.91 205.62,142.91 CV215.2 205.65,143.07 v2(206.1,143.52) 205.47,144.16 CV216.2 ; C290.2 v2(279.18,106.16) ; CMOS1.1 210.51,59.34 209.89,59.96 v2(209.26,59.96) 209.26,61.18 CH51.2 ; v2(232.7,150.27) 231.74,150.27 231.25,150.76 CV33.2 ; v2(245.02,32.6) C580.2 245.02,34.44 C579.2 ; C744.2 299.09,115.33 298.78,115.65 C779.2 298.43,115.65 ; v2(168.17,147.94) 168.64,148.41 168.64,149.79 ; v2(133.79,121.72) 134.04,121.72 134.48,121.28 RC62.1 ; JTP1.10 v3(253.55,106) v2(252.43,107.11) ; QV3.3 249.73,116.96 CV52.2 v2(250.54,116.98) ; CV295.2 CV296.2 214.49,171.17 v2(214.99,171.68) ; v2(182.09,145.11) 182.28,144.92 CV191.2 ; CV281.2 v2(209.41,171.65) ; CH7.1 209.29,59.02 208.95,59.02 208.73,59.24 v2(208.73,59.19) ; RC80.2 162.4,124.04 v2(161.98,124.46) ; v2(248.42,38.32) 248.6,38.49 248.6,39 ; C344.2 21.7,208.2 v2(21.74,208.24) 21.75,208.25 22.45,208.25 22.72,207.99 C354.2 ; PR307.1 v4(241.16,3.31) ; C676.2 354.27,219.34 354.59,219.66 v2(354.59,220.04) ; v2(234.13,119.27) CV118.2 ; v2(188.83,109.94) 188.9,109.88 C783.2 ; v2(129,27.8) 128.9,27.7 RD16.2 ; R804.2 277.58,56.96 v2(277.39,56.77) ; PC814.2 165.72,167.91 v4(165.46,167.65) ; C299.2 196.04,163.95 196.39,164.3 196.39,166.32 195.87,166.84 C300.2 195.05,166.85 195.05,168.03 v2(195.3,168.27) ; RV62.2 231.48,127.01 231.48,127.41 v2(231.82,127.75) ; RV238.2 CV340.2 RV240.2 236.41,127.9 236.57,127.74 v2(236.74,127.74) ; CV153.2 182.96,112.66 182.98,112.67 182.98,113.31 v2(183.19,113.53) ; v2(214.7,67.95) 215.15,67.5 CH75.2 ; CV357.2 237.65,118.76 237.9,118.5 v2(237.9,117.74) RV243.2 ; RC59.1 v2(134.48,124.74) ; PQ709.3 75.18,175.45 75.62,175.89 v2(75.62,176.69) ; C1526.2 347.56,218.96 346.95,218.35 v2(346.58,218.35) ; C724.2 286.65,102.41 286.33,102.1 284.46,102.1 283.68,102.88 v2(283.68,103) ; R106.1 172.25,148.68 171.67,148.11 170.94,148.11 v2(170.91,148.08) ; v2(247.25,53.96) C1502.1 C564.1 ; v2(131.2,2.35) 131.02,2.17 PC7.2 ; v2(218.55,126.69) 218.32,126.92 CV71.2 ; v2(200.71,41.63) 200.76,41.58 C1216.2 ; v2(183.76,21.67) 183.82,21.73 RD11.2 ; C581.2 244.18,42.24 243.96,42.02 v2(243.96,41.29) C1511.1 ; v2(290.3,127.06) R424.1 ; CD9.2 156.1,26.78 CD30.2 156.07,27.2 v2(156.45,27.58) ; PC812.1 v2(66.28,170.65) ; C477.2 C486.2 ; v2(252.38,51.92) 252.38,51.88 252.2,51.7 C577.2 250.76,51.08 250.76,49.92 ; v2(212.71,169.3) 212.71,169.98 211.65,171.03 CV297.2 ; CH5.1 205.94,57.24 RH53.1 v2(204.79,58.39) ; R1684.2 v2(321.86,138.34) ; PCV174.2 218.03,130.18 v2(217.55,129.7) ; v2(268.99,82.83) 268.38,83.44 267.42,83.44 267.32,83.54 ; v2(180.67,153.77) 180.56,153.87 179.57,153.87 178.98,153.28 C725.2 ; PC215.2 v4(215.95,14.11) ; PR684.2 v4(198.74,98.56) ; PC307.2 v4(239.12,3.31) ; PQ829.3 v2(146.41,175.17) ; v2(201.53,169.42) 201.53,169.65 201.49,169.68 CV46.2 ; v2(246.54,37.86) 246.54,40.02 C800.1 ; v2(337.38,208.9) 337.78,208.51 SW1.1 ; CV119.2 233.56,118.25 v2(234.08,117.73) ; JSF1.5 325.93,146.31 v2(325.76,146.14) ; C649.2 CE12.2 279.08,33.41 v2(279.03,33.46) ; v2(329.6,166.03) 329.6,166.59 329.37,166.81 C1004.2 ; C1503.1 247.72,50.63 v2(248.14,51.05) 248.36,51.05 C1505.1 ; RC100.2 128.38,97.88 128.38,97.48 v2(128.19,97.29) ; v4(206.8,18.3) 206.99,18.3 207.56,17.73 PC210.2 ; v2(207.82,151.17) 208.39,151.74 RV163.1 ; v2(176.36,144.34) 176.2,144.17 C112.2 175.62,144.94 175.88,145.2 R108.1 ; CV66.2 212.76,122.11 v2(213.05,122.39) ; CD45.2 v2(117.23,24.87) ; v2(314.63,127) 314.24,126.62 JKB1.12 ; CC135.2 153.16,71.3 RC84.2 153.75,70.81 154.49,70.07 v2(154.7,70.07) ; R1688.2 v2(318.27,128.35) ; CV319.2 222.86,151.78 222.56,152.07 v2(222.53,152.07) 222.12,152.07 CV318.2 ; PC707.2 83.29,185.81 v4(83.1,186) ; C570.2 258.94,33.35 C572.2 260,33.4 v2(260,34.07) ; RV20.2 215.3,153.05 v2(214.99,153.35) 214.99,153.62 215.44,154.06 CV35.2 ; PC945.2 222.3,130.29 222.67,130.65 v2(222.67,130.69) ; C746.2 189.99,40.98 188.91,39.91 v2(188.91,39.65) ; PQ817.3 72.51,175.77 72.97,176.22 v2(72.97,177.09) ; v2(215.95,55.65) 215.95,55.82 RH215.2 ; v2(336.28,155.97) 336.41,156.1 R6.2 ; CV129.2 187.56,108.25 v2(187.92,108.61) ; v2(217.66,163.21) CV23.2 RV7.2 ; v2(218.6,128.75) 218.6,128.79 219.17,129.36 219.85,129.36 PC931.2 ; v2(212.61,76.06) 212.08,76.59 CH71.2 ; v2(282.08,104.72) 282.08,105.13 282.24,105.3 C740.2 C780.2 ; C399.2 v2(110.6,49.16) ; CH73.2 210.99,70.8 211.27,71.07 v2(211.38,71.07) 212.1,71.07 212.25,71.23 ; RV5.2 212.45,150.73 v2(212.17,150.44) ; v2(342.55,201.56) 342.45,201.66 D23.1 ; C553.2 293.29,139.59 v2(293.28,139.57) ; PC666.2 v4(197.72,98.56) ; R793.2 277.45,52.02 R786.1 ; C755.2 258.94,97.42 v2(258.85,97.51) ; v2(212.61,68.86) 212.83,68.64 212.83,67.77 RH187.2 ; CH42.2 208.25,74.49 v2(208.11,74.34) ; CV199.2 CV293.2 v2(217.66,166.51) ; D8.1 191.64,159.34 v2(191.4,159.11) ; v2(258.36,62.04) 258.4,62 258.4,61.85 258.65,61.6 260.97,61.6 C712.2 ; CH74.2 213.76,72.44 v2(213.76,73.08) ; PR302.1 v4(237.09,3.31) ; v2(149.97,121.93) 149.72,121.68 PC920.2 ; R1583.1 277.57,48.84 277.76,49.02 v2(278.05,49.02) 278.13,48.95 278.93,48.95 278.94,48.93 279.92,48.93 280.35,49.36 R1154.1 ; v2(317.66,137.5) 318.04,137.5 318.37,137.17 C756.2 ; v2(227.53,131.67) 227.62,131.76 PC958.2 ; PC610.2 305.18,160.85 v4(305.8,160.85) ; v2(204.26,77.17) 203.84,76.75 CH22.2 ; R791.1 263.18,61.71 C706.2 264.45,61.76 264.45,62.38 v2(264.35,62.48) ; C752.2 268.08,96.39 267.5,95.81 v2(267.5,95.76) ; CH30.2 207.95,68.58 v2(207.46,68.09) ; C635.2 277.17,37.2 ; 277.17,37.2 C642.2 ; 277.17,37.2 v2(278.04,36.33) ; PC918.2 v2(146.92,122.9) ; PC815.2 v4(150.48,159.5) ; v2(105.01,152.92) 104.5,153.43 PU702.4 ; RV186.2 v2(182.16,127.65) ; CV65.2 228.46,118.17 v2(227.79,117.5) 227.44,117.85 CV63.2 ; v2(121.89,25.45) 122.38,25.94 123.54,25.94 123.55,25.93 CD24.2 CD23.2 ; v2(200.21,75.99) 200.16,76.05 199.71,76.05 CH21.2 ; v2(139.91,160) 139.91,159.3 140.25,158.96 PQ6.6 ; v2(242.93,109.36) 242.88,109.31 PC407.2 ; v2(156.09,36.74) 155.81,37.02 CD5.2 ; v2(317.04,146.54) 317.63,147.13 JSF1.6 ; Q47.3 v2(110.35,154.5) ; CD7.2 147.02,36.93 v2(147.76,36.93) ; C1507.1 248.08,53.61 248.08,53.85 v2(247.99,53.94) ; C633.2 v2(271.22,39.51) ; C765.2 172.18,162.43 v2(172.83,161.79) ; PC727.2 PC726.2 89.87,165.37 v2(89.31,164.81) ; v2(329.12,175.23) 329.48,174.87 JLED2.7 ; v2(189.31,164.12) 189.31,164.4 188.95,164.77 C301.2 ; 223.1,73.72 v2(223.07,73.72) ; 223.1,73.72 223.63,73.72 CH15.2 ; CD43.2 CD44.2 183.75,28.38 v2(184.03,28.66) ; CV343.2 226.45,140.3 v2(226.69,140.55) ; v4(242.45,12.51) 242.45,12.95 241.8,13.6 PC308.2 ; JSIM1.15 255.9,191.09 v2(255.9,191.08) ; C560.1 244.17,40.02 243.56,40.63 v2(243.56,40.69) ; v2(251.95,93.38) JTP1.9 ; C705.2 v2(272.14,62.78) 272.69,62.78 R518.1 ; v2(59.42,172.26) 59.78,172.63 PQ818.3 ; RH223.2 195.79,54.66 195.03,53.9 194.92,53.9 194.32,53.3 194.32,51.97 v2(194.22,51.87) ; PC800.2 245.35,75.03 v2(245.36,75.04) ; CV331.2 v2(182.13,125.62) ; v2(231.05,133.48) 231.05,133.58 231.22,133.76 231.22,134.08 RV113.1 ; JSD1.19 271.97,29.49 271.74,29.26 v2(271.74,28.71) ; CV114.2 233.88,123.24 v2(234.36,122.75) CV213.2 ; v2(200.87,85.15) 201.2,85.15 CH28.2 ; v2(224.49,66.37) 224.44,66.32 224.44,66.2 224.28,66.04 RH118.1 RH138.2 RH136.2 ; PC959.2 227.9,133.2 227.47,133.64 v2(227.47,133.71) ; C637.2 277.67,34.43 v2(277.94,34.7) ; CV61.2 228.38,136.07 228.61,135.84 v2(228.61,135.61) 228.95,135.27 229.78,135.27 230.34,135.83 230.34,136.21 230.36,136.23 RV35.1 ; JSD1.3 263.34,30.82 v2(263.42,30.9) ; v2(55.61,195.59) 55.56,195.64 55.55,195.64 55.33,195.87 55.33,195.87 54.97,196.23 C998.2 ; CD32.2 156.76,16.4 v2(156.9,16.26) ; RV80.2 186.55,106.01 v2(186.66,106.12) ; CH47.2 216.11,77.9 216.24,78.03 218.25,78.03 v2(218.42,77.85) ; R748.2 v2(328,130.9) ; v2(194.34,85.46) 194.34,84.92 195.15,84.12 CH32.2 CH33.2 ; PR207.1 v4(212.96,8.65) ; CH72.2 211.63,74.14 211.95,74.46 v2(212.38,74.46) ; v2(23.73,208.28) R76.2 ; v2(225.52,134.64) 226.06,135.18 RV25.1 ; PR858.2 153.18,176.97 PR844.2 152.29,177.6 v4(152.4,177.7) ; CV225.2 CV223.2 v2(237.16,142.46) ; CV278.2 224.37,136.34 v2(224.64,136.61) ; PC401.2 v4(229.98,103.77) ; v2(22.46,194.89) C342.2 ; v2(244.01,43.32) C559.1 ; C750.2 264.52,95.29 264.48,95.29 264.48,95.26 v2(264.52,95.26) ; C401.2 320.28,125.49 v2(320.76,125.01) 320.76,124.15 320.55,123.94 Q85.3 ; C701.2 197.72,188.05 198.03,187.74 v2(198.03,187.55) ; v2(276.73,110.81) 276.89,110.97 R892.1 ; v2(220.49,126.75) 219.99,127.25 219.99,127.33 PC934.2 ; v2(260.31,34.67) 260.33,34.67 261.22,33.78 R826.2 ; PR405.2 v4(231.25,108.98) ; v2(184.03,43.6) 184.56,43.6 184.79,43.37 CD18.2 CD17.2 ; RV49.2 226.81,121.17 226.69,121.29 v2(226.68,121.29) ; v2(253.83,52.23) 254.49,52.23 255.21,51.51 C714.2 ; v2(272.33,79.46) 272.16,79.64 RH56.2 ; v2(298.13,103.95) 298.13,103.56 297.5,102.93 C721.2 ; 168.64,144.62 168.64,145.61 v2(168.03,146.21) 167.37,145.55 U26.1 ; v2(269.73,62.53) 270.45,61.81 C708.2 ; C675.2 354.5,220.74 v2(354.76,220.99) ; RV65.2 194.25,159.89 v2(193.93,159.57) ; R803.2 v2(269.71,42.98) ; PC665.2 PR682.2 200.16,92.82 v4(199.5,93.48) ; R1141.2 335.26,166.51 335.75,166.99 v2(335.75,167.09) ; v2(129.79,3.38) 129.73,3.31 PC15.2 ; RV242.2 CV341.2 223.88,117.32 v2(223.94,117.38) ; R889.1 278.95,117.04 278.54,117.04 278.42,117.17 v2(278.31,117.17) 277.74,116.6 276.41,116.6 275.66,117.35 v3(275.66,117.87) 275.66,119.32 276.5,120.15 C720.2 ; U53.4 v2(201.15,28.66) ; QV6.3 181.89,111.25 v2(182.28,111.65) ; RD27.2 v2(121.59,27.69) ; JSD1.21 247.33,29.49 v2(246.97,29.84) ; PC818.1 v2(37.36,170.18) ; PC954.2 PC953.2 225.07,126.23 v2(225.55,125.75) 225.74,125.93 PC960.2 ; v2(261.58,182.37) 260.8,182.37 C631.2 ; U89.2 v2(19.9,210.13) ; PD1.2 v2(239.33,63.87) ; PC208.2 v4(206.1,9.79) ; C396.2 v2(110.6,40.53) ; RV104.1 v2(244.67,116.98) ; R1686.2 v2(328.06,127.09) ; RC89.2 176.67,100.39 v2(177.69,100.39) ; v2(320.43,207.12) 320.43,205.98 320.9,205.51 C447.2 ; CV274.2 CV275.2 216.71,135.01 v2(217.4,135.7) ; RV120.2 v2(181.97,137.81) ; v2(225.47,131.77) 226.03,132.32 PC952.2 ; v2(26.48,192.72) R87.2 ; v2(295.74,104.55) 295.54,104.34 C741.2 294.45,105.27 C722.2 ; PQ830.3 v2(34.72,174.7) ; PC813.2 v4(149.21,159.5) ; v2(209.41,151.18) CV22.2 ; v2(258.85,91.78) 259.41,91.22 JUSH1.22 ; C623.2 317.86,175.98 v2(317.11,175.23) ; PC917.2 v2(152.26,121.96) ; CV146.2 182.65,143.9 v2(182.14,143.4) 182.14,143.32 182.57,142.89 CV133.2 ; v2(28.56,194.87) C340.2 ; v2(297.01,138.86) 297.37,139.22 R657.2 ; v2(167.73,104.92) 167.45,104.64 166.56,104.64 RC82.2 ; CD34.2 151.68,16.36 v2(151.58,16.26) ; C452.2 324.25,204.63 C448.2 324.24,205.17 323.93,205.47 v2(323.12,205.47) ; v2(354.14,214.26) 353.96,214.26 353.75,214.46 C1524.2 ; CH17.2 v2(191.4,68.91) ; CH40.2 211.65,64.08 v2(211.27,64.46) ; v2(205.09,171.69) 205.19,171.59 CV294.2 ; PC806.2 v4(128.63,170.18) ; v2(24.75,211.16) R82.2 ; v2(297.04,126.58) C551.2 ; RV61.1 v2(250.53,118)
  GND1 w0.203: 111.33,19.34 H3.1 ; H3.1 112.67,19.82 ; H3.1 112.67,22.51 ; H3.1 113.16,21.17 ; H3.1 111.33,22.99 ; H3.1 109.99,19.82 ; H3.1 109.5,21.17 ; H3.1 109.99,22.51 ; 160.77,186.79 JDOCK1.145 ; JDOCK1.145 162.88,182.82 ; JDOCK1.145 160.77,184.81 ; JDOCK1.145 162.88,184.81 ; JDOCK1.145 161.82,186.79 ; JDOCK1.145 162.88,186.79 ; JDOCK1.145 160.77,182.82 ; JDOCK1.145 161.82,182.82 ; JUSB4.13 14.19,175.25 ; JUSB4.13 14.19,174.37 ; JUSB4.13 10.63,174.37 ; JUSB4.13 14.19,176.12 ; JUSB4.13 10.63,175.25 ; JUSB4.13 12.41,174.37 ; H14.1 113.59,142.65 ; H14.1 112.41,145.42 ; H14.1 113.59,145 ; H14.1 114,143.83 ; H14.1 111.24,145 ; H14.1 112.41,142.24 ; H14.1 110.83,143.83 ; H14.1 111.24,142.65 ; 15.17,216.04 H27.1 ; H27.1 15.66,214.69 ; H27.1 15.66,217.38 ; H27.1 18.34,214.69 ; H27.1 17,214.21 ; H27.1 18.83,216.04 ; H27.1 17,217.86 ; H27.1 18.34,217.38 ; H17.1 131.23,76.6 ; H17.1 129.05,74.41 ; H17.1 130.65,78.19 ; H17.1 127.45,78.19 ; H17.1 129.05,78.78 ; H17.1 126.86,76.6 ; H17.1 127.45,75 ; H17.1 130.65,75 ; 126.86,112.6 H16.1 ; H16.1 130.65,114.19 ; H16.1 127.45,114.19 ; H16.1 130.65,111 ; H16.1 127.45,111 ; H16.1 129.05,110.41 ; H16.1 129.05,114.78 ; H16.1 131.23,112.6 ; 234.6,45.53 JSATA2.13 ; JSATA2.13 235.65,45.53 ; JSATA2.13 234.45,46.06 ; JSATA2.13 235.65,46.58 ; JSATA2.13 234.6,46.58 ; JSATA2.13 235.8,46.06 ; JSATA2.13 235.13,46.73 ; JSATA2.13 235.13,45.38 ; 234.51,54.23 MBATT1.8 ; MBATT1.8 231.25,54.23 ; MBATT1.8 234.51,55.06 ; MBATT1.8 234.51,55.88 ; MBATT1.8 231.25,55.88 ; MBATT1.8 231.25,55.06 ; MBATT1.8 232.88,54.23 ; MBATT1.8 232.88,55.88 ; JSATA1.23 111.84,28.62 ; JSATA1.23 108.24,28.62 ; JSATA1.23 111.84,27.57 ; JSATA1.23 111.84,29.68 ; JSATA1.23 110.04,27.57 ; JSATA1.23 110.04,29.68 ; JSATA1.23 108.24,27.57 ; JSATA1.23 108.24,29.68 ; 179.45,79.5 H19.1 ; H19.1 178.87,81.1 ; H19.1 181.05,83.28 ; H19.1 181.05,78.91 ; H19.1 179.45,82.69 ; H19.1 182.65,82.69 ; H19.1 183.23,81.1 ; H19.1 182.65,79.5 ; 298.45,62.81 H2.1 ; H2.1 297.47,60.27 ; H2.1 304.53,60.27 ; H2.1 301,63.8 ; H2.1 301,56.73 ; H2.1 303.55,57.72 ; H2.1 303.55,62.81 ; H2.1 298.45,57.72 ; JDOCK1.164 210.56,188.73 ; JDOCK1.164 206.44,187.75 ; JDOCK1.164 210.56,187.75 ; JDOCK1.164 208.5,187.75 ; JDOCK1.164 208.5,189.71 ; JDOCK1.164 210.56,189.71 ; JDOCK1.164 206.44,189.71 ; JDOCK1.164 206.44,188.73 ; JSATA2.17 238.5,30 ; JSATA2.17 237.3,29.48 ; JSATA2.17 237.3,30.53 ; JSATA2.17 237.83,29.33 ; JSATA2.17 238.35,30.53 ; JSATA2.17 238.35,29.48 ; JSATA2.17 237.83,30.68 ; JSATA2.17 237.15,30 ; 109.99,13.01 H6.1 ; H6.1 112.67,13.01 ; H6.1 109.99,15.7 ; H6.1 111.33,16.18 ; H6.1 109.5,14.36 ; H6.1 112.67,15.7 ; H6.1 113.16,14.36 ; H6.1 111.33,12.53 ; JDOCK1.157 167.2,185.6 ; JDOCK1.157 168,183.75 ; JDOCK1.157 167.2,184.01 ; JDOCK1.157 168.8,184.01 ; JDOCK1.157 166.95,184.81 ; PBATT1.4 116.25,190.27 ; PBATT1.4 115.58,188.72 ; PBATT1.4 115.37,189.4 ; PBATT1.4 117.13,189.4 ; PBATT1.4 116.92,188.72 ; PBATT1.4 116.25,188.52 ; PBATT1.4 115.58,190.07 ; PBATT1.4 116.92,190.07 ; JHDMI1.21 2.3,215.17 ; JHDMI1.21 3.58,215.17 ; JHDMI1.21 3.58,214.24 ; JHDMI1.21 1.01,215.17 ; JHDMI1.21 1.01,214.24 ; 362,161.73 H11.1 ; H11.1 360.17,163.56 ; H11.1 360.66,164.9 ; H11.1 362,165.38 ; H11.1 363.34,164.9 ; H11.1 363.83,163.56 ; H11.1 360.66,162.21 ; H11.1 363.34,162.21 ; 10.63,191.82 JUSB4.10 ; JUSB4.10 12.41,191.82 ; JUSB4.10 10.63,190.95 ; JUSB4.10 14.19,191.82 ; JUSB4.10 14.19,190.07 ; JUSB4.10 14.19,190.95 ; 356.68,223.83 JUSB2.4 ; JUSB2.4 357.74,222.78 ; JUSB2.4 356.53,223.31 ; JUSB2.4 356.68,222.78 ; JUSB2.4 357.21,223.98 ; JUSB2.4 357.21,222.63 ; JUSB2.4 357.74,223.83 ; JUSB2.4 357.88,223.31 ; 140.66,183.46 H13.1 ; H13.1 143.34,186.15 ; H13.1 142,186.63 ; H13.1 140.17,184.81 ; H13.1 143.34,183.46 ; H13.1 142,182.98 ; H13.1 140.66,186.15 ; H13.1 143.83,184.81 ; H8.1 102,95.52 ; H8.1 100.66,95.04 ; H8.1 103.83,93.7 ; H8.1 102,91.87 ; H8.1 103.34,92.35 ; H8.1 103.34,95.04 ; H8.1 100.17,93.7 ; H8.1 100.66,92.35 ; 63.3,203.76 H28.1 ; H28.1 65,199.72 ; H28.1 63.3,200.35 ; H28.1 62.66,202.06 ; H28.1 66.7,203.76 ; H28.1 65,204.39 ; H28.1 66.7,200.35 ; H28.1 67.34,202.06 ; 358.71,195.63 JUSB3.7 ; JUSB3.7 358.18,195.78 ; JUSB3.7 358.71,196.98 ; JUSB3.7 358.04,196.31 ; JUSB3.7 358.18,196.83 ; 235.72,24.33 JSATA2.32 ; JSATA2.32 237.12,25.11 ; JSATA2.32 237.12,24.33 ; JSATA2.32 235.72,25.88 ; JSATA2.32 234.33,25.88 ; JSATA2.32 237.12,25.88 ; JSATA2.32 234.33,25.11 ; JSATA2.32 234.33,24.33 ; JHDMI1.2 12.06,200.63 ; JHDMI1.2 11.13,201.56 ; JHDMI1.2 12.06,201.56 ; JHDMI1.2 12.18,201.09 ; JHDMI1.2 11.6,200.51 ; JHDMI1.2 11.13,200.63 ; JHDMI1.2 11.01,201.09 ; H4.1 113.16,72.31 ; H4.1 111.33,70.48 ; H4.1 109.99,73.65 ; H4.1 109.99,70.96 ; H4.1 109.5,72.31 ; H4.1 112.67,73.65 ; H4.1 112.67,70.96 ; H4.1 111.33,74.13 ; 13.82,183.62 JUSB4.7 ; JUSB4.7 13.29,182.42 ; JUSB4.7 13.96,183.1 ; JUSB4.7 13.82,182.57 ; JUSB4.7 13.29,183.77 ; 223.62,106.9 H25.1 ; H25.1 226.82,110.09 ; H25.1 227.4,108.5 ; H25.1 223.62,110.09 ; H25.1 225.22,106.31 ; H25.1 226.82,106.9 ; H25.1 225.22,110.68 ; H25.1 223.03,108.5 ; H10.1 249.83,126.6 ; H10.1 249.34,127.94 ; H10.1 246.17,126.6 ; H10.1 248,124.77 ; H10.1 249.34,125.25 ; H10.1 246.66,127.94 ; H10.1 246.66,125.25 ; H10.1 248,128.42 ; 320.72,234.12 JUSB1.12 ; JUSB1.12 320.72,236.87 ; JUSB1.12 321.6,236.87 ; JUSB1.12 320.72,235.49 ; JUSB1.12 321.6,234.12 ; 161.44,188.73 JDOCK1.161 ; JDOCK1.161 161.44,187.75 ; JDOCK1.161 165.56,188.73 ; JDOCK1.161 163.5,189.71 ; JDOCK1.161 161.44,189.71 ; JDOCK1.161 165.56,187.75 ; JDOCK1.161 165.56,189.71 ; JDOCK1.161 163.5,187.75 ; JUSB2.11 368.06,211.08 ; JUSB2.11 365.32,211.96 ; JUSB2.11 365.32,211.08 ; JUSB2.11 366.69,211.08 ; JUSB2.11 368.06,211.96 ; JHDMI1.17 10.51,208.13 ; JHDMI1.17 10.51,209.06 ; JHDMI1.17 10.63,208.59 ; JSATA2.14 237.83,28.28 ; JSATA2.14 237.83,26.93 ; JSATA2.14 237.15,27.6 ; JSATA2.14 238.35,27.08 ; JSATA2.14 237.3,27.08 ; JSATA2.14 237.3,28.13 ; JSATA2.14 238.5,27.6 ; JSATA2.14 238.35,28.13 ; MBATT1.5 233.66,58.51 ; MBATT1.5 233.48,57.91 ; MBATT1.5 232.28,57.91 ; MBATT1.5 232.1,58.51 ; MBATT1.5 233.48,59.1 ; MBATT1.5 232.28,59.1 ; 204.66,4.9 H7.1 ; H7.1 204.17,3.56 ; H7.1 204.66,2.21 ; H7.1 207.34,4.9 ; H7.1 206,1.73 ; H7.1 207.34,2.21 ; H7.1 207.83,3.56 ; H7.1 206,5.38 ; H30.1 288.87,19.38 ; H30.1 286.53,21.73 ; H30.1 289.29,20.56 ; H30.1 287.7,18.97 ; H30.1 288.87,21.73 ; H30.1 286.11,20.56 ; H30.1 286.53,19.38 ; H30.1 287.7,22.14 ; 45,199.72 H29.1 ; H29.1 45,204.39 ; H29.1 46.7,200.35 ; H29.1 43.3,200.35 ; H29.1 43.3,203.76 ; H29.1 47.34,202.06 ; H29.1 42.66,202.06 ; H29.1 46.7,203.76 ; 206.44,179.9 JDOCK1.156 ; JDOCK1.156 210.56,181.86 ; JDOCK1.156 208.5,179.9 ; JDOCK1.156 206.44,181.86 ; JDOCK1.156 210.56,179.9 ; JDOCK1.156 210.56,180.88 ; JDOCK1.156 208.5,181.86 ; JDOCK1.156 206.44,180.88 ; PBATT1.2 112.92,190.07 ; PBATT1.2 113.13,189.4 ; PBATT1.2 112.25,188.52 ; PBATT1.2 111.58,188.72 ; PBATT1.2 112.92,188.72 ; PBATT1.2 111.37,189.4 ; PBATT1.2 111.58,190.07 ; PBATT1.2 112.25,190.27 ; JDOCK1.160 204.8,184.01 ; JDOCK1.160 205.05,184.81 ; JDOCK1.160 203.2,184.01 ; JDOCK1.160 204.8,185.6 ; JDOCK1.160 204,185.86 ; JDOCK1.160 204,183.75 ; JDOCK1.160 203.2,185.6 ; JUSB3.12 366.69,205.03 ; JUSB3.12 365.32,204.16 ; JUSB3.12 368.06,205.03 ; JUSB3.12 365.32,205.03 ; JUSB3.12 368.06,204.16 ; JDOCK1.153 165.56,180.88 ; JDOCK1.153 161.44,180.88 ; JDOCK1.153 165.56,181.86 ; JDOCK1.153 161.44,181.86 ; JDOCK1.153 163.5,181.86 ; JDOCK1.153 165.56,179.9 ; JDOCK1.153 161.44,179.9 ; JDOCK1.153 163.5,179.9 ; H22.1 317.9,227.39 ; H22.1 315.07,224.56 ; H22.1 315.85,222.5 ; H22.1 315.85,226.61 ; H22.1 320.73,224.56 ; H22.1 317.9,221.72 ; H22.1 319.95,222.5 ; H22.1 319.95,226.61 ; JSATA2.21 236.1,33.21 ; JSATA2.21 234.9,33.73 ; JSATA2.21 234.9,32.68 ; JSATA2.21 235.43,33.88 ; JSATA2.21 235.95,33.73 ; JSATA2.21 235.95,32.68 ; JSATA2.21 235.43,32.53 ; H5.1 283.34,8.01 ; H5.1 283.34,10.7 ; H5.1 282,11.18 ; H5.1 283.83,9.36 ; H5.1 280.66,8.01 ; H5.1 280.66,10.7 ; H5.1 282,7.53 ; H5.1 280.17,9.36 ; 10.47,212.34 JHDMI1.23 ; JHDMI1.23 13.03,213.27 ; JHDMI1.23 10.47,211.42 ; JHDMI1.23 11.75,211.42 ; JHDMI1.23 10.47,213.27 ; JHDMI1.23 13.03,212.34 ; JHDMI1.23 13.03,211.42 ; JHDMI1.23 11.75,213.27 ; 193.05,184.81 JDOCK1.159 ; JDOCK1.159 192,183.75 ; JDOCK1.159 192.8,184.01 ; JDOCK1.159 190.95,184.81 ; JDOCK1.159 191.2,184.01 ; JDOCK1.159 192,185.86 ; JDOCK1.159 192.8,185.6 ; PBATT1.11 108.18,189.4 ; PBATT1.11 108.18,187.41 ; PBATT1.11 106.07,187.41 ; PBATT1.11 106.07,189.4 ; PBATT1.11 107.13,187.41 ; 232.28,56.41 MBATT1.6 ; MBATT1.6 233.48,56.41 ; MBATT1.6 232.88,56.23 ; MBATT1.6 233.66,57.01 ; MBATT1.6 233.48,57.6 ; MBATT1.6 232.1,57.01 ; MBATT1.6 232.28,57.6 ; 11,169.03 H26.1 ; H26.1 9.17,170.86 ; H26.1 9.66,169.51 ; H26.1 12.34,172.2 ; H26.1 12.83,170.86 ; H26.1 11,172.68 ; H26.1 9.66,172.2 ; H26.1 12.34,169.51 ; 325.28,226.01 JUSB1.4 ; JUSB1.4 325.95,225.34 ; JUSB1.4 326.48,226.54 ; JUSB1.4 325.42,225.49 ; JUSB1.4 326.48,225.49 ; JUSB1.4 326.62,226.01 ; 192,187.75 JDOCK1.163 ; JDOCK1.163 193.05,187.75 ; JDOCK1.163 192,189.71 ; JDOCK1.163 193.05,189.71 ; JDOCK1.163 193.05,188.73 ; JDOCK1.163 190.95,187.75 ; JDOCK1.163 190.95,188.73 ; JDOCK1.163 190.95,189.71 ; JDOCK1.154 181.05,181.86 ; JDOCK1.154 180,179.9 ; JDOCK1.154 178.95,180.88 ; JDOCK1.154 180,181.86 ; JDOCK1.154 178.95,179.9 ; JDOCK1.154 178.95,181.86 ; JDOCK1.154 181.05,180.88 ; JDOCK1.154 181.05,179.9 ; JHDMI1.11 10.51,205.13 ; JHDMI1.11 10.63,205.59 ; JHDMI1.11 10.51,206.06 ; 329.45,226.84 JUSB1.7 ; JUSB1.7 328.92,226.99 ; JUSB1.7 328.78,227.51 ; JUSB1.7 330.12,227.51 ; JUSB1.7 329.98,226.99 ; 237.3,31.88 JSATA2.20 ; JSATA2.20 238.35,32.93 ; JSATA2.20 237.15,32.41 ; JSATA2.20 237.83,33.08 ; JSATA2.20 238.5,32.41 ; JSATA2.20 237.3,32.93 ; JSATA2.20 237.83,31.73 ; JSATA2.20 238.35,31.88 ; 3.94,174.37 JUSB4.12 ; JUSB4.12 3.94,175.25 ; JUSB4.12 5.31,174.37 ; JUSB4.12 6.68,175.25 ; JUSB4.12 6.68,174.37 ; 178.95,184.81 JDOCK1.158 ; JDOCK1.158 180,183.75 ; JDOCK1.158 180.8,185.6 ; JDOCK1.158 180,185.86 ; JDOCK1.158 180.8,184.01 ; JDOCK1.158 181.05,184.81 ; JDOCK1.158 179.2,184.01 ; JDOCK1.158 179.2,185.6 ; 128.32,187.41 PBATT1.10 ; PBATT1.10 128.32,189.4 ; PBATT1.10 129.37,187.41 ; PBATT1.10 130.43,189.4 ; PBATT1.10 130.43,187.41 ; 233.45,45.06 JSATA2.12 ; JSATA2.12 233.6,44.53 ; JSATA2.12 234.13,45.73 ; JSATA2.12 234.8,45.06 ; JSATA2.12 233.6,45.58 ; JSATA2.12 234.13,44.38 ; JUSB3.4 357.74,199.28 ; JUSB3.4 356.68,199.28 ; JUSB3.4 356.68,200.33 ; JUSB3.4 357.21,199.13 ; JUSB3.4 357.74,200.33 ; JUSB3.4 357.88,199.81 ; JUSB3.4 357.21,200.48 ; JUSB3.4 356.53,199.81 ; 234.9,35.08 JSATA2.24 ; JSATA2.24 235.95,35.08 ; JSATA2.24 235.43,34.93 ; JSATA2.24 236.1,35.61 ; JSATA2.24 235.95,36.13 ; JSATA2.24 234.75,35.61 ; JSATA2.24 235.43,36.28 ; JSATA2.24 234.9,36.13 ; JUSB3.11 368.06,187.58 ; JUSB3.11 366.69,187.58 ; JUSB3.11 365.32,188.46 ; JUSB3.11 368.06,188.46 ; JUSB3.11 365.32,187.58 ; H9.1 232.8,78.92 ; H9.1 234.14,78.44 ; H9.1 234.14,75.75 ; H9.1 230.97,77.1 ; H9.1 232.8,75.27 ; H9.1 231.46,75.75 ; H9.1 231.46,78.44 ; H9.1 234.63,77.1 ; 108.24,66.04 JSATA1.24 ; JSATA1.24 111.84,64.99 ; JSATA1.24 110.04,64.99 ; JSATA1.24 108.24,64.99 ; JSATA1.24 111.84,66.04 ; JSATA1.24 110.04,67.09 ; JSATA1.24 108.24,67.09 ; JSATA1.24 111.84,67.09 ; 64.17,186.6 H1.1 ; H1.1 66,188.42 ; H1.1 66,184.77 ; H1.1 67.83,186.6 ; H1.1 67.34,187.94 ; H1.1 64.66,185.25 ; H1.1 64.66,187.94 ; H1.1 67.34,185.25 ; 314.54,240.51 JLOM1.15 314.02,240.51 ; 110.25,188.52 PBATT1.1 ; PBATT1.1 110.92,188.72 ; PBATT1.1 111.13,189.4 ; PBATT1.1 109.58,188.72 ; PBATT1.1 110.25,190.27 ; PBATT1.1 110.92,190.07 ; PBATT1.1 109.58,190.07 ; PBATT1.1 109.37,189.4 ; 2.27,195.94 JHDMI1.20 ; JHDMI1.20 2.27,195.02 ; JHDMI1.20 4.83,195.02 ; JHDMI1.20 4.83,195.94 ; JHDMI1.20 3.55,195.02 ; JUSB2.13 359.59,228.53 ; JUSB2.13 357.81,226.78 ; JUSB2.13 361.37,228.53 ; JUSB2.13 357.81,227.66 ; JUSB2.13 361.37,227.66 ; H20.1 288.87,40.38 ; H20.1 289.29,41.56 ; H20.1 286.11,41.56 ; H20.1 287.7,39.97 ; H20.1 286.53,40.38 ; H20.1 286.53,42.73 ; H20.1 287.7,43.14 ; H20.1 288.87,42.73 ; 357.81,188.46 JUSB3.10 ; JUSB3.10 357.81,189.33 ; JUSB3.10 361.37,188.46 ; JUSB3.10 359.59,187.58 ; JUSB3.10 357.81,187.58 ; JUSB3.10 361.37,187.58 ; JUSB4.11 5.31,191.82 ; JUSB4.11 6.68,190.95 ; JUSB4.11 3.94,190.95 ; JUSB4.11 3.94,191.82 ; JUSB4.11 6.68,191.82 ; 228.66,183.46 H12.1 ; H12.1 231.83,184.81 ; H12.1 228.66,186.15 ; H12.1 231.34,186.15 ; H12.1 230,186.63 ; H12.1 230,182.98 ; H12.1 231.34,183.46 ; H12.1 228.17,184.81 ; H23.1 244.98,151.5 ; H23.1 241.2,149.9 ; H23.1 240.61,151.5 ; H23.1 244.4,153.09 ; H23.1 244.4,149.9 ; H23.1 242.8,153.68 ; H23.1 241.2,153.09 ; H23.1 242.8,149.31 ; JSATA2.33 237.12,48.88 ; JSATA2.33 235.72,48.88 ; JSATA2.33 234.33,47.33 ; JSATA2.33 237.12,48.11 ; JSATA2.33 234.33,48.11 ; JSATA2.33 234.33,48.88 ; JSATA2.33 237.12,47.33 ; JSATA2.33 235.72,47.33 ; 11.13,204.56 JHDMI1.8 ; JHDMI1.8 11.13,203.63 ; JHDMI1.8 12.06,203.63 ; JHDMI1.8 11.01,204.09 ; JHDMI1.8 12.06,204.56 ; JHDMI1.8 12.18,204.09 ; 184.01,161.34 H15.1 ; H15.1 185.19,161.75 ; H15.1 184.01,164.52 ; H15.1 185.6,162.93 ; H15.1 185.19,164.1 ; H15.1 182.42,162.93 ; H15.1 182.84,164.1 ; H15.1 182.84,161.75 ; JSATA2.4 233.24,30.74 ; JSATA2.4 234.6,31.04 ; JSATA2.4 233.25,31.04 ; JUSB4.4 15.46,179.6 ; JUSB4.4 14.26,179.07 ; JUSB4.4 14.79,178.92 ; JUSB4.4 15.32,180.12 ; JUSB4.4 15.32,179.07 ; JUSB4.4 14.79,180.27 ; JUSB4.4 14.26,180.12 ; JUSB4.4 14.12,179.6 ; 189.4,151.44 H24.1 ; H24.1 192.6,151.44 ; H24.1 193.18,153.04 ; H24.1 189.4,154.63 ; H24.1 191,150.85 ; H24.1 192.6,154.63 ; H24.1 191,155.22 ; H24.1 188.81,153.04 ; 231.25,67.28 MBATT1.7 ; MBATT1.7 234.51,67.28 ; MBATT1.7 232.88,65.63 ; MBATT1.7 234.51,66.46 ; MBATT1.7 231.25,66.46 ; MBATT1.7 231.25,65.63 ; MBATT1.7 232.88,67.28 ; MBATT1.7 234.51,65.63 ; JUSB1.10 338.18,226.62 ; JUSB1.10 337.3,226.62 ; JUSB1.10 338.18,230.17 ; JUSB1.10 338.18,228.39 ; JUSB1.10 337.3,230.17 ; JUSB1.10 336.42,226.62 ; JSATA2.7 233.93,35.52 ; JSATA2.7 234.45,35.37 ; JSATA2.7 233.25,34.85 ; JSATA2.7 234.6,34.85 ; JSATA2.7 233.4,35.37 ; JHDMI1.22 13.03,196.92 ; JHDMI1.22 10.47,198.77 ; JHDMI1.22 11.75,196.92 ; JHDMI1.22 13.03,198.77 ; JHDMI1.22 13.03,197.84 ; JHDMI1.22 10.47,196.92 ; JHDMI1.22 11.75,198.77 ; JHDMI1.22 10.47,197.84 ; 358.04,219.81 JUSB2.7 ; JUSB2.7 358.71,220.48 ; JUSB2.7 358.71,219.13 ; JUSB2.7 358.18,220.33 ; JUSB2.7 358.18,219.28 ; H18.1 180.21,120.28 ; H18.1 178.61,116.5 ; H18.1 181.81,116.5 ; H18.1 178.03,118.1 ; H18.1 180.21,115.91 ; H18.1 181.81,119.69 ; H18.1 182.39,118.1 ; H18.1 178.61,119.69 ; JUSB3.13 357.81,205.03 ; JUSB3.13 357.81,203.28 ; JUSB3.13 357.81,204.16 ; JUSB3.13 361.37,205.03 ; JUSB3.13 361.37,204.16 ; JUSB3.13 359.59,205.03 ; 339.57,155.23 H21.1 ; H21.1 339.57,151.88 ; H21.1 339.57,153.56 ; H21.1 344,155.23 ; H21.1 348.43,153.56 ; H21.1 344,151.88 ; H21.1 348.43,155.23 ; H21.1 348.43,151.88 ; 357.81,211.96 JUSB2.10 ; JUSB2.10 357.81,211.08 ; JUSB2.10 361.37,211.08 ; JUSB2.10 359.59,211.08 ; JUSB2.10 357.81,212.83 ; JUSB2.10 361.37,211.96 ; 190.95,179.9 JDOCK1.155 ; JDOCK1.155 193.05,180.88 ; JDOCK1.155 192,179.9 ; JDOCK1.155 193.05,181.86 ; JDOCK1.155 192,181.86 ; JDOCK1.155 193.05,179.9 ; JDOCK1.155 190.95,181.86 ; JDOCK1.155 190.95,180.88 ; JSATA2.1 234.6,27.23 ; JSATA2.1 233.25,27.23 ; JSATA2.1 233.93,26.55 ; JSATA2.1 234.45,26.7 ; JSATA2.1 233.4,26.7 ; JUSB1.11 337.3,236.87 ; JUSB1.11 338.18,236.87 ; JUSB1.11 337.3,234.12 ; JUSB1.11 338.18,235.49 ; JUSB1.11 338.18,234.12 ; JDOCK1.162 181.05,187.75 ; JDOCK1.162 181.05,189.71 ; JDOCK1.162 180,189.71 ; JDOCK1.162 181.05,188.73 ; JDOCK1.162 178.95,188.73 ; JDOCK1.162 178.95,189.71 ; JHDMI1.5 10.63,202.59 ; JHDMI1.5 10.51,203.06 ; JHDMI1.5 10.51,202.13 ; 321.6,226.62 JUSB1.13 ; JUSB1.13 322.48,226.62 ; JUSB1.13 320.72,226.62 ; JUSB1.13 320.72,228.39 ; JUSB1.13 320.72,230.17 ; JUSB1.13 321.6,230.17 ; 209.12,182.82 JDOCK1.152 ; JDOCK1.152 211.23,182.82 ; JDOCK1.152 209.12,186.79 ; JDOCK1.152 211.23,184.81 ; JDOCK1.152 210.17,186.79 ; JDOCK1.152 210.17,182.82 ; JDOCK1.152 209.12,184.81 ; JDOCK1.152 211.23,186.79 ; 365.32,227.66 JUSB2.12 ; JUSB2.12 368.06,228.53 ; JUSB2.12 366.69,228.53 ; JUSB2.12 365.32,228.53 ; JUSB2.12 368.06,227.66
  GND2 w0.203: JDOCK1.162 181.05,188.73 ; JDOCK1.162 178.95,188.73 ; JDOCK1.162 181.05,187.75 ; JDOCK1.162 181.05,189.71 ; JDOCK1.162 180,189.71 ; JDOCK1.162 178.95,189.71 ; JUSB1.10 338.18,230.17 ; JUSB1.10 337.3,230.17 ; JUSB1.10 338.18,226.62 ; JUSB1.10 337.3,226.62 ; JUSB1.10 336.42,226.62 ; JUSB1.10 338.18,228.39 ; 116.25,188.52 PBATT1.4 ; PBATT1.4 117.13,189.4 ; PBATT1.4 115.37,189.4 ; PBATT1.4 116.25,190.27 ; PBATT1.4 115.58,188.72 ; PBATT1.4 116.92,188.72 ; PBATT1.4 116.92,190.07 ; PBATT1.4 115.58,190.07 ; H3.1 112.67,19.82 ; H3.1 113.16,21.17 ; H3.1 111.33,19.34 ; H3.1 109.99,22.51 ; H3.1 111.33,22.99 ; H3.1 109.5,21.17 ; H3.1 112.67,22.51 ; H3.1 109.99,19.82 ; JHDMI1.21 2.3,215.17 ; JHDMI1.21 1.01,214.24 ; JHDMI1.21 3.58,214.24 ; JHDMI1.21 3.58,215.17 ; JHDMI1.21 1.01,215.17 ; H24.1 191,155.22 ; H24.1 192.6,154.63 ; H24.1 189.4,154.63 ; H24.1 191,150.85 ; H24.1 192.6,151.44 ; H24.1 189.4,151.44 ; H24.1 193.18,153.04 ; H24.1 188.81,153.04 ; 64.66,185.25 H1.1 ; H1.1 64.66,187.94 ; H1.1 64.17,186.6 ; H1.1 67.34,187.94 ; H1.1 67.34,185.25 ; H1.1 66,184.77 ; H1.1 67.83,186.6 ; H1.1 66,188.42 ; MBATT1.6 233.66,57.01 ; MBATT1.6 232.28,56.41 ; MBATT1.6 232.88,56.23 ; MBATT1.6 232.1,57.01 ; MBATT1.6 232.28,57.6 ; MBATT1.6 233.48,56.41 ; MBATT1.6 233.48,57.6 ; 231.46,78.44 H9.1 ; H9.1 232.8,75.27 ; H9.1 232.8,78.92 ; H9.1 234.14,75.75 ; H9.1 230.97,77.1 ; H9.1 231.46,75.75 ; H9.1 234.63,77.1 ; H9.1 234.14,78.44 ; JHDMI1.23 11.75,213.27 ; JHDMI1.23 10.47,212.34 ; JHDMI1.23 10.47,213.27 ; JHDMI1.23 10.47,211.42 ; JHDMI1.23 13.03,213.27 ; JHDMI1.23 13.03,211.42 ; JHDMI1.23 13.03,212.34 ; JHDMI1.23 11.75,211.42 ; H29.1 46.7,200.35 ; H29.1 47.34,202.06 ; H29.1 43.3,203.76 ; H29.1 42.66,202.06 ; H29.1 45,199.72 ; H29.1 45,204.39 ; H29.1 43.3,200.35 ; H29.1 46.7,203.76 ; 237.3,29.48 JSATA2.17 ; JSATA2.17 238.35,29.48 ; JSATA2.17 237.15,30 ; JSATA2.17 237.83,30.68 ; JSATA2.17 237.83,29.33 ; JSATA2.17 238.35,30.53 ; JSATA2.17 238.5,30 ; JSATA2.17 237.3,30.53 ; H25.1 225.22,110.68 ; H25.1 223.62,106.9 ; H25.1 226.82,110.09 ; H25.1 227.4,108.5 ; H25.1 225.22,106.31 ; H25.1 223.03,108.5 ; H25.1 223.62,110.09 ; H25.1 226.82,106.9 ; 206.44,180.88 JDOCK1.156 ; JDOCK1.156 206.44,181.86 ; JDOCK1.156 208.5,179.9 ; JDOCK1.156 210.56,179.9 ; JDOCK1.156 206.44,179.9 ; JDOCK1.156 210.56,181.86 ; JDOCK1.156 210.56,180.88 ; JDOCK1.156 208.5,181.86 ; PBATT1.11 108.18,187.41 ; PBATT1.11 106.07,187.41 ; PBATT1.11 108.18,189.4 ; PBATT1.11 107.13,187.41 ; PBATT1.11 106.07,189.4 ; JUSB3.4 357.74,199.28 ; JUSB3.4 356.68,199.28 ; JUSB3.4 357.88,199.81 ; JUSB3.4 357.21,200.48 ; JUSB3.4 356.53,199.81 ; JUSB3.4 357.21,199.13 ; JUSB3.4 357.74,200.33 ; JUSB3.4 356.68,200.33 ; JDOCK1.155 193.05,181.86 ; JDOCK1.155 192,181.86 ; JDOCK1.155 192,179.9 ; JDOCK1.155 193.05,179.9 ; JDOCK1.155 190.95,179.9 ; JDOCK1.155 190.95,181.86 ; JDOCK1.155 193.05,180.88 ; JDOCK1.155 190.95,180.88 ; MBATT1.8 234.51,55.06 ; MBATT1.8 234.51,54.23 ; MBATT1.8 231.25,54.23 ; MBATT1.8 231.25,55.06 ; MBATT1.8 234.51,55.88 ; MBATT1.8 232.88,55.88 ; MBATT1.8 231.25,55.88 ; MBATT1.8 232.88,54.23 ; 109.58,190.07 PBATT1.1 ; PBATT1.1 111.13,189.4 ; PBATT1.1 110.92,188.72 ; PBATT1.1 110.25,188.52 ; PBATT1.1 109.37,189.4 ; PBATT1.1 109.58,188.72 ; PBATT1.1 110.92,190.07 ; PBATT1.1 110.25,190.27 ; 287.7,39.97 H20.1 ; H20.1 286.53,40.38 ; H20.1 287.7,43.14 ; H20.1 286.11,41.56 ; H20.1 289.29,41.56 ; H20.1 286.53,42.73 ; H20.1 288.87,40.38 ; H20.1 288.87,42.73 ; 231.25,65.63 MBATT1.7 ; MBATT1.7 231.25,66.46 ; MBATT1.7 234.51,66.46 ; MBATT1.7 234.51,67.28 ; MBATT1.7 234.51,65.63 ; MBATT1.7 231.25,67.28 ; MBATT1.7 232.88,67.28 ; 100.66,92.35 H8.1 ; H8.1 102,91.87 ; H8.1 100.66,95.04 ; H8.1 103.34,95.04 ; H8.1 103.83,93.7 ; H8.1 102,95.52 ; H8.1 103.34,92.35 ; H8.1 100.17,93.7 ; 246.66,125.25 H10.1 ; H10.1 246.66,127.94 ; H10.1 249.34,125.25 ; H10.1 248,128.42 ; H10.1 249.83,126.6 ; H10.1 246.17,126.6 ; H10.1 248,124.77 ; H10.1 249.34,127.94 ; H28.1 67.34,202.06 ; H28.1 66.7,200.35 ; H28.1 65,204.39 ; H28.1 65,199.72 ; H28.1 62.66,202.06 ; H28.1 66.7,203.76 ; H28.1 63.3,203.76 ; H28.1 63.3,200.35 ; H13.1 142,186.63 ; H13.1 143.83,184.81 ; H13.1 143.34,186.15 ; H13.1 140.66,183.46 ; H13.1 140.66,186.15 ; H13.1 140.17,184.81 ; H13.1 143.34,183.46 ; H13.1 142,182.98 ; 365.32,188.46 JUSB3.11 ; JUSB3.11 368.06,188.46 ; JUSB3.11 368.06,187.58 ; JUSB3.11 366.69,187.58 ; JUSB3.11 365.32,187.58 ; H15.1 185.6,162.93 ; H15.1 184.01,161.34 ; H15.1 182.42,162.93 ; H15.1 184.01,164.52 ; H15.1 182.84,164.1 ; H15.1 185.19,164.1 ; H15.1 182.84,161.75 ; H15.1 185.19,161.75 ; 111.24,142.65 H14.1 ; H14.1 114,143.83 ; H14.1 113.59,145 ; H14.1 112.41,145.42 ; H14.1 110.83,143.83 ; H14.1 111.24,145 ; H14.1 113.59,142.65 ; H14.1 112.41,142.24 ; 237.3,27.08 JSATA2.14 ; JSATA2.14 237.83,28.28 ; JSATA2.14 238.35,27.08 ; JSATA2.14 238.35,28.13 ; JSATA2.14 237.83,26.93 ; JSATA2.14 237.15,27.6 ; JSATA2.14 237.3,28.13 ; JSATA2.14 238.5,27.6 ; JSATA2.12 234.8,45.06 ; JSATA2.12 233.45,45.06 ; JSATA2.12 233.6,44.53 ; JSATA2.12 233.6,45.58 ; JSATA2.12 234.13,45.73 ; JSATA2.12 234.13,44.38 ; 11.13,200.63 JHDMI1.2 ; JHDMI1.2 11.6,200.51 ; JHDMI1.2 12.06,201.56 ; JHDMI1.2 12.18,201.09 ; JHDMI1.2 11.13,201.56 ; JHDMI1.2 12.06,200.63 ; JHDMI1.2 11.01,201.09 ; 234.45,46.06 JSATA2.13 ; JSATA2.13 235.65,45.53 ; JSATA2.13 235.65,46.58 ; JSATA2.13 235.8,46.06 ; JSATA2.13 235.13,46.73 ; JSATA2.13 234.6,45.53 ; JSATA2.13 235.13,45.38 ; JSATA2.13 234.6,46.58 ; 10.63,175.25 JUSB4.13 ; JUSB4.13 12.41,174.37 ; JUSB4.13 10.63,174.37 ; JUSB4.13 14.19,176.12 ; JUSB4.13 14.19,174.37 ; JUSB4.13 14.19,175.25 ; 234.9,33.73 JSATA2.21 ; JSATA2.21 235.43,33.88 ; JSATA2.21 236.1,33.21 ; JSATA2.21 234.9,32.68 ; JSATA2.21 235.95,33.73 ; JSATA2.21 235.43,32.53 ; JSATA2.21 235.95,32.68 ; JHDMI1.11 10.63,205.59 ; JHDMI1.11 10.51,206.06 ; JHDMI1.11 10.51,205.13 ; H18.1 182.39,118.1 ; H18.1 178.61,119.69 ; H18.1 180.21,115.91 ; H18.1 178.03,118.1 ; H18.1 181.81,116.5 ; H18.1 178.61,116.5 ; H18.1 180.21,120.28 ; H18.1 181.81,119.69 ; JUSB2.11 368.06,211.08 ; JUSB2.11 366.69,211.08 ; JUSB2.11 365.32,211.08 ; JUSB2.11 365.32,211.96 ; JUSB2.11 368.06,211.96 ; 320.72,236.87 JUSB1.12 ; JUSB1.12 320.72,234.12 ; JUSB1.12 320.72,235.49 ; JUSB1.12 321.6,234.12 ; JUSB1.12 321.6,236.87 ; H6.1 113.16,14.36 ; H6.1 112.67,13.01 ; H6.1 109.99,15.7 ; H6.1 111.33,12.53 ; H6.1 111.33,16.18 ; H6.1 112.67,15.7 ; H6.1 109.99,13.01 ; H6.1 109.5,14.36 ; H7.1 207.83,3.56 ; H7.1 207.34,4.9 ; H7.1 204.66,4.9 ; H7.1 204.17,3.56 ; H7.1 204.66,2.21 ; H7.1 206,5.38 ; H7.1 206,1.73 ; H7.1 207.34,2.21 ; 357.81,204.16 JUSB3.13 ; JUSB3.13 357.81,203.28 ; JUSB3.13 361.37,204.16 ; JUSB3.13 361.37,205.03 ; JUSB3.13 359.59,205.03 ; JUSB3.13 357.81,205.03 ; JUSB3.7 358.71,196.98 ; JUSB3.7 358.18,195.78 ; JUSB3.7 358.04,196.31 ; JUSB3.7 358.18,196.83 ; JUSB3.7 358.71,195.63 ; 10.47,196.92 JHDMI1.22 ; JHDMI1.22 11.75,198.77 ; JHDMI1.22 13.03,197.84 ; JHDMI1.22 10.47,198.77 ; JHDMI1.22 10.47,197.84 ; JHDMI1.22 13.03,196.92 ; JHDMI1.22 11.75,196.92 ; JHDMI1.22 13.03,198.77 ; 10.63,191.82 JUSB4.10 ; JUSB4.10 10.63,190.95 ; JUSB4.10 14.19,191.82 ; JUSB4.10 12.41,191.82 ; JUSB4.10 14.19,190.95 ; JUSB4.10 14.19,190.07 ; 108.24,67.09 JSATA1.24 ; JSATA1.24 108.24,66.04 ; JSATA1.24 110.04,64.99 ; JSATA1.24 108.24,64.99 ; JSATA1.24 111.84,66.04 ; JSATA1.24 111.84,67.09 ; JSATA1.24 111.84,64.99 ; JSATA1.24 110.04,67.09 ; H22.1 320.73,224.56 ; H22.1 315.85,222.5 ; H22.1 319.95,226.61 ; H22.1 315.85,226.61 ; H22.1 315.07,224.56 ; H22.1 317.9,221.72 ; H22.1 319.95,222.5 ; H22.1 317.9,227.39 ; JSATA2.7 233.93,35.52 ; JSATA2.7 233.25,34.85 ; JSATA2.7 233.4,35.37 ; JSATA2.7 234.45,35.37 ; JSATA2.7 234.6,34.85 ; 161.82,182.82 JDOCK1.145 ; JDOCK1.145 160.77,182.82 ; JDOCK1.145 160.77,184.81 ; JDOCK1.145 162.88,184.81 ; JDOCK1.145 160.77,186.79 ; JDOCK1.145 162.88,182.82 ; JDOCK1.145 162.88,186.79 ; JDOCK1.145 161.82,186.79 ; 357.81,212.83 JUSB2.10 ; JUSB2.10 361.37,211.08 ; JUSB2.10 357.81,211.08 ; JUSB2.10 357.81,211.96 ; JUSB2.10 359.59,211.08 ; JUSB2.10 361.37,211.96 ; JUSB4.7 13.96,183.1 ; JUSB4.7 13.82,183.62 ; JUSB4.7 13.29,183.77 ; JUSB4.7 13.29,182.42 ; JUSB4.7 13.82,182.57 ; JHDMI1.17 10.51,208.13 ; JHDMI1.17 10.63,208.59 ; JHDMI1.17 10.51,209.06 ; 3.94,174.37 JUSB4.12 ; JUSB4.12 6.68,175.25 ; JUSB4.12 6.68,174.37 ; JUSB4.12 3.94,175.25 ; JUSB4.12 5.31,174.37 ; 325.42,225.49 JUSB1.4 ; JUSB1.4 326.48,226.54 ; JUSB1.4 326.48,225.49 ; JUSB1.4 325.95,225.34 ; JUSB1.4 325.28,226.01 ; JUSB1.4 326.62,226.01 ; JUSB2.13 361.37,227.66 ; JUSB2.13 357.81,227.66 ; JUSB2.13 361.37,228.53 ; JUSB2.13 359.59,228.53 ; JUSB2.13 357.81,226.78 ; JSATA2.1 234.45,26.7 ; JSATA2.1 233.25,27.23 ; JSATA2.1 233.4,26.7 ; JSATA2.1 234.6,27.23 ; JSATA2.1 233.93,26.55 ; 109.99,73.65 H4.1 ; H4.1 112.67,70.96 ; H4.1 112.67,73.65 ; H4.1 109.99,70.96 ; H4.1 111.33,74.13 ; H4.1 109.5,72.31 ; H4.1 113.16,72.31 ; H4.1 111.33,70.48 ; JSATA2.24 236.1,35.61 ; JSATA2.24 234.9,36.13 ; JSATA2.24 234.75,35.61 ; JSATA2.24 235.95,36.13 ; JSATA2.24 235.95,35.08 ; JSATA2.24 235.43,34.93 ; JSATA2.24 235.43,36.28 ; JSATA2.24 234.9,35.08 ; JDOCK1.154 180,181.86 ; JDOCK1.154 181.05,180.88 ; JDOCK1.154 178.95,181.86 ; JDOCK1.154 181.05,181.86 ; JDOCK1.154 180,179.9 ; JDOCK1.154 181.05,179.9 ; JDOCK1.154 178.95,180.88 ; JDOCK1.154 178.95,179.9 ; JDOCK1.164 210.56,187.75 ; JDOCK1.164 208.5,187.75 ; JDOCK1.164 206.44,188.73 ; JDOCK1.164 206.44,189.71 ; JDOCK1.164 210.56,189.71 ; JDOCK1.164 210.56,188.73 ; JDOCK1.164 206.44,187.75 ; JDOCK1.164 208.5,189.71 ; H30.1 289.29,20.56 ; H30.1 287.7,22.14 ; H30.1 286.53,19.38 ; H30.1 286.53,21.73 ; H30.1 287.7,18.97 ; H30.1 286.11,20.56 ; H30.1 288.87,19.38 ; H30.1 288.87,21.73 ; 108.24,27.57 JSATA1.23 ; JSATA1.23 108.24,28.62 ; JSATA1.23 110.04,27.57 ; JSATA1.23 111.84,28.62 ; JSATA1.23 108.24,29.68 ; JSATA1.23 110.04,29.68 ; JSATA1.23 111.84,29.68 ; JSATA1.23 111.84,27.57 ; JUSB4.4 15.32,180.12 ; JUSB4.4 14.26,179.07 ; JUSB4.4 14.12,179.6 ; JUSB4.4 14.26,180.12 ; JUSB4.4 14.79,180.27 ; JUSB4.4 15.46,179.6 ; JUSB4.4 14.79,178.92 ; JUSB4.4 15.32,179.07 ; H5.1 283.34,10.7 ; H5.1 280.66,8.01 ; H5.1 282,11.18 ; H5.1 282,7.53 ; H5.1 283.83,9.36 ; H5.1 283.34,8.01 ; H5.1 280.66,10.7 ; H5.1 280.17,9.36 ; H2.1 303.55,57.72 ; H2.1 301,56.73 ; H2.1 298.45,57.72 ; H2.1 297.47,60.27 ; H2.1 304.53,60.27 ; H2.1 298.45,62.81 ; H2.1 301,63.8 ; H2.1 303.55,62.81 ; 365.32,227.66 JUSB2.12 ; JUSB2.12 368.06,227.66 ; JUSB2.12 368.06,228.53 ; JUSB2.12 365.32,228.53 ; JUSB2.12 366.69,228.53 ; JSATA2.33 237.12,47.33 ; JSATA2.33 234.33,48.11 ; JSATA2.33 237.12,48.11 ; JSATA2.33 235.72,47.33 ; JSATA2.33 234.33,48.88 ; JSATA2.33 234.33,47.33 ; JSATA2.33 237.12,48.88 ; JSATA2.33 235.72,48.88 ; H21.1 348.43,151.88 ; H21.1 344,151.88 ; H21.1 348.43,153.56 ; H21.1 344,155.23 ; H21.1 348.43,155.23 ; H21.1 339.57,155.23 ; H21.1 339.57,151.88 ; H21.1 339.57,153.56 ; H17.1 129.05,78.78 ; H17.1 126.86,76.6 ; H17.1 129.05,74.41 ; H17.1 130.65,78.19 ; H17.1 131.23,76.6 ; H17.1 127.45,78.19 ; H17.1 127.45,75 ; H17.1 130.65,75 ; 360.66,164.9 H11.1 ; H11.1 363.34,162.21 ; H11.1 360.66,162.21 ; H11.1 362,161.73 ; H11.1 363.34,164.9 ; H11.1 363.83,163.56 ; H11.1 362,165.38 ; H11.1 360.17,163.56 ; 161.44,181.86 JDOCK1.153 ; JDOCK1.153 165.56,179.9 ; JDOCK1.153 161.44,179.9 ; JDOCK1.153 165.56,180.88 ; JDOCK1.153 163.5,181.86 ; JDOCK1.153 165.56,181.86 ; JDOCK1.153 161.44,180.88 ; JDOCK1.153 163.5,179.9 ; 3.94,191.82 JUSB4.11 ; JUSB4.11 5.31,191.82 ; JUSB4.11 6.68,190.95 ; JUSB4.11 6.68,191.82 ; JUSB4.11 3.94,190.95 ; PBATT1.10 130.43,187.41 ; PBATT1.10 128.32,189.4 ; PBATT1.10 128.32,187.41 ; PBATT1.10 129.37,187.41 ; PBATT1.10 130.43,189.4 ; 168,183.75 JDOCK1.157 ; JDOCK1.157 167.2,184.01 ; JDOCK1.157 166.95,184.81 ; JDOCK1.157 168.8,184.01 ; JDOCK1.157 167.2,185.6 ; 192,187.75 JDOCK1.163 ; JDOCK1.163 193.05,188.73 ; JDOCK1.163 193.05,187.75 ; JDOCK1.163 193.05,189.71 ; JDOCK1.163 190.95,188.73 ; JDOCK1.163 190.95,189.71 ; JDOCK1.163 190.95,187.75 ; JDOCK1.163 192,189.71 ; 320.72,228.39 JUSB1.13 ; JUSB1.13 321.6,230.17 ; JUSB1.13 321.6,226.62 ; JUSB1.13 320.72,230.17 ; JUSB1.13 322.48,226.62 ; JUSB1.13 320.72,226.62 ; 337.3,234.12 JUSB1.11 ; JUSB1.11 338.18,235.49 ; JUSB1.11 338.18,234.12 ; JUSB1.11 338.18,236.87 ; JUSB1.11 337.3,236.87 ; 357.81,188.46 JUSB3.10 ; JUSB3.10 361.37,188.46 ; JUSB3.10 357.81,187.58 ; JUSB3.10 361.37,187.58 ; JUSB3.10 357.81,189.33 ; JUSB3.10 359.59,187.58 ; 209.12,186.79 JDOCK1.152 ; JDOCK1.152 209.12,182.82 ; JDOCK1.152 211.23,186.79 ; JDOCK1.152 210.17,186.79 ; JDOCK1.152 209.12,184.81 ; JDOCK1.152 211.23,182.82 ; JDOCK1.152 211.23,184.81 ; JDOCK1.152 210.17,182.82 ; 11,169.03 H26.1 ; H26.1 11,172.68 ; H26.1 12.83,170.86 ; H26.1 9.17,170.86 ; H26.1 9.66,172.2 ; H26.1 9.66,169.51 ; H26.1 12.34,172.2 ; H26.1 12.34,169.51 ; 11.01,204.09 JHDMI1.8 ; JHDMI1.8 12.06,203.63 ; JHDMI1.8 12.18,204.09 ; JHDMI1.8 11.13,203.63 ; JHDMI1.8 12.06,204.56 ; JHDMI1.8 11.13,204.56 ; 178.95,184.81 JDOCK1.158 ; JDOCK1.158 180.8,184.01 ; JDOCK1.158 181.05,184.81 ; JDOCK1.158 179.2,184.01 ; JDOCK1.158 180,185.86 ; JDOCK1.158 180.8,185.6 ; JDOCK1.158 179.2,185.6 ; JDOCK1.158 180,183.75 ; JSATA2.4 234.6,31.04 ; JSATA2.4 233.24,30.74 ; JSATA2.4 233.25,31.04 ; H23.1 244.4,149.9 ; H23.1 241.2,153.09 ; H23.1 242.8,149.31 ; H23.1 244.4,153.09 ; H23.1 240.61,151.5 ; H23.1 244.98,151.5 ; H23.1 241.2,149.9 ; H23.1 242.8,153.68 ; 178.87,81.1 H19.1 ; H19.1 181.05,83.28 ; H19.1 181.05,78.91 ; H19.1 183.23,81.1 ; H19.1 179.45,79.5 ; H19.1 179.45,82.69 ; H19.1 182.65,82.69 ; H19.1 182.65,79.5 ; JDOCK1.161 163.5,189.71 ; JDOCK1.161 165.56,188.73 ; JDOCK1.161 165.56,187.75 ; JDOCK1.161 161.44,187.75 ; JDOCK1.161 161.44,189.71 ; JDOCK1.161 163.5,187.75 ; JDOCK1.161 165.56,189.71 ; JDOCK1.161 161.44,188.73 ; 237.3,32.93 JSATA2.20 ; JSATA2.20 237.3,31.88 ; JSATA2.20 237.15,32.41 ; JSATA2.20 237.83,31.73 ; JSATA2.20 238.5,32.41 ; JSATA2.20 238.35,31.88 ; JSATA2.20 237.83,33.08 ; JSATA2.20 238.35,32.93 ; JSATA2.32 235.72,25.88 ; JSATA2.32 237.12,25.11 ; JSATA2.32 234.33,25.11 ; JSATA2.32 234.33,24.33 ; JSATA2.32 237.12,24.33 ; JSATA2.32 235.72,24.33 ; JSATA2.32 237.12,25.88 ; JSATA2.32 234.33,25.88 ; JDOCK1.160 204,185.86 ; JDOCK1.160 204,183.75 ; JDOCK1.160 205.05,184.81 ; JDOCK1.160 204.8,185.6 ; JDOCK1.160 203.2,184.01 ; JDOCK1.160 204.8,184.01 ; JDOCK1.160 203.2,185.6 ; JUSB1.7 330.12,227.51 ; JUSB1.7 329.98,226.99 ; JUSB1.7 328.78,227.51 ; JUSB1.7 328.92,226.99 ; JUSB1.7 329.45,226.84 ; MBATT1.5 233.48,59.1 ; MBATT1.5 232.28,57.91 ; MBATT1.5 232.28,59.1 ; MBATT1.5 233.66,58.51 ; MBATT1.5 233.48,57.91 ; MBATT1.5 232.1,58.51 ; 191.2,184.01 JDOCK1.159 ; JDOCK1.159 190.95,184.81 ; JDOCK1.159 192,183.75 ; JDOCK1.159 192.8,184.01 ; JDOCK1.159 192.8,185.6 ; JDOCK1.159 193.05,184.81 ; JDOCK1.159 192,185.86 ; PBATT1.2 112.92,190.07 ; PBATT1.2 112.25,188.52 ; PBATT1.2 112.92,188.72 ; PBATT1.2 113.13,189.4 ; PBATT1.2 111.58,190.07 ; PBATT1.2 111.37,189.4 ; PBATT1.2 112.25,190.27 ; PBATT1.2 111.58,188.72 ; 2.27,195.94 JHDMI1.20 ; JHDMI1.20 2.27,195.02 ; JHDMI1.20 3.55,195.02 ; JHDMI1.20 4.83,195.94 ; JHDMI1.20 4.83,195.02 ; JUSB3.12 368.06,204.16 ; JUSB3.12 366.69,205.03 ; JUSB3.12 368.06,205.03 ; JUSB3.12 365.32,205.03 ; JUSB3.12 365.32,204.16 ; JUSB2.4 357.74,223.83 ; JUSB2.4 356.68,222.78 ; JUSB2.4 356.68,223.83 ; JUSB2.4 357.74,222.78 ; JUSB2.4 357.88,223.31 ; JUSB2.4 357.21,223.98 ; JUSB2.4 357.21,222.63 ; JUSB2.4 356.53,223.31 ; JUSB2.7 358.71,220.48 ; JUSB2.7 358.18,220.33 ; JUSB2.7 358.04,219.81 ; JUSB2.7 358.71,219.13 ; JUSB2.7 358.18,219.28 ; JHDMI1.5 10.51,202.13 ; JHDMI1.5 10.51,203.06 ; JHDMI1.5 10.63,202.59 ; 228.17,184.81 H12.1 ; H12.1 231.34,183.46 ; H12.1 231.34,186.15 ; H12.1 228.66,183.46 ; H12.1 230,186.63 ; H12.1 228.66,186.15 ; H12.1 230,182.98 ; H12.1 231.83,184.81 ; H16.1 130.65,114.19 ; H16.1 129.05,114.78 ; H16.1 131.23,112.6 ; H16.1 127.45,111 ; H16.1 127.45,114.19 ; H16.1 130.65,111 ; H16.1 129.05,110.41 ; H16.1 126.86,112.6 ; H27.1 18.34,217.38 ; H27.1 15.17,216.04 ; H27.1 17,217.86 ; H27.1 18.83,216.04 ; H27.1 18.34,214.69 ; H27.1 15.66,217.38 ; H27.1 15.66,214.69 ; H27.1 17,214.21 ; JLOM1.15 314.54,240.51 ; JLOM1.15 314.02,240.51 ; JLOM1.15 314.02,237
  IN2 w0.254: v4(306.18,155.84) 306.18,153.43 305.8,153.05 v4(305.8,151.02) ; v4(307.7,150.63) 307.83,150.63 307.96,150.76 307.96,154.44 308.44,154.93 308.44,155.18 v4(308.47,155.21)
  VCC w0.203: 5.31,174.37 JUSB4.12 ; JUSB4.12 6.68,174.37 ; JUSB4.12 3.94,175.25 ; JUSB4.12 3.94,174.37 ; JUSB4.12 6.68,175.25 ; H22.1 319.95,226.61 ; H22.1 317.9,221.72 ; H22.1 320.73,224.56 ; H22.1 315.85,222.5 ; H22.1 315.07,224.56 ; H22.1 315.85,226.61 ; H22.1 317.9,227.39 ; H22.1 319.95,222.5 ; 14.12,179.6 JUSB4.4 ; JUSB4.4 14.79,180.27 ; JUSB4.4 15.32,180.12 ; JUSB4.4 14.26,180.12 ; JUSB4.4 14.79,178.92 ; JUSB4.4 15.46,179.6 ; JUSB4.4 14.26,179.07 ; JUSB4.4 15.32,179.07 ; JUSB3.11 368.06,188.46 ; JUSB3.11 366.69,187.58 ; JUSB3.11 365.32,187.58 ; JUSB3.11 365.32,188.46 ; JUSB3.11 368.06,187.58 ; JHDMI1.11 10.51,206.06 ; JHDMI1.11 10.51,205.13 ; JHDMI1.11 10.63,205.59 ; 15.66,217.38 H27.1 ; H27.1 18.34,214.69 ; H27.1 17,214.21 ; H27.1 15.66,214.69 ; H27.1 15.17,216.04 ; H27.1 17,217.86 ; H27.1 18.34,217.38 ; H27.1 18.83,216.04 ; 179.45,79.5 H19.1 ; H19.1 183.23,81.1 ; H19.1 182.65,82.69 ; H19.1 182.65,79.5 ; H19.1 181.05,78.91 ; H19.1 179.45,82.69 ; H19.1 181.05,83.28 ; H19.1 178.87,81.1 ; H26.1 12.34,169.51 ; H26.1 12.34,172.2 ; H26.1 9.17,170.86 ; H26.1 11,172.68 ; H26.1 9.66,172.2 ; H26.1 9.66,169.51 ; H26.1 11,169.03 ; H26.1 12.83,170.86 ; 358.04,196.31 JUSB3.7 ; JUSB3.7 358.18,196.83 ; JUSB3.7 358.18,195.78 ; 11.13,203.63 JHDMI1.8 ; JHDMI1.8 12.18,204.09 ; JHDMI1.8 12.06,204.56 ; JHDMI1.8 11.13,204.56 ; JHDMI1.8 11.01,204.09 ; JHDMI1.8 12.06,203.63 ; 320.72,226.62 JUSB1.13 ; JUSB1.13 320.72,228.39 ; JUSB1.13 321.6,230.17 ; JUSB1.13 321.6,226.62 ; JUSB1.13 322.48,226.62 ; 2.27,195.94 JHDMI1.20 ; JHDMI1.20 3.55,195.02 ; JHDMI1.20 4.83,195.94 ; JHDMI1.20 4.83,195.02 ; JHDMI1.20 2.27,195.02 ; 329.45,226.84 JUSB1.7 ; JUSB1.7 328.92,226.99 ; JUSB1.7 329.98,226.99 ; 356.53,199.81 JUSB3.4 ; JUSB3.4 357.88,199.81 ; JUSB3.4 356.68,200.33 ; JUSB3.4 356.68,199.28 ; JUSB3.4 357.21,200.48 ; JUSB3.4 357.74,199.28 ; JUSB3.4 357.74,200.33 ; JUSB3.4 357.21,199.13 ; JUSB3.13 359.59,205.03 ; JUSB3.13 357.81,205.03 ; JUSB3.13 361.37,204.16 ; JUSB3.13 357.81,204.16 ; JUSB3.13 361.37,205.03 ; JUSB3.13 357.81,203.28 ; 358.04,219.81 JUSB2.7 ; JUSB2.7 358.18,220.33 ; JUSB2.7 358.18,219.28 ; 357.81,211.96 JUSB2.10 ; JUSB2.10 361.37,211.08 ; JUSB2.10 357.81,212.83 ; JUSB2.10 357.81,211.08 ; JUSB2.10 359.59,211.08 ; JUSB2.10 361.37,211.96 ; 12.41,174.37 JUSB4.13 ; JUSB4.13 14.19,176.12 ; JUSB4.13 14.19,174.37 ; JUSB4.13 10.63,174.37 ; JUSB4.13 10.63,175.25 ; JUSB4.13 14.19,175.25 ; JUSB3.10 361.37,187.58 ; JUSB3.10 357.81,188.46 ; JUSB3.10 357.81,187.58 ; JUSB3.10 359.59,187.58 ; JUSB3.10 357.81,189.33 ; JUSB3.10 361.37,188.46 ; 336.42,226.62 JUSB1.10 ; JUSB1.10 338.18,226.62 ; JUSB1.10 337.3,230.17 ; JUSB1.10 337.3,226.62 ; JUSB1.10 338.18,230.17 ; JUSB1.10 338.18,228.39 ; 10.47,198.77 JHDMI1.22 ; JHDMI1.22 13.03,197.84 ; JHDMI1.22 10.47,196.92 ; JHDMI1.22 13.03,198.77 ; JHDMI1.22 11.75,196.92 ; JHDMI1.22 11.75,198.77 ; JHDMI1.22 13.03,196.92 ; JHDMI1.22 10.47,197.84 ; JHDMI1.17 10.51,208.13 ; JHDMI1.17 10.63,208.59 ; JHDMI1.17 10.51,209.06 ; 365.32,211.08 JUSB2.11 ; JUSB2.11 365.32,211.96 ; JUSB2.11 366.69,211.08 ; JUSB2.11 368.06,211.08 ; JUSB2.11 368.06,211.96 ; JUSB2.4 357.21,223.98 ; JUSB2.4 357.21,222.63 ; JUSB2.4 356.53,223.31 ; JUSB2.4 357.74,222.78 ; JUSB2.4 356.68,222.78 ; JUSB2.4 356.68,223.83 ; JUSB2.4 357.74,223.83 ; JUSB2.4 357.88,223.31 ; 325.95,225.34 JUSB1.4 ; JUSB1.4 326.48,225.49 ; JUSB1.4 326.48,226.54 ; JUSB1.4 325.42,225.49 ; JUSB1.4 326.62,226.01 ; JUSB1.4 325.28,226.01 ; JHDMI1.5 10.63,202.59 ; JHDMI1.5 10.51,202.13 ; JHDMI1.5 10.51,203.06 ; 11.13,200.63 JHDMI1.2 ; JHDMI1.2 11.13,201.56 ; JHDMI1.2 12.06,200.63 ; JHDMI1.2 11.01,201.09 ; JHDMI1.2 11.6,200.51 ; JHDMI1.2 12.18,201.09 ; JHDMI1.2 12.06,201.56 ; 10.47,213.27 JHDMI1.23 ; JHDMI1.23 13.03,213.27 ; JHDMI1.23 13.03,211.42 ; JHDMI1.23 11.75,211.42 ; JHDMI1.23 11.75,213.27 ; JHDMI1.23 10.47,212.34 ; JHDMI1.23 13.03,212.34 ; JHDMI1.23 10.47,211.42 ; H17.1 130.65,78.19 ; H17.1 126.86,76.6 ; H17.1 129.05,78.78 ; H17.1 127.45,78.19 ; H17.1 131.23,76.6 ; H17.1 129.05,74.41 ; H17.1 130.65,75 ; H17.1 127.45,75 ; 10.63,191.82 JUSB4.10 ; JUSB4.10 14.19,191.82 ; JUSB4.10 14.19,190.95 ; JUSB4.10 14.19,190.07 ; JUSB4.10 10.63,190.95 ; JUSB4.10 12.41,191.82 ; 365.32,228.53 JUSB2.12 ; JUSB2.12 365.32,227.66 ; JUSB2.12 365.32,228.09 ; JHDMI1.21 3.58,214.24 ; JHDMI1.21 3.58,215.17 ; JHDMI1.21 2.3,215.17 ; JUSB2.13 361.37,228.53 ; JUSB2.13 361.37,227.66 ; JUSB2.13 357.81,226.78 ; JUSB2.13 357.81,227.66 ; JUSB4.7 13.82,182.57 ; JUSB4.7 13.96,183.1 ; JUSB4.7 13.82,183.62 ; JUSB3.12 368.06,204.16 ; JUSB3.12 365.32,204.16 ; JUSB3.12 368.06,205.03 ; JUSB3.12 366.69,205.03 ; JUSB3.12 365.32,205.03 ; JUSB4.11 6.68,190.95 ; JUSB4.11 3.94,190.95 ; JUSB4.11 6.68,191.82 ; JUSB4.11 3.94,191.82 ; JUSB4.11 5.31,191.82
  VCC w0.508: 362,161.73 H11.1 ; H11.1 360.66,162.21 ; H11.1 360.17,163.56 ; H11.1 363.83,163.56 ; H11.1 363.34,162.21 ; H11.1 363.34,164.9 ; H11.1 362,165.38 ; H11.1 360.66,164.9 ; H21.1 348.43,153.56 ; H21.1 339.57,153.56 ; H21.1 344,155.23 ; H21.1 339.57,155.23 ; H21.1 348.43,155.23 ; H21.1 339.57,151.88 ; H21.1 348.43,151.88 ; H21.1 344,151.88
  GND3 w0.203: 232.88,56.23 MBATT1.6 ; MBATT1.6 232.1,57.01 ; MBATT1.6 232.28,56.41 ; MBATT1.6 233.48,57.6 ; MBATT1.6 233.48,56.41 ; MBATT1.6 232.28,57.6 ; MBATT1.6 233.66,57.01 ; 234.6,31.04 JSATA2.4 ; JSATA2.4 233.25,31.04 ; JSATA2.4 233.24,30.74 ; 231.25,55.88 MBATT1.8 ; MBATT1.8 234.51,54.23 ; MBATT1.8 231.25,55.06 ; MBATT1.8 232.88,55.88 ; MBATT1.8 234.51,55.88 ; MBATT1.8 231.25,54.23 ; MBATT1.8 234.51,55.06 ; MBATT1.8 232.88,54.23 ; 357.81,227.66 JUSB2.13 ; JUSB2.13 357.81,226.78 ; JUSB2.13 361.37,228.53 ; JUSB2.13 361.37,227.66 ; JUSB2.13 359.59,228.53 ; 9.66,172.2 H26.1 ; H26.1 12.83,170.86 ; H26.1 11,172.68 ; H26.1 9.66,169.51 ; H26.1 12.34,169.51 ; H26.1 11,169.03 ; H26.1 12.34,172.2 ; H26.1 9.17,170.86 ; 111.58,190.07 PBATT1.2 ; PBATT1.2 112.92,190.07 ; PBATT1.2 111.37,189.4 ; PBATT1.2 112.25,188.52 ; PBATT1.2 113.13,189.4 ; PBATT1.2 112.92,188.72 ; PBATT1.2 111.58,188.72 ; PBATT1.2 112.25,190.27 ; 234.9,35.08 JSATA2.24 ; JSATA2.24 236.1,35.61 ; JSATA2.24 235.43,34.93 ; JSATA2.24 234.75,35.61 ; JSATA2.24 235.95,36.13 ; JSATA2.24 234.9,36.13 ; JSATA2.24 235.43,36.28 ; JSATA2.24 235.95,35.08 ; 100.66,92.35 H8.1 ; H8.1 103.34,92.35 ; H8.1 103.83,93.7 ; H8.1 103.34,95.04 ; H8.1 100.66,95.04 ; H8.1 102,91.87 ; H8.1 102,95.52 ; H8.1 100.17,93.7 ; 64.17,186.6 H1.1 ; H1.1 66,184.77 ; H1.1 67.34,187.94 ; H1.1 67.34,185.25 ; H1.1 67.83,186.6 ; H1.1 64.66,185.25 ; H1.1 64.66,187.94 ; H1.1 66,188.42 ; 10.63,190.95 JUSB4.10 ; JUSB4.10 14.19,190.07 ; JUSB4.10 14.19,190.95 ; JUSB4.10 14.19,191.82 ; JUSB4.10 10.63,191.82 ; JUSB4.10 12.41,191.82 ; 286.53,42.73 H20.1 ; H20.1 286.11,41.56 ; H20.1 287.7,43.14 ; H20.1 286.53,40.38 ; H20.1 288.87,42.73 ; H20.1 288.87,40.38 ; H20.1 289.29,41.56 ; H20.1 287.7,39.97 ; JUSB3.7 358.71,196.98 ; JUSB3.7 358.18,196.83 ; JUSB3.7 358.18,195.78 ; JUSB3.7 358.04,196.31 ; JUSB3.7 358.71,195.63 ; JLOM1.15 314.54,240.51 ; JLOM1.15 314.02,240.51 ; JLOM1.15 314.02,237 ; 65,199.72 H28.1 ; H28.1 62.66,202.06 ; H28.1 65,204.39 ; H28.1 63.3,200.35 ; H28.1 66.7,203.76 ; H28.1 66.7,200.35 ; H28.1 67.34,202.06 ; H28.1 63.3,203.76 ; H29.1 46.7,200.35 ; H29.1 45,204.39 ; H29.1 45,199.72 ; H29.1 47.34,202.06 ; H29.1 43.3,203.76 ; H29.1 43.3,200.35 ; H29.1 42.66,202.06 ; H29.1 46.7,203.76 ; 129.05,110.41 H16.1 ; H16.1 127.45,114.19 ; H16.1 129.05,114.78 ; H16.1 131.23,112.6 ; H16.1 127.45,111 ; H16.1 130.65,114.19 ; H16.1 126.86,112.6 ; H16.1 130.65,111 ; 365.32,211.96 JUSB2.11 ; JUSB2.11 366.69,211.08 ; JUSB2.11 365.32,211.08 ; JUSB2.11 368.06,211.08 ; JUSB2.11 368.06,211.96 ; H21.1 348.43,155.23 ; H21.1 348.43,153.56 ; H21.1 339.57,153.56 ; H21.1 348.43,151.88 ; H21.1 344,151.88 ; H21.1 339.57,155.23 ; H21.1 339.57,151.88 ; H21.1 344,155.23 ; 336.42,226.62 JUSB1.10 ; JUSB1.10 337.3,230.17 ; JUSB1.10 338.18,228.39 ; JUSB1.10 338.18,230.17 ; JUSB1.10 337.3,226.62 ; JUSB1.10 338.18,226.62 ; 234.13,44.38 JSATA2.12 ; JSATA2.12 233.45,45.06 ; JSATA2.12 233.6,44.53 ; JSATA2.12 233.6,45.58 ; JSATA2.12 234.13,45.73 ; JSATA2.12 234.8,45.06 ; JHDMI1.21 3.58,214.24 ; JHDMI1.21 3.58,215.17 ; JHDMI1.21 1.01,215.17 ; JHDMI1.21 1.01,214.24 ; JHDMI1.21 2.3,215.17 ; 365.32,227.66 JUSB2.12 ; JUSB2.12 366.69,228.53 ; JUSB2.12 368.06,227.66 ; JUSB2.12 368.06,228.53 ; JUSB2.12 365.32,228.53 ; 179.2,184.01 JDOCK1.158 ; JDOCK1.158 180.8,184.01 ; JDOCK1.158 181.05,184.81 ; JDOCK1.158 180,185.86 ; JDOCK1.158 180.8,185.6 ; JDOCK1.158 178.95,184.81 ; JDOCK1.158 179.2,185.6 ; JDOCK1.158 180,183.75 ; 140.66,183.46 H13.1 ; H13.1 143.34,186.15 ; H13.1 140.17,184.81 ; H13.1 143.34,183.46 ; H13.1 143.83,184.81 ; H13.1 140.66,186.15 ; H13.1 142,186.63 ; H13.1 142,182.98 ; 357.81,212.83 JUSB2.10 ; JUSB2.10 357.81,211.96 ; JUSB2.10 357.81,211.08 ; JUSB2.10 361.37,211.08 ; JUSB2.10 359.59,211.08 ; JUSB2.10 361.37,211.96 ; 178.95,188.73 JDOCK1.162 ; JDOCK1.162 181.05,187.75 ; JDOCK1.162 180,189.71 ; JDOCK1.162 181.05,188.73 ; JDOCK1.162 181.05,189.71 ; JDOCK1.162 178.95,189.71 ; JUSB1.7 329.98,226.99 ; JUSB1.7 330.12,227.51 ; JUSB1.7 329.45,226.84 ; JUSB1.7 328.78,227.51 ; JUSB1.7 328.92,226.99 ; JHDMI1.20 4.83,195.02 ; JHDMI1.20 3.55,195.02 ; JHDMI1.20 2.27,195.02 ; JHDMI1.20 2.27,195.94 ; JHDMI1.20 4.83,195.94 ; JUSB3.11 368.06,187.58 ; JUSB3.11 365.32,187.58 ; JUSB3.11 366.69,187.58 ; JUSB3.11 365.32,188.46 ; JUSB3.11 368.06,188.46 ; 223.62,110.09 H25.1 ; H25.1 225.22,106.31 ; H25.1 223.03,108.5 ; H25.1 225.22,110.68 ; H25.1 227.4,108.5 ; H25.1 226.82,106.9 ; H25.1 223.62,106.9 ; H25.1 226.82,110.09 ; H4.1 111.33,74.13 ; H4.1 112.67,73.65 ; H4.1 109.5,72.31 ; H4.1 111.33,70.48 ; H4.1 109.99,70.96 ; H4.1 113.16,72.31 ; H4.1 112.67,70.96 ; H4.1 109.99,73.65 ; 190.95,179.9 JDOCK1.155 ; JDOCK1.155 193.05,179.9 ; JDOCK1.155 190.95,180.88 ; JDOCK1.155 193.05,180.88 ; JDOCK1.155 192,179.9 ; JDOCK1.155 193.05,181.86 ; JDOCK1.155 192,181.86 ; JDOCK1.155 190.95,181.86 ; JHDMI1.2 12.06,200.63 ; JHDMI1.2 11.6,200.51 ; JHDMI1.2 11.01,201.09 ; JHDMI1.2 11.13,201.56 ; JHDMI1.2 11.13,200.63 ; JHDMI1.2 12.18,201.09 ; JHDMI1.2 12.06,201.56 ; H5.1 283.34,10.7 ; H5.1 280.66,10.7 ; H5.1 280.17,9.36 ; H5.1 282,7.53 ; H5.1 282,11.18 ; H5.1 280.66,8.01 ; H5.1 283.34,8.01 ; H5.1 283.83,9.36 ; 111.24,145 H14.1 ; H14.1 113.59,145 ; H14.1 112.41,145.42 ; H14.1 114,143.83 ; H14.1 113.59,142.65 ; H14.1 112.41,142.24 ; H14.1 111.24,142.65 ; H14.1 110.83,143.83 ; 320.72,234.12 JUSB1.12 ; JUSB1.12 320.72,236.87 ; JUSB1.12 321.6,234.12 ; JUSB1.12 320.72,235.49 ; JUSB1.12 321.6,236.87 ; 160.77,182.82 JDOCK1.145 ; JDOCK1.145 161.82,186.79 ; JDOCK1.145 162.88,182.82 ; JDOCK1.145 161.82,182.82 ; JDOCK1.145 160.77,186.79 ; JDOCK1.145 162.88,184.81 ; JDOCK1.145 162.88,186.79 ; JDOCK1.145 160.77,184.81 ; 210.17,182.82 JDOCK1.152 ; JDOCK1.152 210.17,186.79 ; JDOCK1.152 211.23,182.82 ; JDOCK1.152 209.12,182.82 ; JDOCK1.152 211.23,186.79 ; JDOCK1.152 211.23,184.81 ; JDOCK1.152 209.12,184.81 ; JDOCK1.152 209.12,186.79 ; 362,161.73 H11.1 ; H11.1 360.66,164.9 ; H11.1 362,165.38 ; H11.1 360.17,163.56 ; H11.1 360.66,162.21 ; H11.1 363.34,164.9 ; H11.1 363.34,162.21 ; H11.1 363.83,163.56 ; 6.68,191.82 JUSB4.11 ; JUSB4.11 6.68,190.95 ; JUSB4.11 5.31,191.82 ; JUSB4.11 3.94,190.95 ; JUSB4.11 3.94,191.82 ; H23.1 244.98,151.5 ; H23.1 240.61,151.5 ; H23.1 242.8,149.31 ; H23.1 244.4,153.09 ; H23.1 241.2,153.09 ; H23.1 244.4,149.9 ; H23.1 241.2,149.9 ; H23.1 242.8,153.68 ; JUSB4.13 14.19,174.37 ; JUSB4.13 14.19,176.12 ; JUSB4.13 10.63,175.25 ; JUSB4.13 14.19,175.25 ; JUSB4.13 12.41,174.37 ; JUSB4.13 10.63,174.37 ; H30.1 288.87,19.38 ; H30.1 287.7,22.14 ; H30.1 286.53,21.73 ; H30.1 286.53,19.38 ; H30.1 289.29,20.56 ; H30.1 287.7,18.97 ; H30.1 286.11,20.56 ; H30.1 288.87,21.73 ; H22.1 319.95,226.61 ; H22.1 315.85,226.61 ; H22.1 317.9,227.39 ; H22.1 315.07,224.56 ; H22.1 317.9,221.72 ; H22.1 315.85,222.5 ; H22.1 319.95,222.5 ; H22.1 320.73,224.56 ; 234.33,25.88 JSATA2.32 ; JSATA2.32 237.12,24.33 ; JSATA2.32 237.12,25.88 ; JSATA2.32 234.33,24.33 ; JSATA2.32 237.12,25.11 ; JSATA2.32 235.72,24.33 ; JSATA2.32 234.33,25.11 ; JSATA2.32 235.72,25.88 ; 357.81,204.16 JUSB3.13 ; JUSB3.13 357.81,203.28 ; JUSB3.13 361.37,204.16 ; JUSB3.13 357.81,205.03 ; JUSB3.13 359.59,205.03 ; JUSB3.13 361.37,205.03 ; JSATA2.21 235.95,33.73 ; JSATA2.21 234.9,33.73 ; JSATA2.21 235.95,32.68 ; JSATA2.21 235.43,33.88 ; JSATA2.21 235.43,32.53 ; JSATA2.21 234.9,32.68 ; JSATA2.21 236.1,33.21 ; 168,183.75 JDOCK1.157 ; JDOCK1.157 167.2,185.6 ; JDOCK1.157 166.95,184.81 ; JDOCK1.157 168.8,184.01 ; JDOCK1.157 167.2,184.01 ; JHDMI1.22 13.03,196.92 ; JHDMI1.22 13.03,198.77 ; JHDMI1.22 13.03,197.84 ; JHDMI1.22 10.47,197.84 ; JHDMI1.22 10.47,196.92 ; JHDMI1.22 11.75,198.77 ; JHDMI1.22 10.47,198.77 ; JHDMI1.22 11.75,196.92 ; H27.1 18.34,214.69 ; H27.1 18.83,216.04 ; H27.1 17,214.21 ; H27.1 17,217.86 ; H27.1 18.34,217.38 ; H27.1 15.17,216.04 ; H27.1 15.66,217.38 ; H27.1 15.66,214.69 ; 192,183.75 JDOCK1.159 ; JDOCK1.159 192.8,185.6 ; JDOCK1.159 190.95,184.81 ; JDOCK1.159 192,185.86 ; JDOCK1.159 193.05,184.81 ; JDOCK1.159 192.8,184.01 ; JDOCK1.159 191.2,184.01 ; 356.68,199.28 JUSB3.4 ; JUSB3.4 357.21,199.13 ; JUSB3.4 357.21,200.48 ; JUSB3.4 357.88,199.81 ; JUSB3.4 356.68,200.33 ; JUSB3.4 356.53,199.81 ; JUSB3.4 357.74,199.28 ; JUSB3.4 357.74,200.33 ; 108.24,28.62 JSATA1.23 ; JSATA1.23 111.84,28.62 ; JSATA1.23 110.04,27.57 ; JSATA1.23 111.84,27.57 ; JSATA1.23 110.04,29.68 ; JSATA1.23 111.84,29.68 ; JSATA1.23 108.24,27.57 ; JSATA1.23 108.24,29.68 ; 109.99,15.7 H6.1 ; H6.1 113.16,14.36 ; H6.1 112.67,13.01 ; H6.1 109.99,13.01 ; H6.1 111.33,16.18 ; H6.1 109.5,14.36 ; H6.1 111.33,12.53 ; H6.1 112.67,15.7 ; 233.25,27.23 JSATA2.1 ; JSATA2.1 234.6,27.23 ; JSATA2.1 234.45,26.7 ; JSATA2.1 233.93,26.55 ; JSATA2.1 233.4,26.7 ; JSATA2.17 237.83,30.68 ; JSATA2.17 237.15,30 ; JSATA2.17 237.3,30.53 ; JSATA2.17 238.35,29.48 ; JSATA2.17 237.83,29.33 ; JSATA2.17 238.5,30 ; JSATA2.17 237.3,29.48 ; JSATA2.17 238.35,30.53 ; JSATA2.14 238.35,27.08 ; JSATA2.14 237.83,26.93 ; JSATA2.14 237.3,28.13 ; JSATA2.14 237.3,27.08 ; JSATA2.14 238.35,28.13 ; JSATA2.14 237.15,27.6 ; JSATA2.14 238.5,27.6 ; JSATA2.14 237.83,28.28 ; 231.25,65.63 MBATT1.7 ; MBATT1.7 234.51,66.46 ; MBATT1.7 232.88,67.28 ; MBATT1.7 231.25,67.28 ; MBATT1.7 234.51,65.63 ; MBATT1.7 234.51,67.28 ; MBATT1.7 231.25,66.46 ; MBATT1.5 233.66,58.51 ; MBATT1.5 232.28,59.1 ; MBATT1.5 233.48,57.91 ; MBATT1.5 233.48,59.1 ; MBATT1.5 232.1,58.51 ; MBATT1.5 232.28,57.91 ; JHDMI1.8 12.18,204.09 ; JHDMI1.8 12.06,204.56 ; JHDMI1.8 11.13,203.63 ; JHDMI1.8 11.01,204.09 ; JHDMI1.8 11.13,204.56 ; JHDMI1.8 12.06,203.63 ; 115.37,189.4 PBATT1.4 ; PBATT1.4 116.92,190.07 ; PBATT1.4 115.58,188.72 ; PBATT1.4 116.25,190.27 ; PBATT1.4 116.92,188.72 ; PBATT1.4 117.13,189.4 ; PBATT1.4 116.25,188.52 ; PBATT1.4 115.58,190.07 ; JUSB3.12 366.69,205.03 ; JUSB3.12 365.32,204.16 ; JUSB3.12 368.06,205.03 ; JUSB3.12 365.32,205.03 ; JUSB3.12 368.06,204.16 ; 163.5,187.75 JDOCK1.161 ; JDOCK1.161 165.56,187.75 ; JDOCK1.161 165.56,188.73 ; JDOCK1.161 161.44,189.71 ; JDOCK1.161 163.5,189.71 ; JDOCK1.161 161.44,188.73 ; JDOCK1.161 161.44,187.75 ; JDOCK1.161 165.56,189.71 ; H2.1 303.55,62.81 ; H2.1 303.55,57.72 ; H2.1 297.47,60.27 ; H2.1 298.45,57.72 ; H2.1 301,56.73 ; H2.1 304.53,60.27 ; H2.1 298.45,62.81 ; H2.1 301,63.8 ; 107.13,187.41 PBATT1.11 ; PBATT1.11 106.07,189.4 ; PBATT1.11 108.18,187.41 ; PBATT1.11 108.18,189.4 ; PBATT1.11 106.07,187.41 ; H12.1 231.83,184.81 ; H12.1 231.34,186.15 ; H12.1 228.66,183.46 ; H12.1 228.17,184.81 ; H12.1 228.66,186.15 ; H12.1 231.34,183.46 ; H12.1 230,186.63 ; H12.1 230,182.98 ; JSATA2.20 237.83,33.08 ; JSATA2.20 237.3,32.93 ; JSATA2.20 238.5,32.41 ; JSATA2.20 237.83,31.73 ; JSATA2.20 237.3,31.88 ; JSATA2.20 238.35,32.93 ; JSATA2.20 238.35,31.88 ; JSATA2.20 237.15,32.41 ; H10.1 249.34,127.94 ; H10.1 246.17,126.6 ; H10.1 248,128.42 ; H10.1 246.66,125.25 ; H10.1 249.34,125.25 ; H10.1 248,124.77 ; H10.1 246.66,127.94 ; H10.1 249.83,126.6 ; JDOCK1.156 210.56,180.88 ; JDOCK1.156 210.56,181.86 ; JDOCK1.156 210.56,179.9 ; JDOCK1.156 206.44,179.9 ; JDOCK1.156 208.5,179.9 ; JDOCK1.156 206.44,181.86 ; JDOCK1.156 208.5,181.86 ; JDOCK1.156 206.44,180.88 ; H7.1 207.34,2.21 ; H7.1 204.66,4.9 ; H7.1 206,5.38 ; H7.1 206,1.73 ; H7.1 204.66,2.21 ; H7.1 207.83,3.56 ; H7.1 207.34,4.9 ; H7.1 204.17,3.56 ; JDOCK1.163 193.05,189.71 ; JDOCK1.163 192,189.71 ; JDOCK1.163 192,187.75 ; JDOCK1.163 190.95,188.73 ; JDOCK1.163 190.95,189.71 ; JDOCK1.163 190.95,187.75 ; JDOCK1.163 193.05,187.75 ; JDOCK1.163 193.05,188.73 ; JUSB2.4 357.88,223.31 ; JUSB2.4 356.68,222.78 ; JUSB2.4 357.74,223.83 ; JUSB2.4 356.53,223.31 ; JUSB2.4 357.21,222.63 ; JUSB2.4 357.74,222.78 ; JUSB2.4 356.68,223.83 ; JUSB2.4 357.21,223.98 ; 111.33,19.34 H3.1 ; H3.1 109.99,19.82 ; H3.1 112.67,22.51 ; H3.1 112.67,19.82 ; H3.1 111.33,22.99 ; H3.1 109.5,21.17 ; H3.1 109.99,22.51 ; H3.1 113.16,21.17 ; 10.51,209.06 JHDMI1.17 ; JHDMI1.17 10.51,208.13 ; JHDMI1.17 10.63,208.59 ; JHDMI1.5 10.63,202.59 ; JHDMI1.5 10.51,202.13 ; JHDMI1.5 10.51,203.06 ; JUSB2.7 358.18,220.33 ; JUSB2.7 358.71,220.48 ; JUSB2.7 358.71,219.13 ; JUSB2.7 358.04,219.81 ; JUSB2.7 358.18,219.28 ; 10.51,206.06 JHDMI1.11 ; JHDMI1.11 10.51,205.13 ; JHDMI1.11 10.63,205.59 ; 326.48,226.54 JUSB1.4 ; JUSB1.4 326.62,226.01 ; JUSB1.4 325.28,226.01 ; JUSB1.4 325.95,225.34 ; JUSB1.4 326.48,225.49 ; JUSB1.4 325.42,225.49 ; JDOCK1.154 180,181.86 ; JDOCK1.154 180,179.9 ; JDOCK1.154 178.95,179.9 ; JDOCK1.154 178.95,181.86 ; JDOCK1.154 178.95,180.88 ; JDOCK1.154 181.05,180.88 ; JDOCK1.154 181.05,179.9 ; JDOCK1.154 181.05,181.86 ; H17.1 129.05,78.78 ; H17.1 127.45,78.19 ; H17.1 129.05,74.41 ; H17.1 127.45,75 ; H17.1 131.23,76.6 ; H17.1 130.65,75 ; H17.1 126.86,76.6 ; H17.1 130.65,78.19 ; 178.61,119.69 H18.1 ; H18.1 181.81,116.5 ; H18.1 180.21,120.28 ; H18.1 181.81,119.69 ; H18.1 178.03,118.1 ; H18.1 180.21,115.91 ; H18.1 178.61,116.5 ; H18.1 182.39,118.1 ; JSATA2.33 237.12,47.33 ; JSATA2.33 235.72,48.88 ; JSATA2.33 234.33,48.11 ; JSATA2.33 234.33,48.88 ; JSATA2.33 237.12,48.11 ; JSATA2.33 234.33,47.33 ; JSATA2.33 235.72,47.33 ; JSATA2.33 237.12,48.88 ; 5.31,174.37 JUSB4.12 ; JUSB4.12 6.68,175.25 ; JUSB4.12 6.68,174.37 ; JUSB4.12 3.94,175.25 ; JUSB4.12 3.94,174.37 ; JUSB4.4 14.79,180.27 ; JUSB4.4 14.26,180.12 ; JUSB4.4 14.79,178.92 ; JUSB4.4 15.32,180.12 ; JUSB4.4 15.32,179.07 ; JUSB4.4 14.12,179.6 ; JUSB4.4 15.46,179.6 ; JUSB4.4 14.26,179.07 ; 182.84,161.75 H15.1 ; H15.1 182.84,164.1 ; H15.1 184.01,161.34 ; H15.1 185.19,164.1 ; H15.1 182.42,162.93 ; H15.1 185.19,161.75 ; H15.1 185.6,162.93 ; H15.1 184.01,164.52 ; JDOCK1.160 204.8,185.6 ; JDOCK1.160 203.2,184.01 ; JDOCK1.160 204,183.75 ; JDOCK1.160 204,185.86 ; JDOCK1.160 204.8,184.01 ; JDOCK1.160 203.2,185.6 ; JDOCK1.160 205.05,184.81 ; 234.45,46.06 JSATA2.13 ; JSATA2.13 235.13,45.38 ; JSATA2.13 235.65,45.53 ; JSATA2.13 234.6,46.58 ; JSATA2.13 234.6,45.53 ; JSATA2.13 235.8,46.06 ; JSATA2.13 235.65,46.58 ; JSATA2.13 235.13,46.73 ; JDOCK1.153 165.56,180.88 ; JDOCK1.153 165.56,181.86 ; JDOCK1.153 165.56,179.9 ; JDOCK1.153 163.5,181.86 ; JDOCK1.153 161.44,180.88 ; JDOCK1.153 161.44,179.9 ; JDOCK1.153 161.44,181.86 ; JDOCK1.153 163.5,179.9 ; JSATA2.7 234.6,34.85 ; JSATA2.7 233.93,35.52 ; JSATA2.7 234.45,35.37 ; JSATA2.7 233.25,34.85 ; JSATA2.7 233.4,35.37 ; JUSB3.10 361.37,187.58 ; JUSB3.10 359.59,187.58 ; JUSB3.10 357.81,188.46 ; JUSB3.10 357.81,187.58 ; JUSB3.10 357.81,189.33 ; JUSB3.10 361.37,188.46 ; 181.05,78.91 H19.1 ; H19.1 182.65,79.5 ; H19.1 179.45,79.5 ; H19.1 182.65,82.69 ; H19.1 181.05,83.28 ; H19.1 179.45,82.69 ; H19.1 178.87,81.1 ; H19.1 183.23,81.1 ; H9.1 234.63,77.1 ; H9.1 231.46,75.75 ; H9.1 234.14,78.44 ; H9.1 232.8,75.27 ; H9.1 230.97,77.1 ; H9.1 231.46,78.44 ; H9.1 232.8,78.92 ; H9.1 234.14,75.75 ; JDOCK1.164 210.56,187.75 ; JDOCK1.164 210.56,189.71 ; JDOCK1.164 210.56,188.73 ; JDOCK1.164 208.5,189.71 ; JDOCK1.164 208.5,187.75 ; JDOCK1.164 206.44,189.71 ; JDOCK1.164 206.44,188.73 ; JDOCK1.164 206.44,187.75 ; 128.32,189.4 PBATT1.10 ; PBATT1.10 130.43,187.41 ; PBATT1.10 128.32,187.41 ; PBATT1.10 130.43,189.4 ; PBATT1.10 129.37,187.41 ; H24.1 192.6,151.44 ; H24.1 188.81,153.04 ; H24.1 193.18,153.04 ; H24.1 189.4,151.44 ; H24.1 192.6,154.63 ; H24.1 191,150.85 ; H24.1 191,155.22 ; H24.1 189.4,154.63 ; 321.6,226.62 JUSB1.13 ; JUSB1.13 320.72,228.39 ; JUSB1.13 321.6,230.17 ; JUSB1.13 322.48,226.62 ; JUSB1.13 320.72,230.17 ; JUSB1.13 320.72,226.62 ; JHDMI1.23 13.03,211.42 ; JHDMI1.23 10.47,212.34 ; JHDMI1.23 10.47,211.42 ; JHDMI1.23 13.03,213.27 ; JHDMI1.23 10.47,213.27 ; JHDMI1.23 11.75,213.27 ; JHDMI1.23 13.03,212.34 ; JHDMI1.23 11.75,211.42 ; JUSB1.11 338.18,234.12 ; JUSB1.11 337.3,234.12 ; JUSB1.11 337.3,236.87 ; JUSB1.11 338.18,236.87 ; JUSB1.11 338.18,235.49 ; PBATT1.1 110.92,188.72 ; PBATT1.1 110.92,190.07 ; PBATT1.1 109.58,190.07 ; PBATT1.1 109.58,188.72 ; PBATT1.1 111.13,189.4 ; PBATT1.1 110.25,188.52 ; PBATT1.1 109.37,189.4 ; PBATT1.1 110.25,190.27 ; 111.84,66.04 JSATA1.24 ; JSATA1.24 108.24,66.04 ; JSATA1.24 108.24,64.99 ; JSATA1.24 108.24,67.09 ; JSATA1.24 110.04,67.09 ; JSATA1.24 111.84,64.99 ; JSATA1.24 111.84,67.09 ; JSATA1.24 110.04,64.99 ; 13.29,182.42 JUSB4.7 ; JUSB4.7 13.96,183.1 ; JUSB4.7 13.29,183.77 ; JUSB4.7 13.82,183.62 ; JUSB4.7 13.82,182.57
  BOTTOM w0.089: v2(153.73,111.92) JCPU1.W33 ; JCPU1.AP35 139.2,113.47 v2(138.73,113.94)
  BOTTOM w0.102: UV4.J1 v2(193.05,125.9) ; v3(353.83,185.81) 353.77,185.75 352.4,185.75 R15.2 ; UV3.J10 193.45,140.98 v2(193.65,140.78) ; UV3.D10 189.38,141.3 v2(189.04,141.64) ; v2(138.73,105.92) JCPU1.AP27 ; v2(209.91,159.7) UV7.D10 ; v2(141.73,110.92) JCPU1.AL32 ; v3(105.85,165.57) 105.84,165.56 v2(105.84,164.78) ; 208.17,63.45 208.17,63.46 208.17,64.05 ; v2(206.71,158.9) UV7.J10 ; v2(197.85,141.7) UV3.P10 ; UV10.J1 227.71,166.89 v2(227.71,166.9) ; v4(186.2,95.33) 187.19,95.33 v3(187.21,95.31) ; v2(47.52,188.21) 47.52,187.5 v3(47.43,187.41)
  BOTTOM w0.127: UV1.N2 216.85,145.18 216.57,144.9 216.57,144.58 216.49,144.5 v2(216.49,143.8)
  BOTTOM w0.203: UV1.K7 214.16,142.4 213.75,142.81 213.08,142.81 ; v2(211.67,126.38) 211.43,126.63 211.43,127.03 211.05,127.41 UV1.F25 ; v2(225.17,119.85) 225.42,119.6 UV1.AD35 UV1.AD37 ; U100.11 v2(284.72,180.34) ; UV1.AR5 234.55,143.9 v2(234.93,144.28) ; 213.08,142.81 213.45,143.18 UV1.J6 ; 213.08,142.81 v2(213.05,142.79) ; UV1.AW32 238.07,122.2 238.25,122.01 v2(238.26,122.01) ; U102.11 301.66,193.41 v2(301.73,193.48) ; v2(229.18,117.41) 229.18,117.45 228.85,117.78 UV1.AH39 ; U105.11 v2(223.85,37.59)
  BOTTOM w0.254: UV7.C12 v2(211.51,157.29) ; UV5.A14 199.85,115.11 v2(200.24,115.49) ; JDOCK1.91 190.75,181.71 190.43,182.03 190.15,182.03 189.75,181.63 JDOCK1.87 189.75,179.72 v2(189.54,179.51) ; v2(208.11,126.14) 208.16,126.2 UV1.B27 ; UV1.AP39 233.61,118 v2(233.12,117.5) 232.85,117.77 UV1.AN38 ; v2(211.96,138.34) 211.77,138.34 211.46,138.04 211.45,138.04 211.05,137.64 UV1.F13 ; v2(218.36,145.67) 218.36,145.28 UV1.R2 ; JDOCK1.131 201.75,181.66 201.37,182.04 199.36,182.04 v2(198.75,182.65) JDOCK1.119 ; UH1.G38 217.04,72.06 v2(216.61,72.49) ; UV7.T10 v2(201.1,159.68) ; UV1.AE6 226.65,142.71 v2(226.61,142.67) ; v2(231.87,142.77) 231.87,142.77 231.45,143.18 UV1.AL6 ; UV5.B10 v2(198.65,118.7) ; v2(329.62,193.18) 329.54,193.1 U90.10 ; UV8.J1 206.31,167.03 v2(206.33,167.05) ; v2(220.55,156.45) 220.55,156.43 220.89,156.09 UV9.U14 ; v2(225.77,159.82) 225.71,159.76 UV9.L10 ; UV3.N3 v2(197.05,136.09) ; v2(198.65,142.5) UV3.R12 ; UV9.B10 v2(232.51,159.7) ; v2(197.85,125.9) UV5.C1 v2(197.85,125.1) ; UV7.N3 203.09,164.9 v2(202.7,164.5) ; UV3.R11 v2(197.85,142.5) ; JDOCK1.26 173.25,187.51 v2(173.48,187.29) 174.42,187.29 174.75,187.62 JDOCK1.32 ; UV5.N12 190.35,116.69 190.65,116.99 v2(190.65,117.15) ; v2(197.85,144.9) UV3.R14 v2(197.85,144.1) UV6.C13 ; UV3.L5 v2(195.45,137.7) UV3.M5 ; v2(183.7,190.35) 183.75,190.3 JDOCK1.64 ; v2(223.94,117.38) 223.94,117.88 UV1.AB39 ; v2(232.51,158.06) 232.55,158.06 232.11,158.49 UV9.C11 ; UV1.U6 219.92,143.2 220.43,142.68 v2(220.56,142.68) 220.85,142.68 221.36,143.2 UV1.W6 ; v2(211.5,129.82) 211.5,129.82 211.5,129.81 211.05,129.36 UV1.F23 ; UV9.G10 v2(229.31,159.7) UV9.F10 ; UH1.D42 218.83,72.11 v2(218.83,71.96) ; v2(191.05,137.83) UV3.F5 190.65,136.9 190.65,135.99 190.35,135.69 UV3.E3 ; v2(205.64,167.03) 205.51,166.9 UV7.K1 205.38,166.37 205.38,165.83 UV7.K2 ; UV7.N14 203.11,155.73 203.14,155.7 v2(203.14,155.55) ; v2(210.67,134.74) 211.02,134.4 UV1.F17 ; U95.10 v2(341.72,193.81) ; v2(230.09,124.22) 230.09,124.31 229.85,124.55 UV1.AJ28 ; UH1.R2 v2(204.44,64.42) ; v2(236.9,135.44) 236.46,135 UV1.AW16 ; UV1.AN17 233.05,134.17 v2(232.5,133.62) 233.05,133.07 UV1.AN19 ; v2(209.04,134.7) 209.05,134.7 UV1.B17 ; v2(214.22,117.5) 214.45,117.74 UV1.K39 ; v2(216.49,143.8) 216.49,143.8 216.6,143.69 216.6,143.25 UV1.N6 ; JDOCK1.58 182.25,187.56 v2(182.44,187.36) ; UV3.B10 v2(187.85,140.57) ; UV7.R11 201.53,158.49 v2(201.91,158.12) 201.91,158.09 UV7.R12 ; UV1.AP30 UV1.AN30 233.05,123.75 v2(232.67,124.13) ; v2(201.42,166.99) 201.45,166.95 201.45,166.55 UV7.R1 ; UV3.H2 192.54,134.79 192.54,134.2 UV3.H1 192.65,134.09 193.05,133.69 v2(193.05,133.69) ; v2(172.96,183.21) 173.25,182.92 JDOCK1.25 ; v2(212.31,158.09) UV7.A12 ; v2(211.51,159.71) 211.51,159.69 UV7.B10 ; v2(196.26,115.49) 196.65,115.11 UV5.E14 ; UV5.T10 v2(187.45,118.7) ; UV7.C4 v2(210.71,164.5) ; R491.1 178.8,178.98 178.9,179.08 178.9,179.77 178.75,179.92 JDOCK1.47 ; UV5.F10 v2(195.45,118.7) UV5.G10 ; UV9.K13 226.41,156.8 226.41,156.19 UV9.K14 226.45,156.03 226.45,155.63 226.53,155.55 226.53,155.38 226.56,155.35 v2(226.54,155.35) ; v2(233.31,166.9) UV9.A1 ; JDOCK1.81 188.25,179.68 v2(188.12,179.55) ; v2(186.71,114.59) 186.71,114.75 UV5.U14 ; UV7.C11 v2(210.71,158.9) ; JDOCK1.82 188.25,189.98 v2(188.4,190.13) ; UV1.AK31 230.68,122.8 231.03,122.44 v2(231.03,122.42) ; UV4.C13 188.65,116.15 188.65,116.15 188.65,116.53 188.65,116.54 UV5.R12 v2(188.25,117.1) UV5.R11 v2(189.05,117.9) UV5.P10 ; v2(211.16,117.47) 211.25,117.56 UV1.F39 ; 227.68,156.51 228.06,156.89 UV9.H13 ; 227.68,156.51 227.68,156.51 228.1,156.09 UV9.H14 ; 227.68,156.51 v2(227.71,156.51) ; v2(197.25,187.54) JDOCK1.114 ; UV1.AG6 228.16,143.2 227.86,143.5 v2(227.84,143.5) ; UV5.C3 v2(198.65,123.5) ; UV3.E12 v2(190.65,142.5) ; UV9.C14 232.11,156.09 232.53,155.68 v2(232.55,155.68) ; UV7.H14 v2(207.51,156.49) UV7.H13 ; v2(186.65,116.29) 187.05,116.69 UV5.U12 ; v2(207.99,122.82) 208.16,123 UV1.B31 ; UV9.N14 224.12,156.08 224.12,155.64 v2(224.17,155.6) ; UV1.AF10 227.63,140 v2(227.81,140.18) ; UV7.L5 v2(204.71,162.77) ; JDOCK1.14 170.25,187.99 169.91,187.65 169.87,187.65 169.43,187.21 v2(169.35,187.21) 168.75,187.81 JDOCK1.8 ; v2(199.94,155.56) 199.94,156.07 UV7.U14 ; v2(228.51,166.9) UV9.H1 v2(228.51,166.1) UV9.H2 ; v2(231.05,133.48) 231.05,133.58 231.45,133.98 UV1.AL17 ; v2(196.25,141.7) UV3.M10 ; v2(208.09,139.02) 208.12,139 UV1.B11 ; UV1.AP19 233.63,132.57 v2(233.63,132.27) ; v2(158.66,89) 158.64,89 158.2,89.44 JCPU1.R11 ; JDOCK1.75 186.75,179.97 186.69,179.91 186.69,179.5 v2(186.65,179.46) ; v2(234.33,140.97) 234.23,140.97 234.23,140.93 234.1,140.8 UV1.AP9 ; v2(194.65,125.9) UV5.H1 v2(194.65,125.1) UV5.H2 ; UV3.F10 v2(191.05,140.77) ; v2(191.85,121.77) UV5.L5 ; UV7.P10 v2(201.91,158.9) ; UV3.N1 196.65,134.11 v2(196.26,134.49) ; UV1.AL26 231.45,127.38 v2(231.82,127.75) ; UV6.J1 193.45,134.09 v2(193.02,134.52) ; UV1.L2 215.2,145.25 215.2,145.67 214.81,146.06 v2(214.81,146.2) ; v2(210.71,156.49) UV7.C14 ; UV1.AL23 231.83,129.78 v2(231.83,130.01) ; UV1.A37 208.45,118.8 v2(208.11,118.46) ; UV1.AM35 231.86,119.6 v2(231.57,119.89) 231.45,120.01 UV1.AL34 ; UV7.E1 v2(209.11,166.9) ; v2(223.07,143.57) 223.45,143.2 UV1.AA6 ; v2(233.27,126.34) 233.27,126.33 233.6,126 UV1.AP27 UV1.AP28 ; v2(232.69,125.14) 232.69,125.35 233.05,125.72 UV1.AN27 ; v2(197.85,123.5) UV5.C4 ; JDOCK1.49 179.25,179.93 180.04,179.13 v2(180.04,178.79) ; UV9.G5 v2(229.31,162.9) ; v2(205.77,155.57) 205.77,155.57 205.51,155.83 UV7.K14 205.4,156.2 205.4,156.79 UV7.K13 ; JCPU1.P11 159.22,89.45 v2(159.71,88.96) ; UV1.AP29 233.68,124.57 233.08,124.57 UV1.AN29 ; UV1.AK7 230.64,142.4 v2(230.25,142.78) 229.85,143.18 UV1.AJ6 ; JDOCK1.120 198.75,187.83 198.47,187.55 v2(198.03,187.55) ; v2(181.12,178.9) 180.75,179.28 JDOCK1.51 ; v2(342.12,220.1) 341.99,220.1 341.35,219.46 U92.21 ; UV1.AC2 224.9,145.2 225.17,145.47 v2(225.17,145.74) ; UH1.AT10 200.26,72.46 v2(200.02,72.23) ; UV3.R1 v2(197.85,134.49) ; UV1.AE2 226.45,145.25 226.53,145.33 226.53,145.81 v2(226.58,145.87) ; v2(208.57,132.69) 208.61,132.73 208.92,132.73 UV1.B19 ; v2(213.36,144.79) 213.42,144.79 213.65,145.02 UV1.J2 ; v2(176.84,156.01) 176.8,155.97 JLVDS1.17 ; v2(201.11,163.7) UV7.R4 ; v2(226.92,166.1) 226.51,165.7 UV9.K2 ; v2(222.5,167) 222.5,166.98 222.51,166.97 UV9.R1 ; JDOCK1.88 189.75,187.67 189.72,187.64 v2(189.72,187.54) ; JDOCK1.43 177.75,179.86 v2(177.44,179.55) ; v2(231.55,144.79) 231.54,144.79 231.54,144.81 231.25,145.1 UV1.AL2 ; v2(170.64,179.3) 170.51,179.43 170.48,179.43 170.25,179.66 JDOCK1.13 170.25,181.79 170.01,182.03 168.98,182.03 168.75,181.8 JDOCK1.7 ; v2(196.25,125.9) UV5.E1 ; UV5.H14 194.26,115.09 v2(194.66,115.49) 194.26,115.89 UV5.H13 ; UH1.H36 215.92,71.78 215.67,71.78 215.51,71.63 v2(215.43,71.63) 215.29,71.5 UH1.K33 ; v2(220.07,146.08) 220.05,146.05 UV1.U2 ; UV1.H39 212.85,117.62 v2(212.71,117.48) ; UV1.W31 221.22,122.8 v2(220.61,122.19) ; v2(186.65,125.9) UV5.U1 ; UV1.H9 212.65,140.8 v2(212.24,141.21) ; v2(234.46,139.34) 234.32,139.2 UV1.AP11 233.65,139 UV1.AN11 233.15,139.1 233.15,139.89 UV1.AN10 ; v2(187.45,137.7) UV3.B5 ; v2(213.04,141.2) 213.44,141.6 UV1.J8 ; JDOCK1.69 185.25,179.78 184.76,179.29 v2(184.76,179.26) ; UV1.AL14 231.45,136.12 v2(231.56,136.02) ; D78.3 D78.8 v2(329.55,224.04) ; v2(209,145.96) 209.14,145.96 209.45,145.65 UV1.C1 ; v2(210.75,142.82) 210.75,142.69 UV1.F7 ; v2(209.95,143.53) 210.32,143.9 UV1.E5 ; v2(208.02,124.47) 208.14,124.58 209.04,124.58 UV1.B29 ; UV1.V11 221.05,139.01 220.74,138.71 v2(220.57,138.71) ; v2(221.71,162.57) UV9.T5 ; v2(207.51,166.9) UV7.H1 v2(207.51,166.1) UV7.H2 ; v2(211.18,131.33) 211.18,130.93 UV1.F21 ; v2(231.71,166.9) UV9.C1 ; v2(212.3,155.69) 212.71,156.09 UV7.A14 ; JDOCK1.57 182.25,179.57 182.22,179.54 v2(181.75,179.54) 181.75,180.8 JDOCK1.55 ; UV7.L10 204.71,159.76 v2(204.77,159.82) ; v2(232.75,119.88) 232.75,120.09 UV1.AN34 ; v2(351.02,195.36) 351.02,195.31 351.12,195.21 D91.8 D91.3 ; v2(197.85,115.49) UV5.C14 ; JDOCK1.125 200.25,179.78 199.73,179.26 v2(199.49,179.26) 199.75,179.52 JDOCK1.123 ; UV1.F11 211.02,139.2 v2(210.63,138.8) ; v2(208.62,129.61) 208.83,129.61 UV1.B23 ; v2(200.24,134.49) 199.85,134.11 UV3.U1 ; v2(171.75,187.32) JDOCK1.20 ; v2(190.29,114.55) 190.25,114.6 UV5.N14 ; UV1.F27 211.29,126 v2(211.67,126.38) ; JLVDS1.12 176.57,153.47 v2(176.84,153.19) 176.62,152.97 JLVDS1.11 ; v2(166.68,180.67) 166.68,180.23 167.04,179.87 167.14,179.87 167.25,179.98 JDOCK1.1 ; JXDP2.7 275.24,89.83 274.97,90.1 274.97,90.22 v2(274.85,90.33) ; v2(197.05,117.1) UV5.E12 ; v2(188.62,126.05) 188.62,126 188.65,125.97 UV5.R1 ; UV1.AC28 225.05,125.25 v2(225.55,125.75) 226,126.2 UV1.AD27 ; UH1.U10 205.53,66.54 v2(205.7,66.37) 205.8,66.27 UH1.R8 ; v2(229,141.04) 228.7,141.04 UV1.AG9 ; UV1.B33 208.96,121.31 v2(208.52,121.31) ; v2(227.15,159.88) 227.15,159.46 UV9.J10 ; v2(191.05,121.77) UV5.M5 ; JDOCK1.38 176.25,187.54 v2(176.22,187.52) ; v2(19.88,184.8) D79.8 ; v2(171.91,179.34) 171.75,179.49 JDOCK1.19 ; UV9.E12 v2(230.91,158.09) ; UV7.N1 203.11,166.92 203.2,167.01 v2(203.2,167.02) ; v2(209.91,158.09) UV7.E12 ; UV1.AN8 v2(232.65,141.19) UV1.AM9 ; v2(218.11,142.74) 218.09,142.75 218.09,143.04 UV1.R6 ; UV1.AR28 235.05,125.8 235.46,125.8 235.85,126.18 UV1.AV27 235.85,126.6 UV1.AW26 236.25,127.37 236.54,127.66 236.66,127.66 v2(236.74,127.74) ; v2(215.1,143.85) 215.19,143.76 215.19,143.34 UV1.L6 ; UV7.U1 199.58,166.5 v2(199.41,166.33) ; v2(210.65,124.06) 210.65,124.06 210.99,124.4 UV1.F29 ; UV3.H14 192.63,144.48 192.63,143.72 UV3.H13 192.62,143.7 v2(192.2,143.27) ; v2(191.05,118.83) UV5.M10 ; v2(209.11,163.7) UV7.F5 ; UV1.J31 213.51,122.73 214.19,122.73 UV1.K31 214.28,122.8 v2(214.73,122.35) 215.18,122.8 UV1.L31 ; v2(223.73,165.28) 224.11,164.9 UV9.N3 ; v2(200.32,164.5) 200.31,164.5 UV7.U3 ; v2(186.65,144.9) UV3.A14 ; v2(232.7,162.78) 232.91,162.99 UV9.B5 ; v2(192.24,125.91) 192.65,125.5 UV5.K1 ; JLVDS1.24 176.62,159.47 176.91,159.18 v2(177.78,159.18) ; UV3.R3 198.25,135.69 v2(198.66,136.11) ; UV3.E1 190.25,133.73 v2(190.4,133.58) ; v2(208.44,145.34) 208.65,145.13 UV1.A3 ; v2(188.25,141.7) UV3.C11 ; UV7.M5 v2(203.91,162.77) ; UV9.C12 v2(232.51,157.29) ; v2(208.04,127.94) 208.19,127.79 209.04,127.79 UV1.B25 ; UV1.AW14 236.25,136.62 v2(236.65,137.02) ; JCPU1.P26 JCPU1.R26 ; UV9.K1 226.51,166.5 v2(226.96,166.94) ; UV1.AJ33 229.3,121.2 228.91,121.58 v2(228.9,121.58) ; UV1.V39 220.85,117.64 v2(221.02,117.46) ; v2(195.45,140.9) UV3.L10 ; v2(208.62,130.68) 208.73,130.68 UV1.B21 ; UV1.AW22 236.25,130.25 236.55,130.55 v2(236.65,130.55) ; UV9.U12 220.71,157.69 v2(220.47,157.46) ; JDOCK1.31 174.75,181.66 175.15,182.06 v2(175.15,184.61) ; UV7.N12 203.21,157.69 203.51,157.99 203.51,158.9 UV7.M10 v2(203.91,159.83) ; JDOCK1.96 192.75,189.9 192.51,190.13 v2(192.51,190.26) ; JLVDS1.27 176.61,160.97 v2(176.86,161.22) ; UV1.T11 219.05,139.08 218.69,138.71 218.69,138.71 v2(218.68,138.71) ; v2(194.65,144.9) UV3.K14 v2(194.65,144.1) UV3.K13 ; 200.86,67.82 200.86,67.74 UH1.AG2 ; v2(191.91,137.82) 191.85,137.76 UV3.G5 ; v2(213.62,125.19) 213.45,125.37 UV1.J27 ; v2(233.19,145.87) 232.85,145.53 UV1.AN2 ; v2(212.31,163.7) UV7.B5 ; UV3.U14 v2(199.45,144.9) ; UV9.A12 234.1,158.08 v2(234.11,158.08) ; UV1.AJ10 229.65,139.2 UV1.AJ11 UV1.AK11 UV1.AL11 UV1.AM11 232.6,139.34 v2(232.6,139.47) ; v2(225.71,162.77) UV9.L5 ; UV1.E39 210.35,117.73 v2(210.09,117.47) ; v2(186.51,135.6) 186.6,135.69 UV3.A3 ; UV1.AC34 225.05,119.96 v2(225.17,119.85) ; UV5.E3 v2(196.25,123.5) ; v2(187.85,121.57) UV5.T5 ; UV1.AR39 234.55,117.94 234.34,117.74 234.08,117.74 v2(234.08,117.73) ; v2(234.45,132.53) 234.48,132.56 234.48,133.22 UV1.AR18 234.45,133.6 UV1.AP18 ; UV1.H31 212.65,122.79 v2(213.05,122.39) ; UV9.R11 v2(222.11,158.09) UV9.R12 ; v2(229.76,146.32) 229.59,146.14 229.59,145.26 UV1.AJ2 ; v2(234.11,165.3) UV9.A3 ; U92.10 v2(335.52,219.46) ; UV1.B13 208.62,137.4 v2(208.45,137.57) ; UV9.N1 224.11,166.92 224.21,167.02 224.21,167.05 v2(224.2,167.05) ; UV1.AW30 237.45,123.8 237.84,123.41 v2(237.84,123.23) ; v2(217.94,71.32) 218.23,71.32 UH1.B39 ; UV5.G5 v2(195.45,121.9) ; v2(210.75,123.2) 210.75,123.2 211.05,122.9 UV1.F31 ; v2(216.91,123.11) 216.6,122.8 UV1.N31 ; UV1.AW20 236.29,131.8 v2(236.65,131.44) ; UV5.N1 190.25,125.92 190.35,126.02 190.35,126.05 v2(190.34,126.05) ; v2(236.9,134.07) 236.9,134.11 236.81,134.2 UV1.AV17 ; U94.10 32.52,184.79 v2(32.3,184.58) ; v2(210.71,140.4) 211.05,140.74 UV1.F9 ; v2(195.75,187.48) JDOCK1.108 ; UV1.F15 211.83,136 v2(211.89,135.94) ; UV1.M39 216.05,117.7 v2(215.85,117.5) ; UV8.C13 UV7.R14 v2(201.51,155.55) ; JDOCK1.76 186.75,189.81 186.28,190.28 185.25,190.28 v2(185.01,190.04) 185.25,189.8 JDOCK1.70 ; JDOCK1.93 191.25,179.19 v2(190.71,178.65) ; v2(191.25,190.07) JDOCK1.94 ; v2(234.43,134.11) 234.14,134.4 UV1.AP17 233.94,134.49 233.94,135.1 UV1.AP16 ; UV1.AE38 226.85,118.4 UV1.AF39 227.36,117.89 227.4,117.89 v2(227.79,117.5) ; JCPU1.W25 v2(153.73,103.92) ; UV5.A1 199.49,125.13 v2(199.46,125.13) ; UV9.F5 v2(230.11,163.7) ; UV3.U12 v2(200.25,143.3) ; v2(141.74,109.92) 142.2,109.46 JCPU1.AL31 ; UV7.F10 v2(208.31,159.7) UV7.G10 ; UV1.AG2 228.05,145.1 v2(228.34,144.81) ; v2(212.16,146.01) 212.16,145.31 UV1.G2 ; v2(186.65,123.5) UV5.U3 ; v2(210.64,132.45) 210.99,132.8 UV1.F19 ; JDOCK1.44 177.75,189.92 178.05,190.22 v2(178.09,190.22) ; v2(199.45,141.7) UV3.T10 ; v2(209.12,156.49) 209.51,156.11 UV7.E14 ; v2(224.49,143.66) 224.96,143.2 UV1.AC6 ; v2(220.54,166.09) 220.54,166.13 UV9.U1 ; v2(220.49,164.49) 220.9,164.9 UV9.U3 ; v2(197.25,182.41) JDOCK1.113 ; JDOCK1.63 183.75,179.93 183.36,179.54 v2(183.28,179.54) 183.25,179.57 JDOCK1.61 ; UV9.T10 221.71,159.3 222.26,159.84 v2(222.46,159.84) ; v2(222.89,165.26) 222.52,164.9 UV9.R3 ; UV1.L11 215.41,139.2 215.93,138.67 216.49,138.67 v2(216.53,138.63) ; UV5.R14 v2(188.65,114.56) ; UV7.A1 v2(212.31,166.9) ; v2(22.83,184.8) D79.3 ; v2(188.65,133.55) UV3.C1 ; v2(192.74,114.56) 192.73,114.56 192.73,114.56 192.73,114.56 192.65,114.63 UV5.K14 192.55,115.19 192.55,115.8 UV5.K13 ; v2(198.65,116.29) UV5.C12 ; UV5.R4 v2(188.25,122.7) ; v2(197.85,117.9) UV5.C11 ; JLVDS1.14 176.71,154.47 v2(176.87,154.31) 176.53,153.97 JLVDS1.13 ; UV3.T5 v2(199.45,137.7) ; UV1.W2 221.6,145.25 221.6,145.46 221.53,145.53 221.53,145.61 221.74,145.81 v2(221.74,145.82) ; v2(214.36,130.02) 214.54,130.2 UV1.L22 ; UV9.C3 232.12,164.9 v2(231.71,165.31) ; UV3.C14 188.65,144.61 v2(188.35,144.91) ; v2(224.91,159.83) UV9.M10 224.51,158.9 224.51,157.99 224.21,157.69 UV9.N12 ; v2(222.51,155.59) UV9.R14 UV10.C13 ; v2(231.71,164.5) UV9.C4 ; v2(223.28,146.13) 223.26,146.11 223.26,145.2 UV1.AA2 ; UV1.G6 211.85,143.17 v2(211.46,142.79) ; UV7.T5 v2(200.71,162.57) ; v2(210.71,166.1) UV7.C1 v2(210.71,166.9) ; v2(156.68,111.86) 156.7,111.84 156.71,111.84 157.1,111.45 JCPU1.T33 ; v2(234.11,156.49) 234.1,156.49 233.71,156.11 UV9.A14 ; U95.21 341.72,188.21 v2(341.96,187.97) ; v2(192.25,125.1) UV5.K2 ; D88.8 D88.3 v2(354.57,218.71) ; v2(196.25,142.5) UV3.N12 ; v2(224.91,162.77) UV9.M5 ; v2(200.32,158.07) 199.95,157.69 UV7.U12 ; v2(186.71,133.59) 186.71,133.75 UV3.A1 ; v2(208.31,162.9) UV7.G5 ; UV9.E3 v2(230.11,164.5) ; UV5.D10 v2(197.05,118.7) ; v2(230.13,155.73) 230.13,155.73 230.5,156.09 UV9.E14 ; v2(201.92,164.5) 201.91,164.5 UV7.R3 ; v2(236.76,128.57) 236.74,128.6 UV1.AW24 ; UV1.P31 217.71,122.8 v2(218.1,122.41) 218.48,122.8 UV1.T31 ; UV1.K14 214.19,136.6 213.84,136.94 v2(213.84,137.18) ; UV3.E14 190.25,144.94 v2(190.31,144.99) ; UV1.B7 208.95,142.29 v2(208.3,142.29) ; UV1.AD9 226.45,140.8 v2(226.69,140.55) ; UV3.N14 v2(196.25,144.9) ; UV3.K1 v2(194.65,134.49) UV3.K2 ; UV9.D10 v2(230.91,159.7) ; v2(226.68,121.29) 226.71,121.26 226.71,120.46 UV1.AE34 ; v2(229.18,117.41) 229.86,117.41 UV1.AK39 ; v2(219.39,122.59) 219.59,122.8 UV1.U31 ; v2(222.92,164.49) 222.52,164.1 UV9.R4 ; v2(209.11,164.5) UV7.E3 ; JCPU1.AA25 v2(151.73,103.92) ; UV1.B9 208.15,140.6 208.14,140.61 v2(208.14,140.63) ; JCPU1.AR26 v2(137.73,104.92) ; JDOCK1.132 201.75,187.81 201.43,187.49 v2(201.35,187.49) ; v2(231.86,122.39) 231.46,122 UV1.AL32 ; UV3.R4 v2(197.85,136.9) ; v2(200.36,136.25) 200.36,136.13 199.92,135.69 UV3.U3 ; UH1.K15 209.54,65.95 v2(209.3,65.71) 209.27,65.68 UH1.H13 ; JDOCK1.137 203.26,180.79 203.26,179.96 202.99,179.69 202.99,179.45 v2(202.95,179.41) ; v2(188.25,142.5) UV3.C12 ; v2(208.37,135.91) 208.93,135.91 UV1.B15 ; UV5.J10 v2(193.05,117.9) ; v2(200.25,190.39) JDOCK1.126 ; v2(191.91,118.82) 191.85,118.76 UV5.L10 ; UV1.AP7 233.85,142.48 v2(233.49,142.85) 233.14,143.2 UV1.AN6 ; UV5.B5 v2(199.45,122.7) ; v2(230.11,166.9) UV9.E1 ; v2(38.3,184.79) U94.21 ; U90.21 v2(329.54,186.96) ; v2(217.51,117.48) 217.65,117.62 UV1.P39 ; UV3.C3 189.05,136.09 v2(189.05,136.12) 188.67,136.5 UV3.C4 ; JDOCK1.101 194.25,181.68 194.7,182.14 195.76,182.14 v2(195.76,182.13) 195.76,180.82 JDOCK1.107 ; UV5.F5 v2(196.25,122.7) ; v2(219.35,117.27) 219.25,117.37 UV1.T39 ; v2(211.51,164.5) UV7.C3 ; v2(199.45,117.1) UV5.A12 ; UV3.G10 v2(191.85,140.77) ; UV1.Y39 222.45,117.55 v2(222.53,117.46) ; UV3.A12 v2(186.65,142.5) ; v2(200.25,124.3) UV5.A3 ; UV7.A3 v2(213.11,165.3) ; v2(222.91,158.9) UV9.P10 ; v2(194.25,187.48) JDOCK1.102 ; v2(203.25,187.52) JDOCK1.138 ; v2(190.65,124.3) UV5.N3 ; UV5.R3 v2(188.25,123.5) ; JDOCK1.37 176.25,179.91 v2(176.58,179.58)
  BOTTOM w0.279: v2(147.73,103.92) JCPU1.AE25 ; JXDP2.60 272.12,76.83 v2(272.14,76.85) ; v2(142.73,111.07) 142.73,110.82 143.1,110.45 JCPU1.AK32 ; JXDP2.26 269.39,85.33 269.06,85.66 269.03,85.66 ; JXDP2.49 274.86,79.33 v2(274.81,79.27) ; v2(166.73,100.92) 167.2,101.39 JCPU1.F23 ; JCPU1.AG35 v2(145.73,113.92) ; JXDP1.13 112.23,107.4 v2(112.21,107.42) ; 269.03,85.66 v2(269.03,85.48) ; 269.03,85.66 269.03,86.42 269.43,86.83 JXDP2.20 ; v2(171.73,100.92) 171.26,100.45 JCPU1.B22 ; v2(118,116.1) 118.17,116.1 118.46,116.4 JXDP1.50 ; v2(274.76,88.51) 275.06,88.51 275.24,88.33 JXDP2.13 ; JCPU1.AC31 v2(149.73,109.92) ; JCPU1.AG29 v2(145.73,107.92) ; v2(268.99,82.83) 269.01,82.83 269.51,82.33 JXDP2.38 ; v2(169.73,100.92) 169.26,100.45 JCPU1.D22 ; JCPU1.C22 170.26,100.45 v2(170.73,100.92) ; JCPU1.AE31 v2(147.73,109.92) ; JXDP1.59 113.84,118.91 114.99,118.91 v2(115.26,118.63) ; JXDP1.32 v2(121.13,111.9) ; v2(273.67,77.51) 273.97,77.51 273.98,77.51 274.59,77.51 275.27,76.83 JXDP2.59 ; JCPU1.AC25 v2(149.73,103.92) ; v2(272.33,79.46) 272.21,79.34 270.62,79.34 JXDP2.50 ; JCPU1.AC29 v2(149.73,107.92) ; v2(136.73,108.92) JCPU1.AT30 ; JCPU1.AA33 v2(151.73,111.92) ; JXDP1.37 115.37,113.4 v2(115.48,113.28) ; v2(121.09,113.4) JXDP1.38 ; v2(139.73,105.92) JCPU1.AN27 ; v2(140.73,110.92) JCPU1.AM32 ; JXDP2.32 270.62,83.84 272.1,83.84 v2(272.35,84.09) ; v2(142.73,107.92) JCPU1.AK29 ; v2(137.73,103.92) JCPU1.AR25 ; JCPU1.AA29 v2(151.73,107.92) ; JCPU1.AG27 v2(145.73,105.92) ; v2(274.74,82.49) 274.82,82.49 274.99,82.33 JXDP2.37 ; v2(136.73,99.92) JCPU1.AT21 ; JCPU1.AA27 v2(151.73,105.92) ; v2(112.22,105.99) 112.31,105.9 JXDP1.7 ; v2(139.73,108.92) JCPU1.AN30 ; JXDP2.14 272.06,88.33 v2(272.4,88.66) ; v2(142.73,112.92) JCPU1.AK34 ; JXDP1.26 v2(121.18,110.4) ; v2(142.73,103.92) JCPU1.AK25 ; JXDP1.20 v2(121.17,108.9) ; JXDP1.31 v2(115.32,111.9) ; JXDP1.1 111.8,104.4 v2(111.67,104.53) ; v2(272.42,91.24) 272.4,91.24 272.31,91.33 JXDP2.2 ; JCPU1.AC33 v2(149.73,111.92) ; JCPU1.AC35 v2(149.73,113.92) ; v2(274.73,83.63) 274.93,83.83 JXDP2.31 ; JXDP1.25 v2(115.32,110.4) ; JXDP2.8 270.58,89.8 269.17,89.8 268.96,90 268.58,90 v2(268.51,90.07) ; JCPU1.E22 168.26,100.45 v2(168.73,100.92) ; v2(142.73,106.92) JCPU1.AK28 ; JCPU1.AC27 v2(149.73,105.92) ; JXDP2.19 276.31,86.85 274.84,86.85 v2(274.81,86.88) ; v2(137.73,106.92) JCPU1.AR28 ; JCPU1.AG33 v2(145.73,111.92) ; v2(137.73,109.92) JCPU1.AR31 ; UV1.AL8 UV1.AK7 ; JXDP2.25 276.32,85.32 274.91,85.32 274.8,85.21 v2(274.8,85.24) ; JCPU1.AE35 v2(147.73,113.92) ; JXDP1.2 121.16,104.4 v2(121.17,104.41) ; v2(121.29,105.63) 121.02,105.9 JXDP1.8 ; JCPU1.AG25 v2(145.73,103.92) ; v2(136.73,105.92) JCPU1.AT27 ; v2(136.73,102.92) JCPU1.AT24 ; JXDP1.14 v2(121.24,107.4) ; JCPU1.AE33 v2(147.73,111.92) ; JXDP1.49 v2(115.36,116.4) ; JXDP1.19 v2(115.39,108.9) ; JCPU1.AA31 v2(151.73,109.92) ; v2(142.73,104.92) JCPU1.AK26 ; JCPU1.AE29 v2(147.73,107.92) ; JXDP2.1 275.56,91.33 275.06,91.82 v2(274.84,91.82) ; v2(142.73,108.92) JCPU1.AK30 ; JCPU1.AG31 v2(145.73,109.92) ; JCPU1.AE27 v2(147.73,105.92)
  BOTTOM w0.305: JSPI1.17 201.68,41.13 201.29,41.52 200.82,41.52 ; JCPU1.A19 172.26,97.45 v2(172.73,97.92) ; v2(157.74,104.92) 158.2,104.45 JCPU1.R26 ; JCPU1.AE7 148.2,85.39 v2(147.73,84.92) JCPU1.AE6 ; JCPU1.F20 167.25,98.45 v2(167.75,97.95) ; JCPU1.G3 166.26,81.45 v2(166.73,81.92) ; v2(168.73,82.92) 168.26,82.45 JCPU1.E4 ; v2(164.74,89.89) 164.74,89.93 164.26,89.45 JCPU1.J11 ; v2(160.73,83.92) JCPU1.N6 ; 200.82,41.52 201.18,41.16 JSPI1.18 ; 200.82,41.52 v2(200.71,41.63) ; v2(143.73,82.92) 144.2,83.39 JCPU1.AJ5 ; JCPU1.F10 167.26,88.45 v2(167.73,88.92) ; v2(160.73,79.92) JCPU1.N2 ; JCPU1.AP34 139.26,112.45 v2(139.73,112.92) JCPU1.AN34 ; JCPU1.M30 161.2,108.4 160.75,107.95 v2(160.75,107.86) 160.68,107.86 160.49,107.68 160.48,107.68 160.25,107.45 JCPU1.N29 ; JCPU1.AB1 151.2,79.39 v2(150.73,78.92) ; v2(141.73,83.92) JCPU1.AL5 ; JCPU1.D33 169.26,111.45 v2(169.73,111.92) ; JCPU1.AR16 138.2,94.39 v2(137.73,93.92) ; JCPU1.F24 167.2,102.44 166.77,102.01 v2(166.75,102.01) ; v2(166.73,89.92) 166.26,89.45 JCPU1.G11 ; JCPU1.AB3 v2(150.73,81.92) 151.2,82.39 JCPU1.AB4 ; JCPU1.J26 164.26,104.45 v2(164.73,104.92) JCPU1.H26 ; JCPU1.J34 164.2,112.39 v2(163.73,111.92) 163.26,111.45 JCPU1.K33 ; v2(155.73,105.92) JCPU1.U27 ; v2(163.73,87.92) 163.26,87.45 JCPU1.K9 ; JCPU1.T26 157.2,104.45 v2(156.74,104.92) ; v2(141.73,100.92) JCPU1.AL22 ; v2(172.73,107.92) 172.26,107.45 JCPU1.A29 ; JCPU1.W6 154.26,84.45 v2(154.73,84.92) JCPU1.W7 ; 200.14,39.15 200.57,39.15 200.68,39.27 JSPI1.19 ; 200.14,39.15 200.18,39.19 JSPI1.20 ; 200.14,39.15 v2(200.12,39.13) ; v2(170.66,105.93) 170.66,106 JCPU1.C28 ; v2(160.73,87.92) JCPU1.N10 ; v2(168.73,103.92) 168.26,103.45 JCPU1.E25 ; JCPU1.G2 166.26,80.45 v2(166.73,80.92) ; JCPU1.AN13 140.2,91.39 v2(139.73,90.92) ; v2(154.73,110.92) JCPU1.V32 ; v2(158.73,87.92) JCPU1.R10 ; v2(136.73,112.92) JCPU1.AT34 ; JCPU1.F8 167.26,86.45 v2(167.73,86.92) ; v2(146.73,83.92) 147.2,84.39 JCPU1.AF6 ; v2(141.73,93.92) JCPU1.AL15 ; JCPU1.AD11 149.2,89.39 v2(148.73,88.92) ; v2(166.73,97.92) JCPU1.F19 ; v2(138.73,93.92) 139.2,94.39 JCPU1.AP16 ; v2(167.73,87.92) 167.26,87.45 JCPU1.F9 ; JCPU1.AT7 137.2,85.39 v2(136.73,84.92) ; JCPU1.AM4 140.73,81.98 v2(140.73,81.92) ; v2(156.73,107.92) JCPU1.T29 ; JCPU1.A3 172.33,81.45 v2(172.73,81.86) ; JCPU1.F6 167.26,84.45 v2(167.73,84.92) ; v2(144.73,82.92) JCPU1.AH4 ; JCPU1.K7 163.26,85.45 v2(163.73,85.92) ; JCPU1.AP19 139.2,97.39 v2(138.73,96.92) ; JCPU1.AN7 140.2,85.39 v2(139.73,84.92) ; JCPU1.D4 169.26,82.45 v2(169.73,82.92) JCPU1.C4 ; v2(141.73,92.92) JCPU1.AL14 ; UV1.AN32 233.04,122 232.25,122.78 UV1.AM31 232.22,122.8 231.84,123.17 v2(231.84,123.19) ; JCPU1.C30 170.26,108.45 v2(170.73,108.92) ; JCPU1.AM16 141.2,94.39 v2(140.73,93.92) ; JCPU1.AT16 137.2,94.39 v2(136.73,93.92) ; JCPU1.AP7 139.2,85.39 v2(138.73,84.92) ; v2(139.73,102.92) JCPU1.AN24 ; JCPU1.B16 171.26,94.45 v2(171.73,94.92) JCPU1.A16 ; JCPU1.AR19 138.2,97.39 v2(137.73,96.92) ; v2(157.73,81.92) JCPU1.T4 ; v2(137.73,100.92) JCPU1.AR22 ; JCPU1.F30 167.26,108.45 v2(167.73,108.92) ; v2(168.73,85.92) 168.26,85.45 JCPU1.E7 ; JCPU1.D31 169.26,109.45 v2(169.73,109.92) ; v2(147.73,87.92) JCPU1.AE9 ; v2(149.73,85.92) 149.26,85.45 JCPU1.AD7 ; U88.15 116.99,10.55 116.68,10.86 v2(116.68,10.93) 116.8,11.05 U88.16 ; JCPU1.C32 v2(169.73,110.92) ; v2(136.73,80.92) 137.2,81.38 JCPU1.AT3 ; JCPU1.AT19 137.2,97.39 v2(136.73,96.92) ; JCPU1.Y11 153.2,89.39 v2(152.73,88.92) ; U88.12 118.48,8.52 v2(118.27,8.31) 117.98,8.59 U88.13 ; JCPU1.F7 167.26,85.45 v2(167.73,85.92) ; JCPU1.W9 154.26,87.45 v2(154.73,87.92) ; v2(161.73,83.92) JCPU1.M6 ; v2(144.73,86.92) JCPU1.AH8 ; v2(136.73,110.92) JCPU1.AT32 ; v2(234.97,119.28) 235.45,118.8 UV1.AU37 ; JCPU1.AC11 150.2,89.39 v2(149.73,88.92) ; JCPU1.F14 167.26,92.45 v2(167.73,92.92) JCPU1.F15 ; v2(141.73,78.92) 142.2,79.39 JCPU1.AL1 ; v2(146.73,85.92) 147.2,86.39 JCPU1.AF8 ; v2(139.73,93.92) 140.2,94.39 JCPU1.AN16 ; v2(141.74,90.93) 142.2,90.47 JCPU1.AL12 ; v2(142.73,82.92) 142.73,82.98 JCPU1.AK5 ; v2(141.73,87.92) JCPU1.AL9 ; JCPU1.K35 163.26,113.45 v2(163.73,113.92) ; JCPU1.E10 168.26,88.45 v2(168.73,88.92) ; v2(155.73,87.92) JCPU1.V10 ; v2(141.73,86.92) JCPU1.AL8 ; v2(163.73,82.92) JCPU1.K5 ; JCPU1.AG6 146.2,84.39 v2(145.73,83.92) ; v2(160.73,84.92) JCPU1.N7 ; JCPU1.AL2 142.2,80.39 v2(141.73,79.92) ; v2(166.73,96.92) JCPU1.F18 ; JCPU1.AR2 138.2,80.35 v2(137.73,79.89) ; v2(172.73,103.92) 172.26,103.45 JCPU1.A25 ; JCPU1.G4 166.26,82.45 v2(166.73,82.92) ; v2(170.73,88.92) 170.26,88.45 JCPU1.C10 ; JCPU1.B2 171.26,80.45 v2(171.73,80.92) ; v2(153.73,113.92) JCPU1.W35 ; JCPU1.M28 161.26,106.45 v2(161.73,106.92) ; v2(167.73,82.92) 167.26,82.45 JCPU1.F4 ; v2(141.73,88.92) JCPU1.AL10 ; v2(137.73,81.93) 138.2,82.4 JCPU1.AR4 ; v2(170.73,102.92) 170.26,102.45 JCPU1.C24 ; v2(147.73,79.92) JCPU1.AE1 ; JCPU1.AM24 v2(140.73,102.92) 141.2,103.39 JCPU1.AM25 ; v2(157.73,108.92) JCPU1.R30 ; JCPU1.AL3 142.2,81.39 v2(141.73,80.92) ; v2(158.73,82.92) JCPU1.R5 ; v2(160.73,80.92) JCPU1.N3 ; v2(138.73,81.92) 139.2,82.39 JCPU1.AP4 ; v2(140.73,84.92) 141.2,85.39 JCPU1.AM7 ; JCPU1.E1 168.26,79.45 v2(168.73,79.92) ; JCPU1.H7 165.26,85.45 v2(165.73,85.92) ; v2(169.73,85.92) 169.26,85.45 JCPU1.D7 ; JCPU1.A27 172.26,105.45 v2(172.73,105.92) ; UV1.L17 215.46,133.78 ; v2(140.73,101.92) JCPU1.AM23 ; v2(154.73,82.92) 154.26,82.45 JCPU1.W4 ; JCPU1.AG11 146.2,89.39 v2(145.73,88.92) ; v2(166.73,78.92) JCPU1.G1 ; JCPU1.AH6 v2(144.73,84.92) 145.2,85.39 JCPU1.AH7 ; v2(170.73,79.92) 170.26,79.45 JCPU1.C1 ; v2(150.73,85.92) JCPU1.AB7 ; v2(163.73,78.92) JCPU1.K1 ; JCPU1.C2 170.26,80.45 v2(170.73,80.92) ; JCPU1.AB10 151.29,88.45 151.44,88.6 151.45,88.61 151.46,88.61 151.5,88.65 151.55,88.71 151.55,88.72 151.73,88.9 v2(151.73,88.92) 152.2,89.39 JCPU1.AA11 ; v2(166.73,113.91) 166.67,113.91 166.22,113.45 JCPU1.G35 ; JCPU1.E19 168.26,97.45 v2(168.73,97.92) JCPU1.D19 ; v2(150.73,87.92) JCPU1.AB9 ; JCPU1.AN2 140.2,80.36 v2(139.73,79.89) 139.29,79.45 JCPU1.AP1 ; v2(154.73,112.92) JCPU1.V34 ; JCPU1.F32 167.2,110.39 v2(166.73,109.92) 166.26,109.45 JCPU1.G31 ; JCPU1.F26 167.26,104.45 v2(167.73,104.92) ; JCPU1.J30 164.26,108.45 v2(164.73,108.92) ; v2(144.73,79.92) JCPU1.AH1 ; v2(140.73,90.92) 141.2,91.39 JCPU1.AM13 ; JCPU1.H10 165.26,88.45 v2(165.73,88.92) ; v2(161.73,104.92) JCPU1.L26 ; v2(140.73,99.92) JCPU1.AM21 ; U88.10 119.48,8.49 v2(119.67,8.31) ; v2(161.73,88.92) JCPU1.M11 ; JCPU1.E13 168.26,91.45 v2(168.73,91.92) ; UV1.AD24 226.02,128.2 v2(225.58,127.76) 225.05,127.23 UV1.AC26 225.05,127.04 224.21,126.2 UV1.AB27 ; JCPU1.B13 171.26,91.45 v2(171.73,91.92) JCPU1.A13 ; JCPU1.C16 v2(169.73,94.92) ; v2(141.73,85.92) JCPU1.AL7 ; JCPU1.R34 158,112.45 157.54,112.92 157.54,113.11 JCPU1.T35 v2(156.73,113.92) ; JCPU1.C34 170.26,112.45 v2(170.73,112.92) JCPU1.B34 ; v2(140.73,100.92) JCPU1.AM22 ; v2(151.73,113.92) JCPU1.AA35 ; v2(141.73,81.92) 142.2,82.39 JCPU1.AL4 ; v2(156.73,88.92) JCPU1.U11 ; v2(232.69,125.14) 232.69,124.94 233.02,124.6 UV1.AN29 ; JCPU1.AF11 147.2,89.39 v2(146.73,88.92) ; v2(170.73,97.92) 170.26,97.45 JCPU1.C19 ; JCPU1.J6 164.2,84.39 v2(163.73,83.92) ; v2(169.73,88.92) 169.26,88.45 JCPU1.D10 ; JCPU1.D27 169.26,105.45 v2(169.73,105.92) ; v2(143.73,88.92) 144.2,89.39 JCPU1.AJ11 ; JCPU1.AL19 142.2,97.39 v2(141.73,96.92) ; v2(172.76,82.86) 172.35,82.45 JCPU1.A4 ; JCPU1.W3 154.26,81.45 v2(154.73,81.92) ; v2(170.73,91.92) 170.26,91.45 JCPU1.C13 ; JCPU1.T33 157.2,111.25 158,110.45 JCPU1.R32 ; v2(163.73,80.92) JCPU1.K3 ; v2(167.73,90.92) 167.26,90.45 JCPU1.F12 ; v2(164.73,106.92) 164.26,106.45 JCPU1.J28 ; v2(163.73,107.92) 163.26,107.45 JCPU1.K29 ; v2(163.73,86.92) 163.26,86.45 JCPU1.K8 ; v2(136.73,87.92) 137.2,88.39 JCPU1.AT10 ; v2(154.73,108.92) JCPU1.V30 ; v2(119.98,13.14) U88.5 ; v2(172.73,111.92) 172.26,111.45 JCPU1.A33 ; v2(141.73,99.92) JCPU1.AL21 ; v2(169.73,113.92) 169.26,113.45 JCPU1.D35 ; v2(172.73,85.92) 172.26,85.45 JCPU1.A7 ; v2(160.73,104.92) JCPU1.M26 ; JCPU1.AR13 138.2,91.39 v2(137.73,90.92) ; v2(157.73,83.92) JCPU1.T6 ; JCPU1.F28 167.2,106.39 v2(166.73,105.92) 166.26,105.45 JCPU1.G27 ; JCPU1.AR7 138.2,85.39 v2(137.73,84.92) ; v2(163.73,79.92) JCPU1.K2 ; JCPU1.D29 169.26,107.45 v2(169.73,107.92) ; v2(172.73,88.92) 172.26,88.45 JCPU1.A10 ; v2(160.73,81.92) JCPU1.N4 ; v2(169.73,91.92) 169.26,91.45 JCPU1.D13 ; v2(164.73,84.92) JCPU1.H6 ; v2(172.73,109.92) 172.26,109.45 JCPU1.A31 ; JCPU1.AN10 v2(140.73,87.92) 141.2,88.39 JCPU1.AM10 ; v2(165.73,83.92) JCPU1.G5 ; v2(167.73,98.92) JCPU1.F21 ; v2(144.73,88.92) JCPU1.AH10 ; v2(160.73,86.92) JCPU1.N9 ; v2(160.73,82.92) JCPU1.N5 ; JCPU1.AT13 137.2,91.39 v2(136.73,90.92) ; JCPU1.AL18 142.2,96.39 v2(141.73,95.92) JCPU1.AL17 ; v2(160.73,78.92) JCPU1.N1 ; v2(156.73,109.92) JCPU1.T31 ; v2(155.73,88.92) JCPU1.V11 ; JCPU1.F34 167.2,112.39 v2(166.73,111.92) 166.26,111.45 JCPU1.G33 ; JCPU1.B19 171.26,97.45 v2(171.73,97.92) ; v2(162.73,88.92) JCPU1.L11 ; JCPU1.R28 158.26,106.45 v2(158.69,106.02) ; JCPU1.G29 166.26,107.45 v2(166.73,107.92) ; JCPU1.AB6 151.17,84.45 150.7,84.92 v2(150.7,85.1) ; v2(162.73,83.92) JCPU1.L6 ; JCPU1.D16 v2(168.73,94.92) ; v2(167.73,89.92) 167.26,89.45 JCPU1.F11 ; v2(141.73,101.92) JCPU1.AL23 ; v2(141.73,84.92) JCPU1.AL6 ; v2(154.73,106.92) JCPU1.V28 ; v2(171.73,85.92) 171.26,85.45 JCPU1.B7 ; JCPU1.J32 164.2,110.39 v2(163.73,109.92) 163.26,109.45 JCPU1.K31 ; JCPU1.K10 163.26,88.45 v2(163.73,88.92) ; JCPU1.H11 165.21,89.45 165.72,89.95 v2(165.77,89.95) ; v2(157.73,78.92) JCPU1.T1 ; v2(136.71,81.96) 137.2,82.45 JCPU1.AT4 ; v2(141.73,89.92) JCPU1.AL11 ; JCPU1.E16 v2(167.73,94.92) ; v2(140.73,96.92) 141.2,97.39 JCPU1.AM19 ; v2(140.73,98.92) JCPU1.AM20 ; v2(144.73,81.92) JCPU1.AH3 ; v2(142.73,88.92) 143.2,89.39 JCPU1.AK11 ; v2(139.73,96.92) 140.2,97.39 JCPU1.AN19 ; v2(154.73,79.92) 154.26,79.45 JCPU1.W1 ; JCPU1.A22 v2(171.73,100.92) ; v2(157.73,80.92) JCPU1.T3 ; v2(139.73,99.92) JCPU1.AN21 ; v2(167.73,95.92) 167.26,95.45 JCPU1.F17 ; JCPU1.W10 154.26,88.45 v2(154.73,88.92) ; JCPU1.B10 171.26,88.45 v2(171.73,88.92) ; JCPU1.AR10 v2(138.73,87.92) 139.2,88.39 JCPU1.AP10 ; JCPU1.AE3 v2(147.73,81.92) 148.2,82.39 JCPU1.AE4 ; v2(147.73,88.92) JCPU1.AE10 ; v2(163.73,81.92) JCPU1.K4 ; v2(138.73,90.92) 139.2,91.39 JCPU1.AP13 ; JCPU1.C7 170.26,85.45 v2(170.73,85.92) ; v2(144.73,87.92) JCPU1.AH9 ; JCPU1.AN4 140.2,82.39 v2(139.73,81.92) ; v2(170.73,82.92) JCPU1.B4 ; v2(157.73,84.92) JCPU1.T7 ; v2(159.73,82.92) JCPU1.P5 ; v2(141.73,98.92) JCPU1.AL20 ; JDEG2.10 v2(328.91,160.96) ; v2(136.73,111.92) JCPU1.AT33 ; v2(141.73,102.92) JCPU1.AL24 ; v2(144.73,80.92) JCPU1.AH2 ; v2(157.73,87.92) JCPU1.T10 ; v2(157.73,86.92) JCPU1.T9 ; v2(144.73,83.92) JCPU1.AH5 ; v2(137.73,112.92) JCPU1.AR34
  BOTTOM w0.33: v2(166.73,85.92) JCPU1.F7 ; v2(137.73,87.92) 138.2,88.39 JCPU1.AR10 ; JCPU1.AN10 140.2,88.39 v2(139.73,87.92) ; JCPU1.H6 165.2,84.39 v2(164.73,83.92) ; v2(144.73,85.92) JCPU1.AH7 ; JCPU1.D25 v2(168.73,103.92) ; JCPU1.C26 v2(170.73,103.92)
  BOTTOM w0.356: PQ824.1 157.73,174.77 158.25,175.29 v2(158.31,175.29) ; PQ812.4 119.17,170.51 v4(118.98,170.7) ; v2(351.63,223.58) 351.63,223.42 352.07,222.98 U48.1 ; U49.1 v2(28.42,192.88) ; v2(155.79,175.83) 155.79,175.49 156,175.27 156.23,175.27 156.43,175.47 PQ824.4 ; v2(210.57,54.01) 210.22,54.36 209.93,54.36 UH2.3 ; v2(310.68,203.89) 310.83,203.89 311.12,204.18 U15.3 ; v2(171.73,82.92) 171.26,82.45 JCPU1.B4
  BOTTOM w0.381: v2(226.47,136.67) 226.05,136.24 UV1.AD15 ; UV1.N18 217.05,133.26 v2(217.56,133.77) 217.99,134.2 UV1.R17 218.17,134.2 v2(218.57,134.6) 219.05,135.07 UV1.T16 UV1.U15 ; U23.7 188.1,170.91 189.28,169.74 190.51,169.74 v2(190.71,169.53) ; 215.49,127.69 215.05,128.13 UV1.L24 ; 215.49,127.69 216,128.2 UV1.M24 UV1.N23 v2(217.55,129.7) UV1.R22 218.55,130.7 218.61,130.7 ; 215.49,127.69 v2(215.49,127.64) ; v2(221.55,131.7) UV1.V21 v2(220.54,130.69) 220.54,130.65 220.08,130.2 UV1.U22 UV1.T23 219.05,129.2 v2(218.6,128.75) 218.6,128.74 218.06,128.2 UV1.R24 217.52,127.67 217.53,127.67 ; v2(159.63,170.68) 159.61,170.69 159.61,171.08 159.24,171.45 PQ910.1 ; UV1.AC13 225.05,136.97 224.71,136.63 224.64,136.63 224.62,136.61 ; v2(231.06,132.45) 231.45,132.06 UV1.AL20 ; 218.62,132.75 v2(218.63,132.75) ; 218.62,132.75 218.62,132.75 219.05,133.18 UV1.T18 219.05,133.21 219.47,133.62 219.47,133.69 v2(219.45,133.7) 219.51,133.7 220.01,134.2 UV1.U17 220.05,134.22 220.5,134.67 220.62,134.67 ; 218.62,132.75 218.07,132.2 UV1.R20 217.96,132.2 v2(217.52,131.76) 217.05,131.29 UV1.N21 UV1.M22 UV1.L22 ; v2(210.09,117.47) 209.84,117.47 209.45,117.86 UV1.C39 ; UV1.AH21 UV1.AG20 228.05,132.19 v2(227.53,131.67) 227.06,131.2 UV1.AF21 227.05,131.13 v2(226.64,130.72) ; v4(162.03,172.86) 161.92,172.75 PQ910.4 ; 219.49,131.71 219.55,131.77 219.56,131.77 219.99,132.2 UV1.U20 220.52,132.67 220.52,132.67 UV1.V18 221.53,133.68 221.53,133.74 221.99,134.2 UV1.Y17 222.11,134.2 222.59,134.67 222.64,134.67 v2(222.67,134.71) 223.05,135.08 UV1.AA16 223.06,135.2 v2(223.51,135.65) 223.51,135.65 UV1.AB15 224.2,136.2 224.62,136.61 224.62,136.61 ; 219.49,131.71 219.05,131.27 UV1.T21 219.05,131.14 218.61,130.7 ; 219.49,131.71 v2(219.41,131.71) ; JCPU1.N35 160.2,114.11 v2(160.26,114.16) ; UC2.3 125.82,102.14 126.21,102.53 v2(126.21,102.96) ; Q52.1 231.89,21.54 231.52,21.91 230.86,21.91 230.59,22.18 Q52.4 230.59,23.41 230.35,23.64 230.35,25.68 230.11,25.92 229.48,25.92 v2(228.91,25.35) ; CV150.2 195.04,129.73 194.18,130.59 CV134.2 ; 220.62,134.67 v2(220.63,134.67) ; 220.62,134.67 221.05,135.1 UV1.V16 221.58,135.73 221.58,135.73 222.05,136.19 UV1.Y15 ; 217.53,127.67 v2(217.57,127.71) ; 217.53,127.67 217.06,127.2 UV1.N26 UV1.R27 ; U24.3 176.28,173.15 v2(176.21,173.23) ; v2(190.83,66.21) 190.59,65.96 190.59,65.48 190.48,65.37 190.2,65.37 UC3.3 ; PU1.2 155.61,175.65 v2(155.79,175.83) ; JCPU1.M34 161.2,112.36 160.75,111.91 160.75,111.9 v2(160.76,111.89) ; 224.62,136.61 v2(224.64,136.61) ; UV1.AG17 227.96,134.2 v2(227.47,133.71) 227.05,133.29 UV1.AF18 227.05,133.09 v2(226.64,132.69) 226.15,132.2 UV1.AD20 225.92,132.2 225.49,131.77 v2(225.47,131.77) 225.47,131.62 UV1.AC21 225.05,131.16 224.6,130.71 v2(224.6,130.68) 224.59,130.67 224.56,130.67 224.09,130.2 UV1.AB22 223.85,130.2 223.44,129.79 v2(223.44,129.73) 223.44,129.62 223.05,129.23 UV1.AA23 223.05,129.11 v2(222.67,128.72) 222.14,128.2 UV1.Y24 222.03,128.2 221.64,127.8 v2(221.51,127.8) 221.51,127.65 UV1.V26 220.93,127.2 v2(220.49,126.75) 220.49,126.63 UV1.U27 ; 218.61,130.7 v2(218.62,130.7) ; 196.2,58.43 196.11,58.34 196.11,57.68 v2(196.13,57.66) ; UV14.3 245.53,132.33 245.66,132.19 245.66,131.89 v2(245.61,131.84) ; UV1.AB24 224.04,128.2 223.54,127.69 v2(223.42,127.69) 223.05,127.33 UV1.AA26 223.05,127.1 222.69,126.74 v2(222.69,126.71) 222.66,126.71 222.15,126.2 UV1.Y27 222.05,126.18 v2(221.59,125.72) ; UV1.AB12 224.11,138.2 v2(224.51,138.59) 225.05,139.13 UV1.AC11 ; 215.46,133.78 215.88,134.2 UV1.M17 UV1.N16 217.05,135.35 v2(217.4,135.7) 217.9,136.2 UV1.R15 218.05,136.3 v2(218.49,136.74) 218.95,137.2 UV1.T13 219.47,137.61 v2(219.47,137.7) ; v2(223.05,124.16) UV1.AA28 ; UV1.T26 219.05,127.38 v2(219.38,127.71) 219.56,127.71 UV1.U24 220.51,128.66 220.52,128.66 221.05,129.19 UV1.V23 221.05,129.21 v2(221.54,129.7) 222.03,130.2 UV1.Y22 222.06,130.2 222.55,130.69 v2(222.67,130.69) 222.67,130.77 223.05,131.15 UV1.AA21 223.48,131.63 v2(223.48,131.72) 223.48,131.79 223.88,132.2 UV1.AB20 224.6,132.75 v2(224.61,132.75) 224.61,132.76 UV1.AC18 225.45,133.59 v2(225.45,133.7) 225.56,133.7 UV1.AD17 UV1.AF16 ; U58.3 v2(319.02,212.63) ; UV1.Y20 222.15,132.2 v2(222.67,132.72) 222.67,132.85 223.02,133.2 UV1.AA18 223.05,133.26 223.42,133.63 223.42,133.67 v2(223.43,133.67) 223.43,133.67 223.96,134.2 UV1.AB17 224.53,134.68 224.64,134.68 v2(224.66,134.71) 224.66,134.81 UV1.AC16 ; UV1.AD22 226.02,130.2 v2(225.5,129.67) 225.05,129.22 UV1.AC23 225.05,129.14 v2(224.64,128.74) ; JCPU1.N31 JCPU1.M30 ; JCPU1.N33 160.34,111.45 160.79,111 160.81,111 160.8,110.99 v2(160.78,110.99) 161.2,110.57 JCPU1.M32 ; v2(212.81,46.99) 212.66,46.84 212,46.84 R1636.1 ; U20.7 191.64,175.06 191.49,175.22 v2(190.05,175.22) ; U21.3 203.63,174.55
  BOTTOM w0.406: Q29.4 120.77,6.16 v2(120.53,5.92) ; v2(213.23,48.5) 213.22,48.5 212.67,49.05 U9.3 ; Q29.1 123.35,7.45 124,7.45 v2(124.33,7.78)
  BOTTOM w0.457: v2(228.85,48.21) 229.12,48.21 229.33,48 Q123.1
  BOTTOM w0.508: v2(117.14,8.62) 116.58,8.62 116.19,9.02 C388.2 ; PR15.1 147.43,169.99 147.54,170.1 PQ2.3 147.54,170.94 147.26,171.22 v2(146.99,171.22) ; JRTC1.4 318.27,147.77 v2(317.04,146.54) ; v2(213.46,36.63) 212.99,37.1 JSPI1.22 ; JMINI3.15 299.86,183.6 299.86,183.6 v2(299.5,183.25) ; v2(214.99,153.35) 214.69,153.05 RV162.1 ; PR601.1 313.6,171.03 313.84,170.79 313.84,170.72 v4(313.83,170.72) ; v2(347.61,192.33) 347.52,192.33 347.18,192.67 C1559.2 ; CV303.2 224.57,170.12 v2(224.81,169.87) ; R733.2 v2(287.38,184.67) ; JMDC1.5 258.45,138.2 257.89,137.64 v2(257.89,137.5) ; v2(218.26,49.83) 218.26,50.25 C289.2 ; v2(179.18,130.84) C113.2 ; v2(111.44,86.37) 112.87,87.81 JFAN1.6 ; R931.2 v2(219.82,20.83) ; C610.2 v2(350.38,197.75) ; CC47.2 129.1,120.88 128.77,121.21 v2(128.48,121.21) ; C288.2 213.79,51.3 v2(213.43,50.94) ; v2(339.58,214.01) R3716.2 R3714.2 ; CV210.2 CV355.2 182.08,141.87 v2(182.01,141.81) ; v2(223.15,78.02) 222.09,78.02 RH115.1 RH116.1 RH117.1 ; v2(337.32,179.97) 336.91,179.57 C967.2 ; v2(215.63,87.95) 215.65,87.97 215.76,87.97 216.56,88.78 YH2.4 ; v2(193.11,59.54) 193.38,59.81 193.38,60.91 RH231.2 ; v2(320.28,181.88) 320.71,182.31 JMINI3.54 ; CV298.2 230.25,151.82 CV315.2 232.25,151.82 RV17.2 232.27,151.46 v2(232.72,151) 233.28,151.56 CV316.2 ; v2(252.74,175.32) 252.41,175.65 C605.2 ; PC525.1 v4(114.03,155.97) ; C1542.2 v2(31.86,190.58) 32.47,190.58 32.88,190.17 R3749.2 ; R557.2 v2(317.61,192.04) ; C960.2 C958.2 338.27,179.21 338.27,180.03 337.7,180.61 v2(337.42,180.61) ; v2(41.26,178.02) C1544.2 ; C471.1 v2(311.46,192.72) 311.46,191.81 C470.1 ; RC94.2 136.41,122.77 136.18,123 v2(136.18,124.6) ; v2(267.6,185.93) 267.85,186.18 JMINI2.35 ; v2(204.76,139.87) 203.99,139.87 CV351.2 ; RC81.2 130.35,107.07 v2(130.25,107.18) ; JRTC1.2 320.83,150.45 v2(321.79,149.49) ; v2(189.75,72.4) 189.75,73.36 RH143.2 RH141.2 ; v2(195.14,31.27) 193.12,33.3 JDIMM2.206 ; v4(301.86,149.24) 301.86,147.59 300.97,146.7 v3(299.58,146.7) 297.46,146.7 297.18,146.98 PC631.2 ; R1138.2 179.73,153.77 v2(180.67,153.77) ; C43.2 C49.2 179.31,159.88 v2(179.87,160.44) ; JMINI3.34 310.66,175.47 v2(310.87,175.26) ; CV146.2 182.65,143.9 v2(182.14,143.4) 182.14,143.32 182.57,142.89 CV133.2 ; C478.2 313.11,208.88 v2(313.67,208.32) ; v2(265.71,148.32) 265.5,148.53 PC949.2 PC957.2 ; C959.2 343.33,178.42 v2(343.07,178.17) ; v2(198.29,129.16) 198.86,129.73 CV185.2 ; v2(206.33,91.7) 206.21,91.82 205.34,91.82 204.57,91.05 RH176.2 ; JMINI2.43 v2(271.05,185.88) ; v2(288.12,180.34) 287.76,180.7 C449.2 ; JLVDS1.43 171.73,162.88 v2(172.83,161.79) ; v2(345.51,213.99) 345.5,214.01 345.5,214.32 C1527.2 344.79,214.58 v2(344.79,214.05) ; v2(210.57,54.01) 210.93,54.37 CH55.2 CH56.2 CH57.2 ; RV48.1 240.94,131.71 241.22,131.99 v2(241.22,132.09) 241.22,132.56 241.05,132.73 RV43.2 ; R3736.2 39.99,190.36 40.1,190.47 v2(41,190.47) R3743.2 ; v2(195.44,61.46) 195.51,61.46 195.99,61.93 RH55.2 ; RV117.1 182.79,150.88 183.28,151.37 v2(183.68,151.37) ; R3734.2 37.19,178.23 37,178.04 36.28,178.04 36.18,178.14 ; 36.18,178.14 v2(36.18,178.05) ; 36.18,178.14 R3748.2 ; v2(331.15,174.29) 332.25,173.19 C984.2 ; v4(145.65,3.31) 145.02,3.95 PC120.2 ; v2(190.83,66.21) 190.91,66.28 191.39,66.28 RH230.2 ; v2(215.39,58.84) 215.53,58.99 215.53,59.52 CH44.2 ; C715.2 317.94,216.04 317.48,216.5 v2(317.48,216.8) ; v2(332.6,221.65) 332.6,221.93 332.8,222.14 C1537.2 ; v2(332.47,214.01) R3718.2 R3717.2 ; Y3.4 312.91,190.77 v2(312.91,191.27) ; v2(253.88,143.32) 253.34,142.78 JMDC1.18 ; PR605.1 310.24,169.35 310.21,169.39 310.21,169.43 v4(310.22,169.43) ; CH13.1 213.13,85.14 v2(213.13,84.44) ; C480.2 v2(301.35,211.21) ; v2(214.99,171.68) CV31.2 ; JMINI2.50 v2(273.85,177.38) ; PC510.2 112.39,156.01 v4(111.62,156.01) ; CH78.2 224.77,71.27 224.77,72.8 CH76.2 224.08,73.11 223.2,72.22 221.67,72.22 ; v4(312.17,169.41) 312.17,169.19 312.02,169.04 PR615.1 ; JDIMM2.205 117.2,30.16 v2(116.01,28.97) ; PQ610.3 319.82,159.41 320.3,159.89 320.93,159.89 321.71,159.11 321.71,158 320.34,156.63 v3(319.69,156.63) v2(318.3,156.63) ; Q22.3 179.8,141.11 v2(179.65,140.96) ; v2(322.39,189.61) 322.64,189.36 322.64,189.35 322.87,189.12 R3683.2 R3684.2 ; JFAN1.4 111.72,90.87 v2(111.72,90.26) ; v2(102.37,161.52) 102.42,161.57 PR738.2 ; v4(78.21,182.04) 78.09,182.17 PC706.2 ; CV329.2 195.94,110.35 196.34,109.96 v2(196.34,109.97) ; CV198.2 CV203.2 232.22,115.29 231.94,115.57 v2(231.94,115.73) ; v2(197.11,169.01) 197.52,169.42 C356.2 ; PR731.2 92.65,164.53 v2(92.48,164.35) ; 115.28,96.59 113.14,96.59 v2(112.15,97.57) ; R3731.2 R3729.2 v2(339.33,224.93) ; v2(220.52,171.03) CV312.2 CV311.2 ; C398.2 v2(229.66,37.22) ; PC511.2 127.53,157.87 v4(127.64,157.99) ; v2(15.81,210.16) 15.11,209.46 15.11,209.16 15.39,208.88 CE16.2 ; RV66.2 246.96,139.85 v2(247.94,139.85) 248.19,139.6 249.33,139.6 C718.2 ; JMINI3.43 314.26,187.08 v2(314.16,187.19) ; v2(260.38,148.36) 260.71,148.03 PC966.2 PC963.2 ; JMINI3.53 v2(291.41,181.8) ; CE9.2 188.32,178.04 188.63,178.35 v2(189.24,178.35) ; v2(211.87,59.01) 211.87,58.77 212.18,58.47 RH81.1 RH119.2 ; JMINI2.26 v2(264.25,180.63) 264.42,180.8 266.68,180.8 267.45,180.03 JMINI2.34 ; v2(234.3,112.92) CV92.2 234.63,113.73 235.12,113.23 CV98.2 ; v2(339.61,166.09) 339.96,165.73 C987.2 C986.2 ; v2(333.48,194.96) 333.52,194.92 334.11,194.92 334.58,194.45 R3687.2 335.2,194.2 335.5,193.89 R3775.2 ; CV37.2 RV22.2 235.06,148.96 v2(235.48,148.54) ; JMDC1.13 v2(259.14,132.13) ; RV169.1 RV171.1 229.59,151.46 229.59,151.32 229.81,151.09 v2(230.25,151.09) ; JSATA1.13 v2(110.46,42.89) ; JMINI1.26 339.35,203.91 v2(339.71,204.27) ; C484.2 v2(308.97,211.21) ; v2(170.56,141.06) 170.56,140.97 170.19,140.6 R111.2 ; D1.2 v2(120.51,91.96) ; CV326.2 RV110.2 192.9,110.21 193.37,109.74 v2(193.37,109.19) ; JMINI1.43 v2(346.15,212.58) ; v2(266.05,170.56) 265.55,170.07 265.48,170.07 v3(265.03,169.61) 264.52,169.11 PC962.2 PC961.2 ; JMDC1.8 254.08,137.4 v2(254.44,137.03) 254,136.6 JMDC1.10 ; CV95.2 239.09,122.85 v2(238.26,122.01) ; v2(347.61,190.64) R3759.2 R3779.2 ; C487.2 227.63,36.91 v2(228.07,37.35) 227.63,37.79 C488.2 ; JMINI2.18 v2(261.05,180.56) ; C397.2 v2(230.74,42.63) ; CE8.2 191.37,177.99 v2(190.71,178.65) ; v4(313.55,156.24) 312.91,156.24 312.87,156.27 312.85,156.27 312.4,156.72 PR658.1 ; v2(209.58,89.74) 210.12,89.2 CH63.2 ; JLVDS1.41 173.78,171.35 172.66,172.47 v2(171.81,172.47) ; C445.2 C450.2 285.66,176.95 v2(286.04,176.57) ; v2(322.94,191.15) R3688.2 R3685.2 ; C678.2 v2(262.03,141.39) ; C719.2 v2(34.69,194.28) ; JMINI3.18 304.26,175.22 v2(304.25,175.21) ; 187.09,66.22 187.38,66.51 187.38,66.87 v2(187.37,66.89) ; v2(181.99,124.76) 182.15,124.6 CV207.2 CV331.2 ; CV297.2 211.62,171.03 212.53,170.12 CV291.2 ; C369.2 202.22,177.94 202.95,178.68 v2(202.95,179.41) ; v2(323.07,183.27) 323.76,183.96 R3682.2 ; v2(347.61,186.58) R3773.2 R3776.2 ; v2(14.4,201) CE14.2 ; C366.2 180.98,177.86 180.98,178.18 180.37,178.79 v2(180.04,178.79) ; v2(198.99,109.94) RV184.2 RV107.1 ; v2(231.12,172) 231,171.87 CV299.2 CV302.2 ; v2(194.34,85.46) 194.34,84.44 194.14,84.24 CH52.2 ; JMINI1.35 v2(342.95,209.62) ; v2(223.07,73.72) 223.39,73.72 224.17,74.51 224.17,75.22 RH146.2 ; CV87.2 244.32,134.76 244.52,134.56 v2(244.52,134.56) ; v2(205.46,138.4) 205.46,138.01 204.21,136.77 RV196.2 ; JLVDS1.42 171.63,145.47 v2(170.86,146.24) ; C462.2 v2(315.32,189.12) ; RV13.2 CV29.2 227.95,171.5 v2(228.16,171.72) ; v2(259.57,186) 258.61,185.04 256.9,185.04 256.6,185.34 256.6,186.4 256.65,186.45 JMINI2.15 ; CH38.2 208.14,93.96 v2(208.14,96.02) ; 208.3,51.65 208.3,51.63 208.83,51.1 v2(208.83,50.88) ; JCAM1.9 192.95,168.66 192.95,168.92 193.58,169.56 v2(194.37,169.56) ; YV1.2 234.01,110.07 233.28,109.35 v4(233.28,109.11) ; v2(335.26,224.93) R3730.2 R3719.2 ; v2(186.11,109.99) 186.11,110.31 185.78,110.64 CV188.2 ; CV142.2 186.8,110.02 v2(186.84,109.98) ; v2(124.25,49.29) 121.96,47 JDIMM1.205 ; PC208.2 v4(206.1,9.79) ; JMINI1.54 v2(352.6,212.8) ; C1522.2 v2(332.09,195.72) ; C473.2 305.85,202.83 v2(305.19,202.17) ; CV47.2 231.91,171.53 v2(231.76,171.68) ; CE17.2 15.25,205.93 CE7.2 v2(14.33,206.08) ; v2(264.44,136.72) 264.27,136.72 263.69,137.3 R751.2 ; JDIMM1.206 187.35,45.16 186.19,44.01 v2(186.19,43.88) ; JDEG2.11 330.77,157.28 330.86,157.19 330.86,155.75 v2(330.78,155.68) ; PR105.2 v4(147.18,1.28) ; v2(222.03,60.77) 221.68,61.12 221.68,61.8 CH8.2 ; v2(16.82,200.85) CE13.2 ; CH14.1 214.38,89.27 213.44,89.27 213.09,88.91 v2(213.09,88.56) 212.68,88.56 212.26,88.13 CH64.2 ; C611.2 325.53,200.76 v2(325.23,201.07) ; CV180.2 197.71,129.73 198.19,130.21 v2(198.19,131.64) ; PR739.2 102.66,165.24 v2(103.26,164.64) ; v2(305.47,182.9) 305.47,184.79 JMINI3.21 ; JMINI1.29 340.55,210.04 340.11,209.6 v2(339.75,209.6) JMINI1.27 ; v2(180.11,178.16) 179.57,178.16 179.31,177.89 R491.1 ; U8.2 216.38,48.61 v2(216.91,49.15) ; v2(43.09,177.48) 43.09,178.04 42.78,178.35 C1545.2 42.64,178.36 42.32,178.04 v2(42.32,177.51) ; v2(254.16,185.72) 254.16,185.84 254.25,185.93 JMINI2.9 ; R3775.2 R3760.2 ; R3775.2 R3766.2 ; v2(114.41,62.18) 113.38,63.21 JSATA1.1 ; R152.1 315.74,192.56 v2(315.74,192.04) ; CV202.2 205.34,171.09 205.09,171.35 v2(205.09,171.69) 204.68,171.69 204.33,171.34 CV287.2 CV135.2 CV288.2 202.32,171.44 202.84,171.96 Q5.3 ; v4(316.68,156.11) 316.26,156.53 PR693.2 315.96,155.64 PC679.2 ; JSATA1.17 v2(110.4,37.81) ; v2(335.52,214.01) R3720.2 R3715.2 ; CV320.2 235.83,151.83 v2(235.34,151.33) 234.83,151.33 234.34,151.83 CV309.2 ; C1549.2 39.23,178.45 v2(39.65,178.03) 39.9,178.03 40.24,178.37 C1548.2 ; R3702.2 335.26,186.07 v2(335.54,186.35) ; R512.2 v2(220.96,39.64) ; v2(260.68,169.24) 260.97,168.95 PC964.2 PC965.2 ; JMDC1.16 260.03,141.9 260.23,142.1 v2(261.96,142.1) ; C463.2 v2(314.05,188.3) ; CV353.2 RV198.2 v2(181.97,146.95) ; v2(116.95,90.82) 117.46,91.33 C7.2 ; v2(326.5,196.2) 326.75,195.95 326.75,195.16 R3686.2 ; R3755.2 v2(32.11,178.08) 32.15,178.04 32.94,178.04 33.13,178.23 R3751.2 ; PR102.1 v4(149.21,1.28) ; C1528.2 343.98,217.31 v2(345.17,217.31) ; C773.2 228.54,24.98 v2(228.91,25.35) ; PC117.2 v4(149.46,12.71) ; JMINI2.27 264.66,187.37 264.66,188.47 v2(264.4,188.73) ; v2(317.11,175.23) 317.06,175.29 JMINI3.50 ; CV150.2 195.18,129.53 v2(194.62,128.97) ; v2(191.12,129.02) CV181.2 ; JMDC1.15 v2(250.35,133.7) ; JSATA1.7 v2(113.9,55.59) ; YV1.4 v2(238.32,111.77) ; v2(257.69,143.69) 257.08,143.69 256.24,142.85 JMDC1.17 ; CV140.2 v2(187.82,109.97) ; CV141.2 182.52,130.7 182.11,131.1 v2(182.1,131.1) ; v2(216.56,24.23) 215.57,23.24 Q70.3 ; v2(130.15,101.23) 130.4,100.98 RC77.2 RC79.2 RC67.2 ; C603.2 263.51,175.36 v2(264.04,174.83) 264.52,175.31 C607.1 ; C479.2 v2(300.08,211.21) ; C1167.2 295.51,210.58 v2(296.4,209.69) ; JMINI2.54 v2(277.5,188.99) ; YH2.2 217.71,92.63 218.3,92.63 v2(218.7,92.23) ; v2(201.53,169.42) 201.28,169.67 CV286.2 ; PC3.2 328.87,154.66 v2(329.33,154.2) ; C472.2 299.02,202.63 v2(299.58,202.07) ; R15.2 351.9,186.22 v2(351.9,186.8) ; CH77.2 224.58,66.45 v2(224.49,66.37) ; R3757.2 338.9,198.16 v2(338.62,197.88) ; v2(216.01,171.65) RV15.2 ; D89.1 350.5,214.26 v2(350.81,213.96) ; v2(354.44,191.4) D90.1 ; R716.2 284.34,184.65 v2(284.31,184.67) ; PR558.2 v2(120.39,148.37) ; C1558.2 335.3,190.21 v2(335.22,190.13) R3701.2 R3700.2 ; v2(125.15,100.09) 125.54,99.71 CC21.2 ; v2(318.32,210.57) 318.69,210.2 C778.2 ; v2(227.61,18.53) 227.61,19.48 227.95,19.82 R1611.2 ; v2(101.9,169.02) 101.9,168.99 102.42,168.47 PC724.2 PR740.2 ; C454.2 304.62,194.67 304.62,193.52 v2(303.89,192.8) ; JCAM1.10 192.05,158.46 v2(191.4,159.11) ; v2(14.33,203.97) 14.92,203.39 CE5.2 ; v2(298.43,194.07) 298.65,194.28 C475.2 ; PR612.1 PR610.1 v4(306.69,169.57) ; v2(130.81,121.73) 130.81,121.25 131.17,120.88 CC48.2 ; Q78.3 279.5,176.27 278.94,176.83 278.94,177.27 v2(278.82,177.38) ; CV324.2 RV131.2 205.04,118.16 205.41,118.53 v2(205.41,118.88) ; v2(179.78,168.31) v3(179.78,168.97) 179.78,169.57 C365.2 ; PC920.2 v2(149.72,120.22) ; v2(203.28,110.53) 203.28,110.41 203.03,110.16 CV212.2 ; PR106.2 v4(153.27,1.28) ; PR521.2 v4(113.9,153.94) ; v2(335.14,200.8) 336.15,201.81 JMINI1.18 ; D72.1 v2(324.47,223.41) ; v2(168.3,134.51) 168.44,134.65 168.45,134.65 169.07,135.27 C111.2 ; RV108.1 v2(188.83,109.94) ; RV42.2 240.6,126.05 v2(240.62,126.07) ; JMINI3.26 307.46,177.92 v2(307.32,178.05) ; 179.08,101.1 179.08,101.63 179.32,101.87 v2(179.32,102.36) ; v2(193.95,178.7) 193.95,178.17 194.17,177.95 R492.1 ; v2(196.2,128.98) CV149.2 ; CV45.2 CV291.2 ; CV291.2 v2(212.71,169.3) ; v2(257.74,139.13) 258.41,139.8 JMDC1.1 ; C455.2 C456.2 301.14,195.88 301.54,196.29 v2(301.54,196.91) ; RH120.1 202.72,57.23 v2(202.94,57.45) ; PR104.1 v4(152.26,1.28) ; v2(170.75,156.17) 170.75,156.15 171.73,155.16 JLVDS1.44 ; v2(192.13,129.03) CV148.2 ; v2(196.9,60.08) 196.99,60.16 196.99,60.97 RH54.2 ; CH10.2 191.78,61.95 v2(192.23,61.49) ; v2(14.27,198.31) CE15.2 ; JMINI1.50 348.95,204.07 v2(349.61,204.74) ; C604.2 274.68,175.65 274.75,175.58 274.75,174.81 v2(274.79,174.81) ; JMINI2.4 252.25,180.23 v2(252.6,180.58) ; v4(226.68,5.09) 226.68,4.52 225.99,3.84 PC309.2 ; CV285.2 v2(209.41,169.43) ; JMINI1.15 v2(331.75,212.57) ; v2(118.45,163.63) 118.45,163.13 PC547.2 PC541.1 ; JMINI1.9 v2(329.35,212.55) ; CV200.2 206.29,171.09 206.29,171.22 205.86,171.65 v2(205.81,171.65) 205.81,172.36 v3(204.82,173.35) 203.63,174.55 ; v2(16.92,203.54) CE18.2 ; v2(114.89,58.8) 114.3,59.4 JSATA1.4 ; PC919.2 v2(144.25,120.23) ; PC118.2 v4(150.73,12.71) ; JMINI1.53 v2(323.3,212.51) ; v2(30.08,178.09) R3741.2 ; R3740.2 v2(36.94,190.51) 36.93,190.53 36.19,190.53 35.92,190.26 R3745.2 ; C723.2 v2(31.86,194.2) ; v2(329.6,166.03) 330.77,167.2 JDEG2.12 ; PR603.1 310.37,171.36 v2(310.68,171.67) ; CV189.2 189.09,129.73 189.39,130.04 v2(189.39,130.35) ; v4(111.35,157.95) 111.35,158.37 112,159.02 PC527.1 ; C717.2 249.84,137.93 v2(250.43,137.35) 250.76,137.02 C677.2 ; C704.2 200.52,178.21 199.49,179.23 v2(199.49,179.26) ; v2(321.76,148.74) 322.14,148.74 322.49,148.4 JRTC1.3 ; v2(177.91,131.37) C114.2 ; R938.2 v2(319.95,215.73) ; v4(307.21,170.9) 307.34,171.03 PR609.1 ; Q59.3 v2(315.69,212.88) ; JMINI1.34 v2(342.55,201.56) ; CV115.2 v2(247.65,137.81) ; C387.2 118.5,15.06 118.83,14.73 v2(118.83,14.03) ; JMINI2.53 248.2,184.51 v2(247.56,183.87) ; v2(297.8,183.22) 297.46,183.56 JMINI3.9 ; JMDC1.14 v2(256.24,132.22) ; CV156.2 182.79,133.86 v2(182.06,134.58) ; CV43.2 182.46,132.98 182.1,133.34 v2(182.1,133.49) ; CV162.2 CV134.2 ; PR25.2 130.23,167.53 129.78,167.98 129.78,169.3 v2(129.78,169.3) ; PC548.1 114.84,149.11 v2(114.52,148.79) ; v2(306.05,211.86) 306.05,211.21 305.66,210.82 C485.1 v2(305.16,211.86) ; CV292.2 v2(210.42,169.43) ; C1529.2 C1530.2 v2(342.63,214.01) ; v2(187.05,128.98) CV143.2 ; JMINI2.21 v2(262.25,188.86) ; PC918.2 v2(146.92,120.22) ; v2(315.45,217.31) C481.2 315.44,216.6 C482.2 ; CV179.2 CV151.2 201.02,110.3 200.68,109.96 v2(199.92,109.96) ; JMINI1.21 v2(337.35,209.62) ; RV44.2 v2(233.28,112.92) ; PC917.2 v2(152.26,120.22) ; v2(309.11,188.52) Y3.2 ; v2(175.97,175.72) 177.34,175.72 Q6.3 177.91,176.29 C695.2 R757.2 ; JMINI3.35 311.06,182.91 v2(311.07,182.89) ; JMINI3.27 307.86,183.56 v2(308.21,183.21) 308.66,183.66 JMINI3.29 ; C595.2 v2(256.27,175.7) ; v4(110.94,156.01) 110.94,156.4 111.53,156.98 PC526.1 ; C772.2 v2(221.09,20.88) ; JSPI1.21 198.03,33.09 v2(197.79,32.84) ; R561.2 v2(314.56,206.01) ; C668.2 v2(18.26,186.73) ; CV94.2 v2(241.65,122.69) ; v2(265.29,188.73) 265.45,188.57 JMINI2.29 ; JMINI3.4 v2(295.46,175.22) ; PC811.2 v2(132.13,188.77) ; v2(123.86,115.46) CC17.2 ; Q48.3 v2(315.69,215.42) ; CV178.2 v2(182.16,128.66) ; CV62.2 241.09,135.56 v2(241.6,136.07) ; v2(193.93,159.57) 194.42,160.06 JCAM1.8 ; R3765.2 336.22,187.45 335.85,187.08 v2(335.52,187.08) R3699.2 ; RV186.2 v2(182.16,127.65) ; R562.2 v2(309.74,192.04) ; C761.2 v2(228.16,34.39) ; v2(327.35,200.97) JMINI1.4 ; v2(182.28,111.65) 182.53,111.39 CV42.2 ; v2(342.37,224.93) R3732.2 ; JSATA1.19 v2(110.02,35.27) ; C446.2 280.93,180.71 v2(280.26,180.03) ; v2(29.35,180.98) R3742.2 ; C474.2 v2(302.12,202.07) ; CV130.2 v2(182.14,129.68) ; C483.2 v2(307.7,211.21) ; JSATA1.11 v2(110.1,45.43) ; D74.1 v2(21.98,181.93)
  vias: v2(2.52,194.45) v2(2.48,192.68) v2(2.94,173.71) v2(2.9,171.59) v2(2.9,170.19) v2(3.67,193.31) v2(4,214.78) v2(4.05,172.61) v2(4.17,171.21) v2(4.3,169.56) v2(4.68,194.45) v2(4.81,192.29) v2(5.06,173.75) v2(5.19,171.59) v2(5.7,172.61) v2(5.7,170.45) v2(6.5,214.29) v2(6.71,194.45) v2(6.71,192.29) v2(7.86,193.31) v2(8.87,194.45) v2(9,192.29) v2(10.17,214.92) v2(10.9,195.85) v2(10.9,193.69) v2(11.53,213.68) v2(12.05,194.7) v2(13.06,195.85) v2(13.19,193.69) v2(17.06,209.52) v2(17.03,174.13) v2(17.45,169.96) v2(17.64,171.74) v2(17.75,209.5) v2(17.76,195.85) v2(17.76,195.08) v2(18.37,195.11) v2(19.77,172.72) v2(19.88,208.01) v2(20.71,201.92) v2(20.82,169.53) v2(21.66,173.99) v2(21.65,171.23) v2(21.93,204.62) v2(22.18,202.58) v2(25.34,202.83) v2(25.34,201.56) v2(25.34,200.29) v2(26.27,202.83) v2(26.27,201.56) v2(26.27,200.29) v2(27.12,202.82) v2(27.12,201.55) v2(27.12,200.28) v2(28.81,186.45) v2(28.81,185.18) v2(28.81,184.29) v2(28.81,182.89) v2(33.76,196.74) v2(33.92,205.78) v2(34.02,203.85) v2(34.83,185.24) v2(34.84,184.62) v2(34.84,184.01) v2(36.89,216.93) v2(41.23,212.31) v2(42.31,185.81) v2(42.3,183.51) v2(45.6,216.98) v2(49.39,203.59) v2(50.02,212.46) v2(54.16,216.7) v2(56.35,177.09) v2(59.01,212.46) v2(59.6,203.85) v2(63.18,216.62) v2(66.71,212.03) v2(70.06,199.17) v2(70.77,216.34) v2(71.61,207.78) v2(75.17,182.38) v2(105.47,99.68) v2(107.13,159.09) v2(109,26.61) v2(109.23,79.79) v2(109.66,84.09) v2(110.4,56.43) v2(110.5,58.08) v2(110.54,8.14) v2(110.9,78.52) v2(112.33,26.96) v2(112.43,80.05) v2(112.75,77.97) v2(115.25,57.59) v2(116.21,100.67) v2(119.12,183.06) v2(123.02,24.7) v2(123.02,23.17) v2(123.02,21.65) v2(123.02,20.13) v2(123.52,35.4) v2(123.52,33.88) v2(123.64,43.6) v2(123.64,42.08) v2(124.87,35.78) v2(124.87,33.49) v2(124.95,37.54) v2(125.14,22.03) v2(125.14,19.75) v2(125.68,43.6) v2(125.68,42.08) v2(126.35,37.6) v2(126.31,35.4) v2(126.31,33.88) v2(126.41,23.17) v2(126.41,21.65) v2(126.41,20.13) v2(126.41,16.22) v2(128.85,43.98) v2(128.85,41.69) v2(128.86,37.57) v2(128.85,35.4) v2(128.85,33.88) v2(128.95,23.94) v2(128.95,22.41) v2(128.95,20.89) v2(128.95,19.36) v2(130.98,24.32) v2(130.98,22.03) v2(131.14,43.6) v2(131.14,42.08) v2(131.14,36.92) v2(131.14,35.4) v2(131.14,33.88) v2(131.14,29.3) v2(131.14,27.53) v2(132.25,23.94) v2(132.25,22.41) v2(132.25,20.89) v2(132.25,19.36) v2(133.19,43.6) v2(133.19,42.08) v2(134.46,43.98) v2(134.46,41.69) v2(134.79,23.94) v2(134.79,22.41) v2(134.79,20.89) v2(135.17,37.54) v2(135.15,35.4) v2(135.15,33.88) v2(135.15,29.3) v2(136.06,24.32) v2(136.06,22.03) v2(136.42,42.08) v2(136.42,35.4) v2(136.42,33.88) v2(136.42,29.3) v2(136.55,27.51) v2(136.63,37.6) v2(137.66,23.94) v2(137.66,22.41) v2(137.66,20.89) v2(137.66,19.36) v2(138.67,127.01) v2(138.67,126.12) v2(138.96,43.6) v2(138.96,42.08) v2(138.92,37.67) v2(138.96,35.4) v2(138.96,33.88) v2(138.96,29.3) v2(139.1,27.53) v2(140.06,166.26) v2(140.06,165.67) v2(140.06,165.09) v2(140.23,35.78) v2(140.23,33.49) v2(140.23,29.3) v2(140.24,27.55) v2(140.2,24.73) v2(140.2,23.21) v2(140.2,21.68) v2(140.2,20.16) v2(140.32,125.07) v2(140.7,166.26) v2(140.7,165.67) v2(140.7,165.09) v2(141.33,166.26) v2(141.33,165.67) v2(141.33,165.09) v2(141.47,22.06) v2(141.47,19.78) v2(141.57,125.07) v2(141.73,91.92) v2(141.73,82.92) v2(141.97,166.26) v2(142.1,43.6) v2(142.1,42.08) v2(142.11,35.4) v2(142.11,33.88) v2(142.11,29.3) v2(142.1,27.54) v2(142.35,165.77) v2(142.6,166.38) v2(142.86,126.89) v2(142.86,125.74) v2(142.87,24.73) v2(142.87,23.21) v2(142.87,21.68) v2(142.87,20.16) v2(143,166.92) v2(142.98,165.87) v2(143.32,166.4) v2(143.59,98.68) v2(144.1,97.95) v2(144.25,124.73) v2(144.25,123.33) v2(144.38,126.38) v2(144.38,98.68) v2(144.56,94.07) v2(144.6,94.74) v2(144.89,100.47) v2(145.18,29.3) v2(145.22,27.53) v2(145.46,92.6) v2(145.65,118.25) v2(145.65,117.36) v2(145.65,116.22) v2(145.65,115.07) v2(145.62,98.68) v2(145.81,94.75) v2(145.97,123.9) v2(146.03,132.35) v2(146.03,130.95) v2(146.16,129.93) v2(146.65,98.79) v2(146.74,84.95) v2(146.92,132.47) v2(146.92,126.5) v2(146.92,100.47) v2(146.95,94.74) v2(147.3,92.66) v2(147.65,98.68) v2(147.68,132.47) v2(147.68,129.68) v2(147.68,118.25) v2(147.68,117.36) v2(147.68,116.22) v2(147.68,115.07) v2(147.71,82.99) v2(148.09,94.78) v2(148.67,95.63) v2(148.65,86.02) v2(148.7,132.47) v2(148.7,129.68) v2(148.75,98.84) v2(148.95,100.47) v2(149.11,94.8) v2(149.14,92.66) v2(149.59,118.25) v2(149.59,117.36) v2(149.59,116.22) v2(149.59,115.07) v2(149.72,132.35) v2(149.68,98.68) v2(149.84,129.3) v2(149.97,130.95) v2(149.97,127.77) v2(149.97,126.63) v2(149.97,124.85) v2(149.97,123.2) v2(150.01,94.7) v2(150.1,97.73) v2(150.25,96.39) v2(150.86,100.47) v2(150.86,92.66) v2(150.89,94.48) v2(151.24,125.49) v2(151.37,98.82) v2(151.65,94.5) v2(151.75,115.07) v2(151.82,118.25) v2(151.82,117.36) v2(151.82,116.22) v2(152,98.82) v2(152.26,124.85) v2(152.33,123.79) v2(152.38,127.77) v2(152.64,98.82) v2(152.6,94.42) v2(152.76,92.66) v2(153.02,100.47) v2(153.41,97.42) v2(153.75,98.68) v2(153.69,94.5) v2(153.75,85.94) v2(153.73,84.98) v2(153.73,81.93) v2(153.75,80.96) v2(153.78,115.07) v2(153.91,126.89) v2(153.91,125.74) v2(154.03,118.25) v2(154.03,117.36) v2(154.03,116.22) v2(154,96.83) v2(154,95.69) v2(154.32,94.48) v2(154.41,124.98) v2(154.48,92.66) v2(154.54,121.42) v2(154.57,98.81) v2(154.62,16.26) v2(154.89,97.34) v2(154.89,95.12) v2(155.05,100.47) v2(155.56,124.98) v2(155.71,96.96) v2(155.71,95.88) v2(155.78,98.68) v2(156.03,94.48) v2(156.13,92.66) v2(156.57,124.98) v2(156.67,97.4) v2(156.67,96.39) v2(156.67,95.37) v2(156.73,98.79) v2(156.92,98.17) v2(157.08,100.47) v2(157.59,126.89) v2(157.59,125.87) v2(157.75,94.5) v2(157.81,98.68) v2(158.29,92.66) v2(158.38,98.2) v2(158.66,66.07) v2(158.66,65.48) v2(158.66,64.9) v2(158.66,64.31) v2(158.89,98.65) v2(159.11,100.47) v2(159.88,154.44) v2(159.88,135.65) v2(159.88,134.89) v2(159.84,98.68) v2(159.84,97.37) v2(159.84,96.41) v2(159.84,95.64) v2(159.84,94.75) v2(160.24,155.71) v2(160.26,92.66) v2(160.35,98.01) v2(160.34,36.91) v2(160.38,136.16) v2(160.83,155.71) v2(160.86,95.24) v2(160.89,136.79) v2(161.05,98.74) v2(161.15,100.47) v2(161.37,98.01) v2(161.42,96.7) v2(161.85,98.68) v2(161.85,95.64) v2(161.85,94.75) v2(162.36,98.01) v2(162.35,92.66) v2(162.41,96.7) v2(162.8,94.37) v2(162.92,100.47) v2(162.95,98.65) v2(162.89,95.24) v2(163.23,66.03) v2(163.23,65.44) v2(163.23,64.86) v2(163.23,64.27) v2(163.38,98.01) v2(163.74,94.09) v2(163.86,98.68) v2(163.86,95.64) v2(163.86,94.75) v2(164.3,98.01) v2(164.35,96.7) v2(164.32,92.66) v2(164.51,94.22) v2(164.75,98.62) v2(164.92,95.18) v2(164.94,22.29) v2(164.94,19.24) v2(165.13,94.32) v2(165.1,43.6) v2(165.1,42.08) v2(165.11,37.54) v2(165.21,100.47) v2(165.32,98.01) v2(165.37,96.7) v2(165.67,27.43) v2(165.71,35.4) v2(165.71,33.88) v2(165.71,32.35) v2(166.47,24.19) v2(166.47,21.9) v2(166.71,83.91) v2(167.08,43.98) v2(167.08,41.69) v2(167.09,37.48) v2(167.23,35.4) v2(167.23,33.88) v2(167.23,29.3) v2(167.76,23.81) v2(167.76,22.29) v2(167.76,20.76) v2(167.76,19.24) v2(169.07,43.6) v2(169.07,42.08) v2(169.08,37.54) v2(169.26,35.4) v2(169.26,33.88) v2(169.21,29.4) v2(169.76,191.19) v2(170.3,24.61) v2(170.3,23.09) v2(170.3,21.57) v2(170.3,20.04) v2(171.1,43.6) v2(171.1,42.08) v2(171.1,35.78) v2(171.1,33.49) v2(171.57,21.95) v2(171.57,19.66) v2(171.69,191.19) v2(172.21,166.28) v2(172.84,24.61) v2(172.84,23.09) v2(172.84,21.57) v2(172.84,20.04) v2(173.46,37.54) v2(173.46,29.41) v2(173.56,43.6) v2(173.56,42.08) v2(173.56,35.4) v2(173.56,33.88) v2(173.74,191.3) v2(174.39,173.2) v2(174.61,139.33) v2(174.61,137.3) v2(175.38,23.94) v2(175.38,22.41) v2(175.38,20.89) v2(175.38,19.36) v2(175.62,139.33) v2(175.62,138.06) v2(175.62,137.3) v2(175.79,191.27) v2(176.26,43.6) v2(176.26,42.08) v2(176.26,37.48) v2(176.26,35.4) v2(176.26,33.88) v2(176.26,29.29) v2(176.54,139.33) v2(176.54,138.06) v2(176.54,137.3) v2(177.03,24.32) v2(177.03,22.03) v2(177.47,29.35) v2(177.53,43.98) v2(177.53,41.69) v2(177.62,163.96) v2(177.63,35.42) v2(177.63,33.9) v2(177.92,163.14) v2(177.9,161.89) v2(178.3,23.94) v2(178.3,22.41) v2(178.3,20.89) v2(178.3,19.36) v2(178.62,103.82) v2(178.8,43.6) v2(178.8,42.08) v2(180.32,37.54) v2(180.29,35.4) v2(180.29,33.88) v2(180.31,29.41) v2(180.65,151.6) v2(180.65,151.02) v2(180.64,150.42) v2(180.64,149.83) v2(180.85,23.22) v2(180.85,21.69) v2(180.85,20.17) v2(181.21,151.78) v2(181.25,149.83) v2(181.47,37.48) v2(181.49,43.6) v2(181.49,42.08) v2(181.82,35.78) v2(181.82,33.49) v2(181.83,29.41) v2(181.94,157.87) v2(182.12,22.07) v2(182.12,19.79) v2(182.48,156.73) v2(183.76,24.72) v2(183.76,23.19) v2(183.76,20.14) v2(184.03,35.4) v2(184.16,186.22) v2(184.15,29.41) v2(185.45,187.54) v2(185.78,173.72) v2(186.2,186.19) v2(189.1,80) v2(190.64,185.04) v2(192.69,81.29) v2(192.86,167.06) v2(194.49,72.66) v2(194.77,71.05) v2(195.77,190.54) v2(195.72,80.2) v2(196.63,75.96) v2(196.93,85.38) v2(197.14,190.59) v2(197.91,73.66) v2(197.99,86.18) v2(198.73,70.21) v2(198.84,74.54) v2(201.07,74) v2(201.28,82.44) v2(201.78,70.29) v2(201.91,114.07) v2(202.17,66.75) v2(202.32,72.5) v2(202.47,114.36) v2(202.46,75.38) v2(202.69,114.92) v2(202.69,83.76) v2(203.16,76.07) v2(203.32,65.6) v2(203.51,79.33) v2(204.2,71.39) v2(206.19,76.39) v2(206.57,84.94) v2(206.53,69.02) v2(206.74,71.11) v2(206.74,62.41) v2(206.81,59.52) v2(207.27,66.58) v2(207.41,61.52) v2(207.95,83.12) v2(207.89,59.29) v2(208.28,80.94) v2(208.33,107.53) v2(208.39,104.43) v2(208.97,100.93) v2(209.04,73.41) v2(209,62.36) v2(209.22,77.65) v2(209.23,67.23) v2(209.85,103.94) v2(210.06,81.3) v2(210.87,107.39) v2(210.83,77.94) v2(210.88,67.07) v2(211.25,74.68) v2(212.12,119.9) v2(213.14,103.94) v2(213.3,69.55) v2(213.67,119.75) v2(214.17,107.39) v2(214.17,76.25) v2(214.42,178.71) v2(214.76,76.62) v2(214.99,186.32) v2(215.22,83.2) v2(215.81,84.87) v2(215.8,73.75) v2(216.26,187.85) v2(216.44,103.94) v2(216.92,70.29) v2(217.09,107.37) v2(217.13,74.36) v2(217.91,187.59) v2(218.04,189.12) v2(218.49,119.79) v2(218.49,72.99) v2(218.5,67.17) v2(219.39,65.71) v2(220.77,71.42) v2(220.84,64.5) v2(221.8,120.01) v2(221.97,72.82) v2(222.26,63.54) v2(223.06,120.84) v2(223.34,67.77) v2(223.88,38.62) v2(223.88,36.59) v2(224.35,64.85) v2(225.79,64.86) v2(227.88,42.57) v2(227.9,41.93) v2(228.95,30.52) v2(229.08,18.52) v2(229.13,33.77) v2(230.04,42.52) v2(230.04,41.84) v2(230.86,92.25) v2(232.06,90.51) v2(233.29,111.7) v2(233.31,111.1) v2(234.07,90.69) v2(234.96,90.54) v2(246.78,10.71) v2(246.78,3.95) v2(247,141.87) v2(247.14,101.68) v2(247.51,167.98) v2(247.96,103.11) v2(248.12,167.98) v2(248.39,57.66) v2(248.52,141.87) v2(248.75,167.98) v2(249.36,167.98) v2(249.54,68.9) v2(249.83,175.34) v2(250.2,32.4) v2(250.48,46.04) v2(250.5,44.84) v2(250.53,43.7) v2(251.66,71.37) v2(252.41,46.01) v2(252.38,44.87) v2(252.43,43.8) v2(253.54,2.16) v2(256.13,11.76) v2(256.95,2.37) v2(260.71,2.25) v2(263.62,11.75) v2(264.07,2.18) v2(265.17,5.09) v2(265.54,190.51) v2(266.62,50.98) v2(266.66,35.69) v2(266.63,35.06) v2(266.63,34.43) v2(266.71,54.15) v2(266.72,52.57) v2(268.18,54.13) v2(268.19,52.64) v2(268.19,51) v2(268.84,2.4) v2(269.76,54.15) v2(269.78,52.62) v2(269.81,51.21) v2(270.21,5.45) v2(272.28,134.19) v2(272.37,36.66) v2(272.4,35.95) v2(272.4,35.19) v2(272.77,15.82) v2(273.13,136.61) v2(273.74,133.78) v2(274.2,120.33) v2(274.38,3.96) v2(274.68,12.08) v2(274.68,7.63) v2(275.95,7.89) v2(276.21,9.41) v2(276.97,33.58) v2(276.97,32.97) v2(278.49,26.3) v2(283.29,15.02) v2(283.6,18.3) v2(283.95,180.34) v2(285.48,180.34) v2(286.24,29.86) v2(287.13,63.13) v2(287.83,123.19) v2(288.45,123.19) v2(299.86,205.78) v2(300.9,191.63) v2(301.66,191.63) v2(302.42,191.63) v2(302.75,205.4) v2(304.44,205.55) v2(306.51,205.56) v2(306.69,179.79) v2(307.45,200.46) v2(307.97,165.84) v2(308.97,183.02) v2(309.1,200.16) v2(310.37,199.15) v2(310.75,201.18) v2(310.88,197.75) v2(310.88,178.19) v2(312.78,178.07) v2(314.31,199.02) v2(314.31,198.13) v2(314.6,183.24) v2(315.01,200.01) v2(315.32,199.02) v2(315.32,198.01) v2(315.64,200.04) v2(316.24,183.46) v2(316.34,200.04) v2(316.34,199.02) v2(316.34,198.01) v2(316.72,197.17) v2(317.36,197.12) v2(318.18,191.24) v2(319.9,190.89) v2(320.4,188.98) v2(321.32,137.17) v2(321.88,131.33) v2(321.9,129.93) v2(322.05,202.26) v2(322.18,217.82) v2(322.25,201.5) v2(322.19,199.72) v2(322.31,175.26) v2(322.55,197.89) v2(322.61,130.77) v2(322.66,124.96) v2(322.94,179.84) v2(323.07,196.35) v2(323.07,195.72) v2(323.2,225.82) v2(323.38,131.36) v2(323.32,129.9) v2(323.58,225.31) v2(324.11,137.17) v2(324.57,124.96) v2(327.64,184.04) v2(327.87,196.35) v2(328.84,179.88) v2(329.17,190.39) v2(329.17,189.75) v2(329.41,196.25) v2(329.55,184.04) v2(329.8,190.39) v2(329.8,189.75) v2(330.06,200.8) v2(330.06,200.16) v2(330.69,200.8) v2(330.69,200.16) v2(331.45,195.72) v2(331.52,184.25) v2(332.57,219.54) v2(332.91,196.23) v2(333.94,159.88) v2(334.5,200.8) v2(334.5,200.16) v2(335.14,200.16) v2(335.9,209.31) v2(336.86,186.54) v2(337.46,186.52) v2(338.31,219.85) v2(338.31,218.71) v2(338.56,227.22) v2(338.95,219.85) v2(338.95,218.71) v2(339.33,227.85) v2(339.33,173.24) v2(339.33,171.72) v2(339.33,170.32) v2(340.01,196.49) v2(340.85,170.95) v2(340.85,169.05) v2(341.04,208.86) v2(341.21,227.95) v2(341.26,191.29) v2(341.26,190.65) v2(341.89,191.29) v2(341.89,190.65) v2(341.98,196.85) v2(342.04,169.05) v2(343.64,172.22) v2(343.64,170.32) v2(343.64,169.05) v2(344.37,227.94) v2(344.39,205.07) v2(344.98,218.8) v2(345.04,205.05) v2(345.31,221.51) v2(345.72,228) v2(346.07,219.82) v2(345.99,195.66) v2(346.29,197.46) v2(346.48,216.51) v2(346.57,221.88) v2(346.57,221.25) v2(346.57,207.53) v2(347.2,204.99) v2(347.33,207.53) v2(348.98,225.87) v2(350.36,225.59) v2(351.57,153) v2(351.82,190.41) v2(351.93,192.32) v2(352.15,226.09) v2(354.41,226.07) v2(354.52,216.14) v2(354.68,154.51) v2(354.78,202.37) v2(354.91,224.08) v2(354.91,223.44) v2(354.91,222.76) v2(354.91,222.12) v2(355.06,206.2) v2(355.09,208.51) v2(355.33,204.74) v2(355.33,204.1) v2(355.82,225.87) v2(355.89,224.1) v2(355.96,204.74) v2(355.96,204.1) v2(356.48,202.56) v2(356.98,226.45) v2(356.98,225.37) v2(357.11,210.5) v2(357.11,207.47) v2(357.13,204.66) v2(357.21,153.15) v2(357.48,205.8) v2(357.74,226.45) v2(358.25,186.07) v2(358.63,158.08) v2(359.01,209.94) v2(359.01,208.04) v2(359.01,205.88) v2(359.39,186.83) v2(360.28,210.58) v2(360.28,208.67) v2(360.28,206.51) v2(360.41,186.07) v2(361.42,186.83) v2(361.55,209.82) v2(361.55,207.91) v2(361.55,205.75) v2(362.69,187.46) v2(362.69,185.94) v2(362.95,210.58) v2(362.95,208.67) v2(362.95,206.51) v2(363.96,186.7) v2(364.22,209.82) v2(364.22,207.91) v2(364.22,205.75) v2(365.36,187.46) v2(365.36,185.94) v2(365.74,210.58) v2(365.74,208.67) v2(365.74,206.51) v2(366.76,186.7) v2(367.01,209.82) v2(367.01,207.91) v2(367.01,205.75) v2(367.95,210.58) v2(367.95,208.67) v2(367.95,206.51) v2(367.98,187.41) v2(368.28,185.94) v3(20.3,174.51) v3(86.83,171.97) v3(89.14,176.34) v3(109.74,172.61) v3(117.48,79.92) v3(119.54,79.95) v3(135.31,150.38) v3(136.23,151.45) v3(141.26,164.12) v3(147,96.74) v3(156.8,11.9) v3(177.48,138.59) v3(191.98,13.88) v3(195.94,94.45) v3(247.63,169.76) v3(286.08,51.07) v3(301.99,169) v3(301.99,158.18) v3(302.45,167.75) v3(302.75,157.49) v3(318.24,197.29) v3(341.94,170.01) v3(346.79,203.7) v3(358.43,208.88) v4(78.66,181.58) v4(80.83,180.06) v4(81.25,178.42) v4(81.5,180.07) v4(81.92,178.43) v4(82.66,178.43) v4(83.33,178.45) v4(84.7,180.06) v4(85.38,180.07) v4(86.05,180.07) v4(86.72,180.09) v4(89.39,174.13) v4(89.39,173.37) v4(90.28,174.13) v4(90.28,173.37) v4(91.04,174.13) v4(91.04,173.37) v4(91.8,174.13) v4(91.8,173.37) v4(92.57,174.13) v4(92.57,173.37) v4(95.11,174.13) v4(95.11,173.37) v4(95.87,174.13) v4(95.87,173.37) v4(96.63,174.13) v4(96.63,173.37) v4(97.39,174.13) v4(97.39,173.37) v4(98.15,174.13) v4(98.15,173.37) v4(101.33,176.86) v4(101.33,176.17) v4(101.33,175.13) v4(101.33,174.45) v4(101.33,173.35) v4(101.33,172.67) v4(103.42,188.4) v4(103.44,187.74) v4(103.44,187.06) v4(103.44,186.42) v4(109.33,187.97) v4(109.33,187.21) v4(109.47,171.58) v4(110.09,187.97) v4(110.09,187.21) v4(110.17,171.58) v4(110.85,187.97) v4(110.85,187.21) v4(111.74,187.97) v4(111.74,187.21) v4(111.74,171.59) v4(112.38,171.59) v4(112.63,187.97) v4(112.63,187.21) v4(113.14,171.59) v4(113.9,171.59) v4(114.79,171.59) v4(115.46,171.58) v4(116.78,171.86) v4(119.36,155.21) v4(119.36,154.44) v4(120.12,155.21) v4(120.12,154.44) v4(120.89,155.21) v4(120.89,154.44) v4(124.32,161.94) v4(124.95,149.62) v4(124.95,148.86) v4(124.95,147.97) v4(125.08,161.94) v4(125.2,9.92) v4(125.71,149.62) v4(125.71,148.86) v4(125.71,147.97) v4(125.84,161.94) v4(125.84,161.18) v4(125.84,9.92) v4(126.47,149.62) v4(126.47,148.86) v4(126.47,147.97) v4(126.47,9.92) v4(126.6,161.18) v4(129.01,149.62) v4(129.01,148.09) v4(129.4,148.86) v4(129.9,149.62) v4(129.9,148.09) v4(129.9,133.74) v4(130.54,148.86) v4(131.05,149.62) v4(131.05,148.09) v4(131.43,133.74) v4(131.55,148.86) v4(132.06,149.62) v4(132.19,148.09) v4(132.57,148.86) v4(133.08,149.62) v4(133.21,148.09) v4(133.71,148.86) v4(134.09,149.62) v4(134.22,148.09) v4(134.73,148.86) v4(134.87,9.11) v4(135.24,149.62) v4(135.24,148.09) v4(135.24,10.81) v4(135.24,10.17) v4(135.45,9.44) v4(135.45,8.8) v4(135.87,148.86) v4(136,10.81) v4(136,10.17) v4(136.11,9.44) v4(136.11,8.8) v4(136.38,149.62) v4(136.38,148.09) v4(136.76,10.81) v4(136.76,10.17) v4(136.76,9.41) v4(136.76,8.78) v4(136.76,8.01) v4(136.76,7.25) v4(137.02,148.86) v4(137.37,8.47) v4(137.4,179.84) v4(137.4,7.82) v4(137.4,7.16) v4(137.52,149.62) v4(137.65,148.09) v4(138.16,148.86) v4(138.67,149.62) v4(138.79,148.09) v4(138.92,179.59) v4(138.92,178.19) v4(139.17,133.62) v4(139.43,148.86) v4(140.06,148.09) v4(142.48,151.52) v4(142.48,150.76) v4(142.48,149.87) v4(142.48,149.11) v4(142.48,148.22) v4(143.24,15.18) v4(144.17,15.06) v4(144.51,149.62) v4(144.51,148.73) v4(144.51,147.84) v4(145.14,149.62) v4(145.14,148.73) v4(145.14,147.84) v4(147.58,12.71) v4(148.43,12.74) v4(149.21,148.09) v4(149.72,148.86) v4(149.84,152.41) v4(149.84,151.52) v4(149.84,150.63) v4(150.1,149.62) v4(150.35,167.53) v4(150.35,166.13) v4(150.35,148.09) v4(150.35,6.74) v4(150.6,6.11) v4(150.86,148.86) v4(150.99,149.62) v4(151.02,6.67) v4(151.11,150.63) v4(151.49,148.09) v4(151.62,167.53) v4(151.75,166.13) v4(151.87,149.62) v4(152,148.86) v4(152.14,168.92) v4(152.13,150.63) v4(152.51,148.09) v4(152.64,149.62) v4(152.89,150.63) v4(153.02,148.86) v4(153.14,168.92) v4(153.14,167.53) v4(153.14,166.13) v4(153.53,148.09) v4(153.65,149.62) v4(155.81,148.48) v4(156.19,147.84) v4(156.57,148.48) v4(156.83,12.97) v4(156.95,149.24) v4(156.95,147.84) v4(157.34,148.48) v4(157.46,12.97) v4(157.63,149.21) v4(157.72,147.84) v4(158.1,148.48) v4(158.22,12.97) v4(158.3,149.19) v4(158.48,147.84) v4(158.73,9.41) v4(158.99,12.97) v4(159.49,9.41) v4(159.49,8.65) v4(159.75,12.97) v4(160.26,9.41) v4(160.26,8.65) v4(160.38,12.97) v4(160.89,8.65) v4(161.02,9.41) v4(161.53,8.34) v4(162.03,174.38) v4(162.8,174.38) v4(162.8,172.86) v4(163.56,174.38) v4(163.56,172.86) v4(165.82,12.67) v4(165.82,11.99) v4(166.58,12.67) v4(166.58,11.99) v4(170.11,9.5) v4(170.84,9.49) v4(171.6,9.47) v4(172.32,9.5) v4(180.78,12.34) v4(180.78,11.71) v4(181.54,12.34) v4(181.54,11.71) v4(186.2,95.96) v4(186.2,94.63) v4(186.33,92.72) v4(187.98,92.98) v4(187.98,91.07) v4(189.14,13.09) v4(189.86,13.77) v4(189.81,12.97) v4(190.44,12.93) v4(190.51,14.36) v4(190.58,13.59) v4(190.99,14.88) v4(191.18,12.85) v4(191.63,15.25) v4(191.63,14.62) v4(191.82,15.86) v4(191.83,12.78) v4(192.32,15.23) v4(192.46,15.95) v4(192.39,14.59) v4(192.53,12.75) v4(193.01,15.25) v4(193.02,14.62) v4(193.12,15.91) v4(193.18,12.71) v4(193.66,15.13) v4(193.76,15.86) v4(194.04,96.34) v4(194.67,96.34) v4(197.19,94.25) v4(197.21,93.56) v4(198.2,94.27) v4(198.23,93.54) v4(210.17,14.11) v4(210.1,13.46) v4(210.8,14.29) v4(210.8,13.6) v4(216.01,10.05) v4(216.01,9.28) v4(216.77,10.05) v4(216.77,9.28) v4(225.03,5.73) v4(225.03,5.09) v4(225.79,5.73) v4(225.79,5.09) v4(226.68,6.36) v4(226.68,5.73) v4(227.44,6.36) v4(227.44,5.73) v4(228.2,6.36) v4(234.23,104.03) v4(234.3,105.68) v4(234.3,104.79) v4(237.79,100.22) v4(238.43,100.22) v4(238.62,9.03) v4(238.62,8.27) v4(239.06,100.22) v4(239.7,100.22) v4(239.7,9.03) v4(239.7,8.27) v4(240.33,100.22) v4(272.65,167.27) v4(272.65,166.64) v4(272.65,166) v4(273.29,167.27) v4(273.29,166.64) v4(273.29,166) v4(274.51,150.76) v4(274.51,150.1) v4(274.51,149.47) v4(275.1,150.49) v4(275.1,149.86) v4(275.1,149.22) v4(282.05,133.68) v4(281.99,132.92) v4(283.32,133.74) v4(283.32,132.98) v4(285.35,115.96) v4(285.42,113.93) v4(285.56,112.08) v4(286.62,136.35) v4(286.61,134.35) v4(287.26,136.35) v4(287.32,134.3) v4(287.45,115.96) v4(287.45,113.93) v4(287.45,112.04) v4(289.49,115.96) v4(289.49,113.93) v4(289.49,112.13) v4(300.96,170.56) v4(300.97,169.85) v4(300.88,162.75) v4(300.88,161.99) v4(301.14,161.29) v4(301.11,152.27) v4(301.11,151.51) v4(301.1,150.76) v4(301.1,150) v4(301.1,149.24) v4(301.2,166.47) v4(301.21,165.73) v4(301.21,164.97) v4(301.35,156.48) v4(301.35,155.71) v4(301.48,154.44) v4(301.48,153.68) v4(301.65,162.75) v4(301.61,161.94) v4(301.72,170.56) v4(301.73,169.85) v4(301.81,152.25) v4(301.81,151.51) v4(301.86,150.76) v4(301.86,150) v4(301.95,166.45) v4(301.98,165.73) v4(301.98,164.97) v4(301.9,161.29) v4(302.12,156.48) v4(302.12,155.71) v4(302.24,162.19) v4(302.24,154.44) v4(302.24,153.68) v4(302.37,162.83) v4(302.5,170.57) v4(302.5,169.81) v4(302.52,151.12) v4(302.5,150.37) v4(302.88,156.48) v4(302.88,155.71) v4(303.18,170.57) v4(303.21,169.79) v4(305.9,163.72) v4(306.43,160.87) v4(306.56,163.72)
