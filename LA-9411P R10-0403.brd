# Allegro board LA-9411P R10-0403.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
SNUB_1.05V: length 1.5
  BOTTOM w0.102: PC309.1 v1(227.39,1.93)
SNUB_1.5VSP: length 1.7
  TOP w0.102: PC407.1 241.97,109.37 v1(242.41,109.82)
SNUB_1.8VSP: length 1.7
  TOP w0.102: 280.53,139.78 279.88,139.78 279.54,140.12 v1(279.01,140.12)
SNUB_1.35V: length 2.2
  BOTTOM w0.102: v1(195.03,15.56) 194.1,14.63 194.1,13.73
SNUB_3V: length 1.7
  TOP w0.102: PR109.2 v1(130.72,7.57)
SNUB_5V: length 1.6
  TOP w0.102: PC119.1 v1(155.57,8.84)
SNUB_CHARGER: length 1.5
  BOTTOM w0.102: PC715.2 v1(97.67,170.65)
SNUB_GPU_P1: length 0.8
  BOTTOM w0.102: v1(291.94,145.71) 292.02,145.78 292.73,145.78
SNUB_GPU_P2: length 1.7
  BOTTOM w0.102: PC607.1 298.75,172.35 v1(299.21,172.81)
SOFT_START_GC: length 30.7
  TOP w0.254: v4(150.17,163.23) 150.25,163.31 PU800.2
  IN3 w0.254: v2(133.47,168.78) 134.9,168.78 135.31,169.2 143.39,169.2 143.58,169.39 148.52,169.39 149.27,170.14 v2(149.27,171.3)
  IN4 w0.254: v4(150.17,163.23) 150.17,164.64 149.49,165.33 149.49,171.08 v2(149.27,171.3)
  BOTTOM w0.254: v2(133.47,168.78) 133.02,169.24 v1(132.7,169.24) 131.16,169.24 PR23.2
SP_TPM_LPC_EN: length 136.5
  TOP w0.102: v2(266.12,48.74) 266.19,48.68 U46.B56 ; v2(301,127.46) 300.99,127.44 R1669.1 ; v1(269.71,39.5) v2(269.17,39.5) 269.06,39.5 268.22,40.34 268.22,41.07 268.12,41.17 268.09,41.17 R772.2
  IN1 w0.102: v2(271.28,53.63) 271.28,53.59 270.7,53 270.7,47.18 271.08,46.8 271.08,43.64 271.32,43.4 271.32,41.66 270.9,41.24 270.12,41.24 269.67,40.79 269.67,39.89 269.27,39.5 v2(269.17,39.5)
  IN2 w0.127: v2(301,127.46) 300.1,128.36 295.41,128.36 294.68,127.63 291.77,127.63 290.16,129.25 v2(288.7,129.25) ; v2(278.35,56.71) 277.95,56.3 276.67,56.3 276.11,55.74 276.11,54.71 275.71,54.32 274.17,54.32 273.06,53.21 271.82,53.21 271.4,53.63 v2(271.28,53.63)
  IN3 w0.127: v2(271.28,53.63) 270.06,53.63 269.35,52.92 269.35,52.41 268.51,51.57 267.7,51.57 267.09,50.96 267.09,50.53 266.51,49.95 266.51,49.01 266.24,48.74 v2(266.12,48.74)
  IN4 w0.102: v2(278.35,56.71) 278.76,56.71 280.23,58.18 280.23,62.79 279.6,63.42 279.6,65.22 277.73,67.09 277.73,91.99 281.87,96.14 281.87,98.05 283.1,99.28 283.16,99.28 286.57,102.68 287.47,102.68 288.3,103.5 288.3,104.41 290.36,106.47 290.36,108.55 290.66,108.85 291.64,108.85 292.49,109.7 292.49,117.41 290.56,119.34 289.36,119.34 288.68,120.02 288.68,121.79 289.17,122.29 289.17,128.33 288.7,128.8 v2(288.7,129.25)
SP_TPM_LPC_EN_R: length 4.9
  TOP w0.102: R1667.2 R1670.2 R1669.2 300.75,128.77 v1(300.75,129.6) U39.28
SPI_CLK32: length 12.8
  TOP w0.102: U53.6 199.88,38.16 200.06,38.34 200.42,38.34 200.66,38.58 v1(201.85,38.58) 202.08,38.58 202.21,38.46 202.21,36.82 202.33,36.69 202.99,36.69 203.12,36.82 203.12,37.38 203.02,37.49 202.7,37.49 202.6,37.59 202.6,37.79 202.7,37.89 203.02,37.89 203.12,37.99 203.12,38.3 202.99,38.43 202.74,38.43 202.5,38.67 202.5,39.9 RE2.1 202.12,41.25 RPH7.2
SPI_CLK64: length 15
  TOP w0.102: R899.1 RE1.1 195.04,40.07 195.17,39.94 195.17,39.8 195.44,39.53 195.44,39.44 v3(196.04,38.85) 196.24,38.85 196.36,38.72 196.36,35.62 196.52,35.47 196.52,34.9 196.39,34.77 195.56,34.77 195.44,34.9 195.44,38.3 195.31,38.43 194.66,38.43 194.41,38.18 193.66,38.18 193.53,38.05 193.53,37.29
SPI_DIN32: length 13.2
  TOP w0.102: R895.2 198.74,27.32 198.42,27.63 196.32,27.63 196.11,27.85 v1(196.11,28.44) 196.11,31.76 196.24,31.89 196.72,31.89 196.85,31.76 196.85,29.15 196.97,29.03 198.48,29.03 198.61,29.15 U53.2
SPI_DIN64: length 13.1
  TOP w0.102: U52.2 192.26,29.22 192.06,29.03 190.55,29.03 190.36,29.22 190.36,31.95 190.23,32.08 189.82,32.08 189.7,31.95 189.7,27.98 v3(189.77,27.9) 190.04,27.63 191.64,27.63 R8.2
SPI_DO32: length 14.6
  TOP w0.102: RPH7.3 202.62,41.42 203.01,41.03 204.96,41.03 205.8,40.2 205.8,38.58 205.28,38.06 204.25,38.06 204.22,38.04 v1(203.55,38.04) 203.48,37.96 203.48,36.46 203.35,36.33 201.98,36.33 201.85,36.46 201.85,38 201.63,38.21 201.34,38.21 201.15,38.02 U53.5
SPI_DO64: length 12.9
  TOP w0.102: U52.5 194.8,34.28 194.93,34.15 196.74,34.15 196.95,34.35 196.95,35.67 196.72,35.9 v3(196.72,40.49) 196.57,40.64 196.26,40.64 R901.1
SPI_PCH_CLK: length 27.9
  TOP w0.102: RPH7.7 202.12,43.52 201.89,43.75 201.29,43.75 200.56,44.48 v1(199.65,44.48) 199.37,44.48 199.08,44.19 199.08,43.63 v2(199.11,43.6) ; R899.2 193.4,41.27 v2(192.39,42.29)
  IN1 w0.102: v2(206.48,38.75) 206.48,39.44 203.95,41.97 202.07,41.97 201.9,42.14 201.52,42.14 200.31,43.34 199.36,43.34 v2(199.11,43.6)
  BOTTOM w0.102: v2(192.39,42.29) 193.16,41.52 196.45,41.52 198.26,43.32 198.36,43.32 198.64,43.6 v2(199.11,43.6) ; RH181.1 206.58,41.81 206.72,41.67 206.72,40.44 JSPI1.7 206.68,38.94 v2(206.48,38.75)
SPI_PCH_CS0#: length 32.6
  TOP w0.102: v2(190.86,25.6) R7.1
  BOTTOM w0.102: v2(190.86,25.6) 191.63,24.84 196.68,24.84 197.85,26.01 198.66,26.01 200.03,24.64 v1(201.3,24.64) 202.15,24.64 202.64,25.12 202.64,35.57 205.84,38.77 205.84,39.53 205.68,39.69 JSPI1.9 205.68,42.24 RH182.1
SPI_PCH_CS0#_R: length 12.8
  TOP w0.102: R7.2 189.97,27.14 189.34,27.77 v3(189.34,32.25) 189.34,32.46 189.47,32.59 191.37,32.59 191.49,32.46 191.49,32.29 191.37,32.16 190.86,32.16 190.74,32.04 190.74,31.87 190.86,31.75 191.4,31.75 191.5,31.65 191.5,31.45 191.4,31.35 191.09,31.35 190.99,31.25 U52.1
SPI_PCH_CS1#: length 33.1
  TOP w0.102: R936.1 197.47,26.11 v1(196.27,24.91) 195.21,23.85 v2(194.72,23.85)
  BOTTOM w0.102: RH177.1 209.63,41.15 209.68,41.1 JSPI1.1 209.68,39.71 203.41,33.44 203.41,24.75 202.51,23.85 v2(194.72,23.85)
SPI_PCH_CS1#_R: length 13.1
  TOP w0.102: R936.2 196.97,27.14 196.83,27 196.83,26.36 196.71,26.24 v1(196.46,26.24) 196.26,26.24 196.13,26.36 196.13,27.32 195.75,27.7 195.75,32.12 195.88,32.25 197.91,32.25 198.04,32.12 198.04,31.19 197.91,31.06 197.47,31.06 197.34,30.94 U53.1
SPI_PCH_DIN: length 34.1
  TOP w0.102: R895.1 198.59,26.07 198.56,26.07 v2(197.99,25.5) ; v2(193.09,24.22) v1(192.65,24.65) 192.13,25.17 R8.1
  BOTTOM w0.102: v2(193.09,24.22) 193.26,24.4 196.88,24.4 v2(197.99,25.5) 199.25,24.24 202.33,24.24 203.02,24.93 203.02,33.95 207.22,38.14 207.22,39.17 207.68,39.64 JSPI1.5 207.68,42.27 RH179.1
SPI_PCH_DO: length 21.9
  TOP w0.102: R901.2 195.69,41.66 199,44.97 200.58,44.97 201.43,44.12 202.04,44.12 202.62,43.54 RPH7.6 202.62,42.5 202.74,42.38 204.95,42.38 206.32,41 v3(206.32,40.03) 207.33,39.02 v2(208.39,39.02)
  BOTTOM w0.102: v2(208.39,39.02) 208.68,39.31 JSPI1.3 208.68,42.29 RH178.1
SPI_PCH_DO2: length 30.2
  TOP w0.102: v2(199.74,25.59) 199.75,25.6 R3667.1 ; R9.1 193.4,25.78 v2(193.05,25.43)
  BOTTOM w0.102: RH183.1 204.55,41.77 204.68,41.64 JSPI1.11 204.68,38.77 202.27,36.36 v1(202.27,26.35) 202.27,25.39 201.91,25.03 200.3,25.03 v2(199.74,25.59) 198.89,26.44 197.72,26.44 196.48,25.2 193.28,25.2 v2(193.05,25.43)
SPI_PCH_DO2_32: length 15.1
  TOP w0.102: R3665.2 RH186.1 R3667.2 199.75,27.51 200.01,27.76 200.97,27.76 201.1,27.89 201.1,28.14 200.97,28.27 200.83,28.27 200.67,28.44 200.67,28.93 200.57,29.03 200.36,29.03 200.26,28.93 v1(200.26,28.44) 200.1,28.27 199.75,28.27 199.47,27.99 196.59,27.99 196.46,28.12 196.46,28.54 196.59,28.67 199.27,28.67 199.88,29.29 U53.3
SPI_PCH_DO2_64: length 15
  TOP w0.102: 193.53,30.04 193.53,29.1 193.66,28.97 194.55,28.97 194.67,28.84 194.67,27.79 194.55,27.66 194.23,27.66 194.1,27.79 194.1,28.21 193.98,28.33 193.1,28.33 v3(192.98,28.45) 192.76,28.67 190.23,28.67 190.1,28.54 190.1,28.14 190.23,28.02 192.53,28.02 192.91,27.63 193.28,27.63 193.4,27.51 R9.2 R3664.2 RH180.1
SPI_PCH_DO3: length 23.5
  TOP w0.102: R3669.2 v2(192.39,41.71) ; v2(199.12,42.95) 199.56,43.4 201.47,43.4 201.62,43.24 RPH7.8
  IN1 w0.102: v2(202.9,38.84) 201.19,40.55 201.19,41.83 200.8,42.22 200.68,42.22 200.06,41.61 199.89,41.61 199.77,41.72 199.77,41.89 200.37,42.49 200.37,42.66 200.12,42.9 199.17,42.9 v2(199.12,42.95)
  BOTTOM w0.102: v2(199.12,42.95) 199.07,42.9 198.41,42.9 v1(197.54,42.04) 196.67,41.16 192.93,41.16 v2(192.39,41.71) ; RH184.1 203.68,42.21 JSPI1.13 203.68,39.61 v2(202.9,38.84)
SPI_PCH_DO3_32: length 13.2
  TOP w0.102: RPH7.1 201.62,40.42 R3666.2 202.14,39.9 202.14,39.13 202,38.99 200.57,38.99 200.27,38.7 v1(199.39,38.7) 199.3,38.79 199.3,39.36 199.42,39.48 199.69,39.48 199.82,39.61 199.82,39.79 199.69,39.92 198.97,39.92 198.84,39.79 198.84,39.06 198.71,38.94 197.9,38.94 197.77,38.81 197.77,38.3 197.9,38.18 198.06,38.18 198.19,38.3 198.19,38.46 198.32,38.58 198.5,38.58 198.61,38.47 U53.7
SPI_PCH_DO3_64: length 13.8
  TOP w0.102: R3668.2 R3669.1 192.26,39.94 192.26,39.52 192.39,39.4 192.88,39.4 192.94,39.45 192.94,39.58 193,39.64 194.28,39.64 194.41,39.51 194.96,39.51 195.09,39.38 195.09,38.91 194.96,38.79 194.51,38.79 194.26,38.53 193.86,38.53 193.73,38.66 193.73,38.96 193.61,39.09 193.2,39.09 193.07,38.96 v3(193.07,38.93) 193.07,38.66 192.95,38.53 192.32,38.53 192.2,38.66 192.2,39.03 191.61,39.62 191.43,39.62 191.18,39.36 191.18,39.01 191.42,38.76 191.42,38.34 191.55,38.21 192.13,38.21 192.26,38.09 U52.7
SPI_WP#_SEL: length 115.7
  TOP w0.102: v2(195.75,25.6) 195.69,25.67 195.69,25.97 RH180.2 ; v2(200.77,25.6) RH186.2 ; v2(275.09,53.89) 274.59,54.39 U46.A12
  IN1 w0.102: v2(275.09,53.89) 274.54,53.34 274.28,53.34 273.23,52.29 273.23,48.51 272.74,48.02 272.74,46.82 273.9,45.67 273.9,43.03 273.11,42.24 273.11,41.36 272.68,40.93 v2(272.68,40.86)
  IN2 w0.127: v2(214.74,26.15) 214,26.89 201.43,26.89 RH186.2 v2(200.77,25.6)
  IN3 w0.127: v2(214.74,26.15) 214.55,25.96 214.55,24.87 217,22.42 221.92,22.42 224.98,19.36 224.98,18.08 226.13,16.93 248.41,16.93 263.18,31.7 263.18,36.55 263.43,36.8 265.36,36.8 267.64,39.08 269.93,39.08 271.18,40.32 272.07,40.32 272.6,40.86 v2(272.68,40.86)
  BOTTOM w0.102: v2(195.75,25.6) 197.05,26.9 199.47,26.9 v1(200.04,26.33) v2(200.77,25.6)
SPKR: length 347.2
  TOP w0.102: v2(186.71,72.01) v1(186.71,71.35) RH34.2 ; R1119.2 v2(329.88,169.56)
  IN3 w0.127: v2(329.88,169.56) 330.59,168.85 330.59,163.91 330.07,163.39 330.07,162.34 330.31,162.09 330.39,162.09 330.94,161.53 330.94,157.71 328.36,155.13 327.87,154.64 327.87,138.24 326.66,137.04 326.66,122.85 324.56,120.75 319.56,120.75 314.05,115.25 314.05,111.56 306.95,104.46 302.76,104.46 299.99,101.69 290.67,101.69 287.98,99 287.98,99 287.34,99 285.82,97.47 282.58,97.47 279,93.89 279,67.56 284.62,61.95 284.62,49.62 274.38,39.38 274.38,38.86 273.93,38.42 272.36,38.42 271.02,37.08 271.02,32.95 268.74,30.67 268.74,29.4 255.2,15.86 225.12,15.86 221.49,19.49 218.04,19.49 212.74,24.8 212.74,26.64 213.43,27.33 213.43,28.05 210.04,31.44 206.64,31.44 204.43,33.65 195.51,33.65 193.38,35.79 193.38,42.9 179.55,56.73 179.55,60.2 180.42,61.07 181.22,61.07 181.68,61.53 181.68,62.41 181.22,62.87 181.22,71.01 182.22,72.01 v2(186.71,72.01)
  IN4 w0.089: 195.71,69.46 195.74,69.48 197.11,69.48 198.65,71.03 198.93,71.03 199.35,71.44 200.12,71.44 200.31,71.24 200.62,71.24 200.78,71.4 v2(201.54,71.4)
  IN4 w0.102: v2(186.71,72.01) 186.82,71.9 191.22,71.9 194.07,69.05 195.31,69.05 195.71,69.46
  BOTTOM w0.089: v2(201.54,71.4) 201.64,71.29 UH1.AL10
SPKR_MUTE_LED#: length 386.2
  TOP w0.102: U46.A57 268.44,46.54 268.59,46.39 v2(268.59,45.29) ; v2(62.04,196.28) v1(58.91,196.28) R988.1
  IN3 w0.127: v2(268.59,45.29) 268.11,44.81 267.33,44.81 265.84,46.29 265.84,46.49 265.43,46.91 261.84,46.91 260,48.74 260,51.84 259.36,52.49 259.36,58.48 259.74,58.87 259.74,63.5 262.61,66.37 262.61,75.85 263.69,76.94 263.69,95.7 264.84,96.85 264.84,120.14 264.16,120.83 264.16,129.89 264.84,130.58 264.84,134.43 264.89,134.48 264.89,136.85 263.51,138.24 263.51,142.46 261.31,144.66 261.31,148.75 260.38,149.67 260.38,165.98 259.51,166.85 259.51,173.02 258.45,174.09 254.69,174.09 252.4,176.38 247.3,176.38 246.85,175.92 238.37,175.92 237.58,175.13 224.48,175.13 224.43,175.18 222.25,175.18 217.58,170.52 193.26,170.52 193.12,170.66 188.11,170.66 186.16,168.71 181.43,168.71 180.52,169.62 178.74,169.62 177.83,170.52 173.84,170.52 173,171.36 170.8,171.36 170.62,171.54 169.97,171.54 169.22,170.79 169.22,169.28 164.95,165.01 163.64,165.01 163.17,164.54 160.98,164.54 157.34,160.9 149.19,160.9 148.77,160.48 147.87,160.48 147.57,160.17 140.76,160.17 140.17,159.58 137.72,159.58 137.12,160.18 135.63,160.18 135.3,159.85 128.68,159.85 127.78,158.95 127.2,158.95 126.86,158.62 123.77,158.62 122.99,159.41 118.35,159.41 117.8,158.86 111.11,158.86 110.38,158.13 109.8,158.13 109.04,158.89 109.04,164.45 108.26,165.23 101.67,165.23 101.41,165.49 89.19,165.49 88.72,165.96 87.52,165.96 82.9,170.59 82.9,172.72 82.14,173.48 81.56,173.48 81.14,173.05 77.5,173.05 77.07,173.48 75.21,173.48 70.86,177.83 70.86,181.6 71.85,182.59 71.85,184.23 70.46,185.63 70.46,190.42 65.59,195.29 63.03,195.29 v2(62.04,196.28)
SRTCRST#: length 8.9
  TOP w0.102: v2(211.32,60.66) 211.33,60.65 212.45,60.65 213.06,60.05 v1(213.06,59.83) 213.06,58.64 ME1.2 211.52,57.1 CH6.2 210.59,56.49 RH42.2
  BOTTOM w0.089: 211.29,60.7 211.21,60.78 211.21,61.23 210.24,62.19 UH1.B9
  BOTTOM w0.102: 211.29,60.7 v2(211.32,60.66)
STSTART_DCBLOCK_GC: length 3.1
  TOP w0.254: PU800.16 155.4,168.53 155.47,168.45 v1(156.4,168.45) 157.34,168.45 PR811.1
SUS_ON: length 225.2
  TOP w0.102: v3(270.87,41.11) 270.87,41.19 270.46,41.6 PR210.1 R878.2 268.71,42.16 v2(268.56,42.31) ; v2(268.04,48.76) 268.19,48.62 U46.B60 ; R1607.1 171.92,161.26 172.66,160.52 v2(172.89,160.52)
  IN1 w0.102: v2(268.56,42.31) 268.56,42.95 267.03,44.49 267.03,46.53 268.04,47.55 v2(268.04,48.76)
  IN2 w0.127: v2(245.99,109.28) 246.5,108.78 248.33,108.78 249.54,107.57 253.78,107.57 253.97,107.76 257.21,107.76 257.54,107.43 v2(257.66,107.43)
  IN3 w0.127: v2(245.99,109.28) 245.59,108.88 245.59,107.85 244.5,106.76 244.5,103.91 242.38,101.8 233.72,101.8 231.06,104.47 228.46,104.47 227.82,103.82 223.09,103.82 217.64,109.27 195.56,109.27 194.37,110.46 184.66,110.46 182.76,112.36 182.76,115.02 184.24,116.49 184.24,119.69 182.62,121.31 182.62,139.84 182.24,140.22 181.3,140.22 181.03,140.48 181.03,142.08 181.45,142.5 181.45,143.58 180.66,144.37 179.88,144.37 177.3,146.96 177.3,149.58 174.85,152.03 174.85,158.56 172.89,160.51 v2(172.89,160.52)
  BOTTOM w0.102: v2(268.04,48.76) 267.03,47.75 267.03,46.62 266.45,46.04 266.01,46.04 265.72,46.34 265.72,46.68 264.82,47.59 264.82,49.19 264.8,49.2 264.8,49.45 264.5,49.75 263.84,49.75 263.52,50.08 263.52,51.66 262.44,52.74 262.44,53.9 262.12,54.22 261.56,54.22 261.13,54.65 261.13,55.11 259.85,56.38 259.85,58.42 260.1,58.66 260.1,63.61 260.46,63.97 260.46,74.18 258.66,75.98 258.66,78.34 257.67,79.33 257.67,80.79 257.12,81.34 257.12,106.16 257.53,106.57 257.53,107.3 v2(257.66,107.43)
SUS_STAT#/LPCPD#: length 186.6
  TOP w0.102: R1667.1 298.56,127.37 v2(299.09,126.83) 299.09,126.82 v1(299.59,126.33) ; v2(196.31,60.69) 196.31,60.08 196.63,59.76 RH73.2
  IN1 w0.089: 201.19,63.93 202.08,64.82 203.69,64.82 204.07,65.2 204.51,65.2 v2(204.7,65.39) ; 200.54,63.28 200.39,63.13 200.39,62.5
  IN1 w0.102: v2(196.31,60.69) 198.64,60.69 200.39,62.45 200.39,62.5 ; 200.54,63.28 201.19,63.93
  IN2 w0.127: v2(259.94,128.08) 260.37,128.51 271.15,128.51 272.6,127.06 274.24,127.06 275.78,128.6 282.28,128.6 282.62,128.26 284.15,128.26 284.6,128.71 290.33,128.71 291.67,127.38 294.79,127.38 294.95,127.55 298.38,127.55 v2(299.09,126.83)
  IN3 w0.089: 209.21,58.62 209.11,58.62 209.09,58.63 207.55,58.63 207.26,58.92 207.26,59.94 206.15,61.05 204.99,61.05 204.86,60.92 204.35,60.92 204.3,60.97 204.3,62.17 203.8,62.67 203.8,64.65 204.54,65.39 v2(204.7,65.39)
  IN3 w0.127: v2(259.94,128.08) 260.03,127.99 260.03,126.3 259.36,125.63 259.36,113.3 257.23,111.18 257.23,109.8 258.1,108.94 258.1,105.64 257.08,104.63 257.08,103.54 247.3,93.76 247.3,85.99 244.38,83.07 244.38,81.66 244.85,81.19 244.85,78.11 244.85,73.91 244.48,73.54 244.48,71.15 243.95,70.61 243.95,60.18 243.67,59.9 243.67,58.42 238.57,53.32 237.45,53.32 235.97,51.84 228.19,51.84 227.9,52.13 227.9,52.54 227.52,52.92 222.07,52.92 221.33,52.18 218.79,52.18 216.1,54.88 215.24,54.88 214.79,55.32 213.2,55.32 212.17,56.35 211.79,56.35 209.53,58.62 209.21,58.62
  BOTTOM w0.089: 204.68,66.07 204.68,65.4 v2(204.7,65.39)
SUSACK#: length 85
  TOP w0.102: v1(204.17,52.51) 203.86,52.83 RH101.1 203.98,53.9 v2(204.91,53.9) ; v2(269.3,45.84) 269.31,45.84 268.82,46.32 268.82,46.61 268.94,46.73 U46.A58
  IN2 w0.127: v2(207.18,46.46) 209.27,44.37 212.16,44.37 216.26,40.27 229.39,40.27 233.05,43.94 233.05,47.17 234.78,48.89 239.56,48.89 241.33,47.13 243.17,47.13 243.86,47.83 245.27,47.83 245.8,47.29 255.94,47.29 257.13,46.1 261.34,46.1 261.79,45.64 263.41,45.64 263.46,45.69 264.98,45.69 265.03,45.64 268.35,45.64 268.41,45.71 269.17,45.71 v2(269.3,45.84)
  IN3 w0.127: v2(204.91,53.9) 204.53,53.52 204.53,51.28 206.48,49.33 206.48,48.49 207.03,47.94 207.03,46.61 v2(207.18,46.46)
SUSACK#_R: length 14.8
  TOP w0.102: RH101.2 203.22,54.72 RH91.2 202.42,55.23 201.91,54.72 v1(201.33,54.72) 201.02,55.03 201.02,55.49 v2(201.12,55.59)
  IN4 w0.089: v2(205.12,64.45) 204.52,63.85 204.52,62.36 204.11,61.95 204.11,61.23 204.28,61.07 204.28,60.9
  IN4 w0.102: v2(201.12,55.59) 201.87,56.34 201.87,57.16 202.57,57.86 202.57,58.29 204.28,59.99 204.28,60.9
  BOTTOM w0.089: v2(205.12,64.45) 204.95,64.62 UH1.R6
SUSCLK: length 1.2
  TOP w0.089: v2(204.05,66.13) 204.05,65.57 T68.1
  BOTTOM w0.089: v2(204.05,66.13) 203.84,66.34 UH1.Y6
SW1: length 4.1
  IN1 w0.762: 154.97,4.8 155.82,3.95 158.73,3.95
  vias: v1(162.03,3.57) v4(153.72,5.44) v4(154.35,5.44) v4(156.45,3.06) v4(157.21,3.06) v4(157.97,3.06) v4(158.75,3.05) v4(159.49,3.82) v4(159.49,3.06) v4(160.26,3.82) v4(160.26,3.06) v4(161.02,3.82) v4(161.02,3.06) v4(161.78,3.06)
SW2: length 8.4
  IN1 w1.016: 139.94,1.98 142.79,1.98 146.16,5.35 146.92,5.35
  vias: v1(134.6,2.17) v4(132.91,3.82) v4(132.9,3.09) v4(133.56,3.84) v4(133.55,3.1) v4(134.23,3.8) v4(134.22,3.06) v4(134.87,3.07) v4(134.88,3.81) v4(136.51,4.33) v4(136.89,3.7) v4(137.14,4.33) v4(138.16,3.7) v4(138.16,2.93) v4(138.79,3.7) v4(138.86,2.93) v4(138.92,2.3) v4(147.3,6.24) v4(147.94,6.24)
SW_1.35V: length 13.8
  IN1 w1.016: 198.99,6.11 198.99,10.93 202.17,14.11 205.09,14.11 206.1,15.13 206.23,15.13
  vias: v1(197.98,3.19) v4(189.59,4.97) v4(189.59,4.2) v4(189.59,3.5) v4(190.36,4.97) v4(190.36,4.2) v4(190.36,3.5) v4(191.12,4.97) v4(191.12,4.2) v4(191.12,3.5) v4(191.88,4.97) v4(191.88,4.2) v4(191.88,3.5) v4(192.64,4.97) v4(192.64,4.2) v4(192.64,3.5) v4(193.4,4.97) v4(193.4,4.2) v4(193.42,3.49) v4(194.17,4.97) v4(194.17,4.2) v4(194.18,3.49) v4(194.95,4.94) v4(194.95,4.2) v4(194.94,3.49) v4(195.72,4.94) v4(195.72,4.2) v4(195.7,3.49) v4(196.48,4.94) v4(196.46,3.49) v4(196.5,4.24) v4(198.09,5) v4(198.85,5) v4(207.37,15.13) v4(208.01,15.13)
SW_+1.05VSP: length 4.2
  IN1 w1.016: 234.93,10.05 239.12,10.05
  vias: v1(233.75,3.48) v4(233.15,9.66) v4(233.15,8.78) v4(233.15,7.89) v4(233.15,6.11) v4(233.15,5.22) v4(233.92,9.66) v4(233.92,8.78) v4(233.92,7.89) v4(233.92,6.11) v4(233.92,5.22) v4(239.12,10.93) v4(239.44,11.51)
SW_LAN_TX0+: length 6.3
  TOP w0.089: T156.1 297.42,208.55 297.92,208.04 297.92,206.77 v4(298.41,206.29) 298.69,206.01 298.69,204.42 298.62,204.36 U32.38
SW_LAN_TX0-: length 6.4
  TOP w0.089: T156.2 298.69,208.55 298.21,208.07 v4(298.21,207.64) 298.21,206.9 298.98,206.13 298.98,204.54 299.12,204.39 U32.37
SW_LAN_TX1+: length 7
  TOP w0.089: U32.34 300.62,204.48 300.72,204.58 300.72,205.57 301.23,206.07 v4(301.75,206.59) 303,207.85 303,208.17 302.5,208.67 T156.5
SW_LAN_TX1-: length 7
  TOP w0.089: U32.33 301.12,204.56 301.01,204.67 301.01,205.44 301.52,205.95 302.9,207.34 v4(302.9,207.34) 302.91,207.34 303.3,207.73 303.3,208.14 303.77,208.61 T156.6
SW_LAN_TX2+: length 7
  TOP w0.089: U32.29 303.12,204.36 303.26,204.5 303.26,205.63 v4(303.79,206.16) 305.49,207.86 305.49,208.05 305.04,208.51 T156.7
SW_LAN_TX2-: length 7
  TOP w0.089: T156.8 306.31,208.57 305.79,208.05 305.79,207.74 v4(305.29,207.24) 303.55,205.5 303.55,204.47 303.62,204.4 U32.28
SW_LAN_TX3+: length 10
  TOP w0.089: 310.12,209.58 310.12,208.56 310.56,208.11 310.56,207.87 309.84,207.15 v4(307.25,207.15) 306.75,207.15 306.25,206.65 305.57,205.98 305.46,205.86 305.22,205.62 305.22,204.42 305.12,204.33 U32.25
SW_LAN_TX3-: length 10.1
  TOP w0.089: T156.12 311.39,208.67 310.85,208.14 310.85,207.75 309.96,206.86 v4(309.34,206.86) 306.87,206.86 306.54,206.53 305.7,205.68 305.58,205.56 305.51,205.5 305.51,204.46 305.62,204.34 U32.24
SYS_LED_MASK#: length 255.3
  TOP w0.102: v2(264.6,42.25) 264.6,42.77 265.11,43.28 265.11,44.02 R775.2 ; v2(318.07,206.64) 317.65,206.22 316.81,206.22 315.96,207.07 311.92,207.07 v2(311.83,206.98) 311.79,206.95 Q325.5 Q325.2 ; v2(264.35,50.41) 264.35,50.35 264.13,50.14 U46.B48 ; v2(328.02,214.9) 327.87,214.9 326.09,213.12 322.33,213.12 320.9,211.68 319.29,211.68 v2(318.93,211.33)
  IN1 w0.102: v2(264.35,50.41) 264.35,50.18 264.79,49.73 264.79,46.24 264.28,45.73 264.28,43.55 264.65,43.18 264.65,42.3 v2(264.6,42.25)
  IN2 w0.127: v2(302.65,136.18) 302.22,136.61 301.25,136.61 300.17,135.53 294.08,135.53 293.49,134.95 292.85,134.95 292.57,135.23 289.85,135.23 286.59,131.97 285.93,131.97 285.46,131.97 285.11,131.62 282.55,131.62 282.25,131.33 281.16,131.33 280.37,132.12 279.95,132.12 276.58,132.12 v2(276.47,132.22)
  IN3 w0.127: v2(302.65,136.18) 302.92,136.45 303.38,136.45 307.92,140.99 307.92,141.63 308.95,142.66 312.22,142.66 315.82,146.26 315.82,147.94 316.8,148.92 316.8,154.74 317.13,155.07 317.13,156.31 316.28,157.16 316.28,165.69 314.94,167.03 314.94,169.68 314.96,169.69 314.96,170.04 314.27,170.72 314.27,170.9 313.99,171.18 313.39,171.18 309.82,174.74 309.82,175.42 309.08,176.17 309.08,181.38 307.73,182.73 307.73,185.48 308.66,186.41 308.66,191.5 v2(307.03,193.13) ; v2(271.98,69.47) 270.84,68.32 270.84,63.35 270.49,63.01 270.49,57.42 269.95,56.87 269.95,55.36 269.72,55.13 266.57,55.13 265.83,54.39 265.83,51.1 265.43,50.7 264.81,50.7 264.53,50.42 264.36,50.42 v2(264.35,50.41)
  IN4 w0.102: v2(307.03,193.13) 306.48,193.67 306.48,194.86 306.23,195.11 306.23,197.52 305.72,198.03 305.72,201.28 308.54,204.1 308.95,204.1 v2(311.83,206.98) ; v2(318.07,206.64) 318.93,207.51 v2(318.93,211.33) ; v2(271.98,69.47) 271.8,69.65 271.8,71.92 272.57,72.7 272.57,74.96 270.99,76.55 270.99,90.81 272.94,92.76 272.94,93.67 275.66,96.39 v2(275.9,96.39)
  BOTTOM w0.102: U58.1 v2(318.93,211.33) ; v2(311.83,206.98) 311.83,205.94 311.22,205.33 Q326.2 ; 328.72,214.9 v2(328.02,214.9) ; v2(275.9,96.39) 275.4,96.39 274.48,97.31 v1(274.48,101.99) 274.48,105.41 272.99,106.9 272.3,107.6 272.3,117.42 272.77,117.89 272.77,123.02 275.18,125.44 275.18,128.09 276.84,129.75 276.84,131.85 v2(276.47,132.22)
SYS_PWROK: length 246.5
  TOP w0.102: v2(115.27,115.63) 115.22,115.58 RC24.1 ; v2(195.4,43.33) 194.79,43.94 194.28,43.94 191.98,46.24 v1(191.98,48.65) 191.98,50.09 v2(192.02,50.13) 191.98,50.16 191.98,50.91 192.88,51.82 192.88,52.79 194.27,54.18 194.27,55.16 194.77,55.65 194.77,56.09 195.33,56.65 195.97,56.65 196.55,57.23 196.55,57.66 RH102.1 ; U46.B57 266.69,48.3 266.58,48.4 266.58,48.94 v2(267.04,49.4)
  IN2 w0.127: v2(267.04,49.4) 266.62,48.98 266.62,48.64 266.27,48.29 264.16,48.29 262.63,49.82 260.42,49.82 259.92,49.33 258.25,49.33 257.22,50.36 250.78,50.36 250.13,49.71 247.61,49.71 246.62,50.7 244.54,50.7 243.69,51.55 224.01,51.55 222.66,50.2 221.94,50.2 220.82,51.32 216.41,51.32 v2(214.56,49.46) 214.35,49.67 213.6,49.67 211.56,47.64 210.7,47.64 209.63,46.57 208.77,46.57 208.47,46.88 206.6,46.88 206.21,46.48 198.55,46.48 v2(195.4,43.33) ; v2(192.02,50.13) 125.96,50.13 120.26,55.82 120.26,64.83 118.8,66.29 118.8,80.3 118.14,80.97 118.14,84.72 117.12,85.74 113.65,85.74 113.08,86.3 113.08,113.36 115.27,115.54 v2(115.27,115.63)
  BOTTOM w0.102: v2(214.56,49.46) 214.51,49.51 214.51,49.82 213.83,50.51 213.23,50.51 213,50.73 213,50.82 212.86,50.96 212.86,51.63 212.52,51.97 212.52,52.25 211.62,53.14 RH85.2
SYS_PWROK_R: length 14.4
  TOP w0.089: v2(200.38,65.86) 200.38,65.65 202.24,63.79 v3(202.24,63.72) 202.24,63.08 202.1,62.94
  TOP w0.102: 202.1,62.94 202.1,62.85 200.96,61.71 200.42,61.71 200.09,61.38 199.4,61.38 198.68,60.66 198.68,59.95 197.42,58.69 197.42,58.53 RH102.2
  IN1 w0.089: v2(202.33,68) 202.27,67.93 202.27,67.74 v2(200.38,65.86)
  BOTTOM w0.089: v2(202.33,68) 202.44,67.89 UH1.AD7
SYS_PWROK_XDP: length 4.8
  TOP w0.102: v1(111.43,115.99) 111.54,115.87 v2(112.14,115.87) 112.43,115.58 RC24.2 RC11.2
  BOTTOM w0.102: v2(112.14,115.87) 112.16,115.9 JXDP1.47
SYS_RESET#: length 172
  TOP w0.102: v2(302.29,117.21) 302.56,116.94 JAPS1.13 ; v2(218.41,102.88) 218.41,102.56 218.02,102.17 205.48,102.17 204.52,101.21 v1(204.52,100.47) v2(204.52,97.66)
  IN1 w0.102: v2(187.56,76.34) 187.31,76.59 187.31,79.51 187.49,79.69 187.49,82.61 192.02,87.15 194.69,87.15 201.76,94.22 201.76,96 203.42,97.66 v2(204.52,97.66)
  IN2 w0.127: v2(187.56,76.34) 187.56,76.85 187.94,77.23 188.96,77.23 189.49,76.7 189.49,74.94 193.37,71.07 193.37,69.58 195.26,67.69 195.26,67.11 194.76,66.61 v2(194.76,66.28) ; v2(218.41,102.88) 219.67,102.88 221.89,105.1 227.69,105.1 229.09,106.5 229.09,108.66 232.28,111.85 232.28,113.39 232.96,114.07 233.45,114.07 234.68,114.07 235.68,113.07 237.94,113.07 238.05,112.96 241.71,112.96 242.93,111.74 247.92,111.74 248.24,111.42 251.44,111.42 252.69,112.66 258.17,112.66 259.7,114.19 274.35,114.19 274.53,114.36 276.96,114.36 277.61,113.72 278.98,113.72 279.13,113.87 282.89,113.87 283.18,113.58 284.89,113.58 285.04,113.42 285.54,113.42 287.45,115.33 291.96,115.33 292.97,116.34 296.27,116.34 297.67,117.74 300.97,117.74 301.51,117.21 v2(302.29,117.21)
  BOTTOM w0.089: UH1.AM1 198.67,68.47 198.02,67.82 197.35,67.82
  BOTTOM w0.102: 197.35,67.82 196.22,67.82 195.53,67.13 195.39,67.13 194.76,66.51 v2(194.76,66.28) 193.28,64.8 193.28,64.05 192.89,63.66 RH66.2 191.91,63.66 UC3.4
SYSPWR_PRES: length 6.5
  TOP w0.102: U51.A59 288.72,108.03 289.13,107.61 289.13,107.5 289.45,107.18 289.45,107.17 290.2,106.42 290.2,105.3 v1(290.33,105.17) 290.33,105.14 290.03,104.84 290.03,104.41 290.29,104.14 R874.1 R876.1
SYSTEM_ID: length 6
  TOP w0.102: R871.2 294.31,114.44 v2(294.25,114.39) 293.78,114.86 293.48,114.86 293.28,114.66 U51.A10 ; v2(296.48,114.44) C742.1
  IN3 w0.127: v2(296.48,114.44) 294.31,114.44 v2(294.25,114.39)
  BOTTOM w0.102: v2(296.48,114.44) v1(297.3,114.44)
TEMP_ALERT#: length 106.5
  TOP w0.102: R738.2 275.45,61.77 v2(275.4,61.82)
  IN2 w0.089: v2(207.59,62.78) 207.59,62.64 206.38,61.43 206.38,60.87 207.29,59.97 207.29,57.98 207.24,57.93
  IN2 w0.127: 207.24,57.93 207.24,57.33 206.78,56.87 206.78,55.87 208.06,54.58 208.06,54.3 206.65,52.9 206.54,52.9 204.51,54.92 203.87,54.92 202.82,53.87 201.52,53.87 198.18,50.54 v2(197.92,50.54) ; v2(238.04,54.85) 238.16,54.85 238.7,55.4 238.98,55.4 239.89,56.3 240.11,56.3 241.84,58.03 241.84,58.47 241.4,58.92 241.4,60.07 242.79,61.46 248.56,61.46 249.7,62.6 254.77,62.6 255.04,62.86 259.47,62.86 260.61,61.72 264.5,61.72 264.65,61.57 266.65,61.57 266.67,61.59 270.09,61.59 270.23,61.73 275.31,61.73 v2(275.4,61.82)
  IN3 w0.089: v2(207.59,62.78) 207.62,62.76 207.62,62.73 207.97,62.37 208.45,62.37 209.44,61.38 209.44,60.49 209.74,60.2 209.74,60.01 210.17,59.58
  IN3 w0.127: v2(238.04,54.85) 237.97,54.77 237.11,54.77 235.53,53.2 230.94,53.2 229.88,54.26 220.9,54.26 220.39,53.75 219.35,53.75 218.17,54.93 218.17,55.18 216.62,56.73 216.62,57.6 216.15,58.08 214.57,58.08 214.4,58.25 211.49,58.25 210.17,59.58
  BOTTOM w0.089: UH1.H6 207.13,62.78 v2(207.59,62.78)
  BOTTOM w0.102: v2(197.92,50.54) 198.19,50.54 198.31,50.66 RH171.2 ; v2(275.4,61.82) v1(276.11,61.82)
TEMP_ALERT#_R: length 12.9
  TOP w0.102: v1(276.41,61.18) 276.41,60.99 275.56,60.13 R738.1 275.37,60.13 274.98,59.74 274.98,59.35 275.16,59.16 275.16,58.74 275.29,58.61 275.83,58.61 v2(276,58.78) ; v2(272.12,53.64) U46.B11
  IN1 w0.102: v2(276,58.78) 276.11,58.67 276.11,55.5 275.75,55.14 275.17,55.14 274.63,54.61 273.4,54.61 272.43,53.64 v2(272.12,53.64)
TESTA: length 5
  BOTTOM w0.102: R3687.1 R3679.2 332.65,192.16 v1(332.65,192.14) 332.65,191.33 331.95,190.63 U90.14
TESTB: length 6.6
  BOTTOM w0.102: U92.14 337.81,221.78 337.32,222.28 336.66,222.28 336.29,222.64 334.68,222.64 R3719.1 333.85,223.08 333.8,223.02 R3709.2 v1(333.31,223.98)
TESTC: length 3.7
  BOTTOM w0.102: R3749.1 R3746.2 v1(33.89,187.87) 34.67,187.1 U94.14
TESTD: length 4.8
  BOTTOM w0.102: v1(344.97,193.71) 344.99,193.69 R3771.2 R3761.1 345.18,192.67 344.15,191.64 U95.14
TESTEN: length 6.3
  TOP w0.102: T139.1 227.19,123.6 v2(226.66,124.12) 226.53,124.25 RV41.1 ; RV49.1 226.84,122.08 v2(226.68,121.92)
  IN2 w0.102: v2(226.68,121.92) 226.63,121.92 226.2,122.35 226.2,123.66 v2(226.66,124.12)
  BOTTOM w0.102: v2(226.66,124.12) 226.66,124.58 UV1.AD28
THERMATRIP2#: length 12.4
  TOP w0.102: Q4.1 279.17,122.91 v2(278.95,123.13) 278.84,123.13 v1(278.05,123.91) ; v2(282.35,120.69) 282.34,120.69 282.05,120.98 C18.1 R51.2 ; U51.B34 283.47,118.86 283.4,118.92 v2(283.03,118.92)
  IN1 w0.102: v2(283.03,118.92) 283.27,118.92 283.68,119.33 283.68,119.62 282.61,120.69 v2(282.35,120.69)
  IN4 w0.102: v2(282.35,120.69) 281.28,121.77 280.27,121.77 278.95,123.09 v2(278.95,123.13)
THERMATRIP3#: length 51.4
  TOP w0.102: v2(249.74,108.7) v1(249.74,109.36) CV57.1 249.96,110.59 QV7.1 ; U51.A2 293.26,110.66 293.5,110.41 293.63,110.41 v2(293.63,110.41) 293.73,110.41 294.27,109.87 R52.1
  IN2 w0.127: v2(249.74,108.7) 249.8,108.64 252.76,108.64 252.88,108.75 263.61,108.75 263.89,109.03 265.48,109.03 266.28,108.23 271.23,108.23 272.11,109.11 275.33,109.11 275.59,108.85 277.54,108.85 277.81,109.12 282.57,109.12 282.63,109.05 289.21,109.05 289.64,109.49 291.46,109.49 292.37,110.4 293.62,110.4 v2(293.63,110.41)
THERMTRIP_VGA: length 30.5
  TOP w0.102: RV47.1 RV77.1 RV104.2 v1(241.82,116.98) 241.37,116.98 v2(241.3,117.06)
  IN1 w0.102: v2(231.85,133.69) 232.35,133.18 234.7,133.18 234.93,132.96 234.93,120.15 234.56,119.79 234.56,118.95 234.86,118.66 v2(234.86,117.12)
  IN3 w0.102: 237.85,117.31 235.05,117.31 v2(234.86,117.12)
  IN3 w0.127: v2(241.3,117.06) 241.04,117.31 237.85,117.31
  BOTTOM w0.102: v2(231.85,133.69) 231.85,133.77 232.25,134.17 UV1.AM17
THSEL_STRAP: length 12.5
  TOP w0.102: v2(286.22,123.22) 286.22,123.71 R1069.1 ; v2(285.96,117.82) 285.97,117.82 U51.B29
  IN1 w0.102: v2(285.96,117.82) 285.96,117.41 286.27,117.11 286.27,116.83 286.6,116.5 287.64,116.5 287.93,116.79 287.93,118.22 286.65,119.51 286.65,121.67 286.22,122.09 v2(286.22,123.22)
  BOTTOM w0.102: v1(286.66,118.34) 286.49,118.34 285.97,117.82 v2(285.96,117.82)
TMDSB_CPU_CLK: length 232.2
  TOP w0.102: v2(34.04,204.54) 33.85,204.73 33.53,204.73 C352.2
  IN1 w0.089: v2(154.73,109.92) 155.18,109.92 155.23,109.97 155.23,110.16 155.05,110.34 154.44,110.34 154.12,110.65 154.12,111.08 153.86,111.34 153.4,111.34 153.13,111.61 153.13,114.85 153.13,115.35 153.13,115.44 153.12,115.46
  IN1 w0.114: 153.12,115.46 153.12,115.68 153.29,115.86 153.29,118.52 153.49,118.71 153.89,119.11 154.96,119.11 155.33,119.49 155.33,119.75 165.22,129.63 165.22,140.55 164.91,140.86 164.91,148.74 165.22,149.05 165.22,159.9 162.99,162.13 160.94,162.13 159.95,163.12 152.97,163.12 152.37,162.52 147.94,162.52 146.97,161.56 140.57,161.56 140.18,161.95 137.51,161.95 136.01,163.45 128.34,163.45 128.21,163.58 128.21,163.58 127.86,163.93 119.66,163.93 118.16,162.43 112.79,162.43 111.84,163.39 110.89,163.39 110.77,163.26 110.77,162.36 110.5,162.1 109.81,162.1 109.55,162.36 109.55,163.26 109.42,163.39 109.04,163.39 108.91,163.26 108.91,163 108.64,162.74 99.46,162.74 98.91,162.19 95.35,162.19 94.13,163.41 93.49,163.41 93.37,163.3 93.37,162.68 93.13,162.43 92.59,162.43 92.35,162.68 92.35,163.3 92.08,163.56 89.24,163.56 87.61,165.19 87.61,166.17 80.5,173.29 68.77,173.29 67.95,174.11 61.18,174.11 60.33,173.27 54.53,173.27 54.42,173.15 54.42,172.7 54.16,172.44 53.65,172.44 53.39,172.7 53.39,173.15 53.27,173.27 51.67,173.27 51.56,173.15 51.56,172.56 51.31,172.31 50.78,172.31 50.53,172.56 50.53,173.15 50.41,173.27 48.17,173.27 41.84,179.6 41.39,179.6 39.81,181.17 39.81,181.62 37.37,184.06 37.37,202.91 35.38,204.9 34.39,204.9 v2(34.04,204.54)
  BOTTOM w0.089: v2(154.73,109.92) JCPU1.V31
TMDSB_CPU_CLK#: length 232.3
  TOP w0.102: v2(34.04,205.13) 33.85,204.94 33.51,204.94 C353.2
  IN1 w0.089: v2(155.73,109.92) 155.52,109.92 155.43,110.01 155.43,110.25 155.14,110.54 154.52,110.54 154.33,110.74 154.33,111.16 153.95,111.54 153.49,111.54 153.34,111.7 153.34,114.93 153.33,114.93 153.33,115.35 153.34,115.43 153.35,115.44 153.35,115.46
  IN1 w0.114: v2(34.04,205.13) 35.47,205.13 37.6,203 37.6,184.16 40.04,181.71 40.04,181.27 41.49,179.83 41.93,179.83 48.26,173.49 50.51,173.49 50.76,173.25 50.76,172.66 50.87,172.54 51.22,172.54 51.33,172.66 51.33,173.25 51.58,173.49 53.37,173.49 53.62,173.25 53.62,172.8 53.74,172.67 54.06,172.67 54.19,172.8 54.19,173.25 54.44,173.49 60.24,173.49 61.08,174.34 68.04,174.34 68.86,173.52 80.59,173.52 87.84,166.27 87.84,165.28 89.33,163.79 92.17,163.79 92.57,163.39 92.57,162.78 92.69,162.66 93.03,162.66 93.15,162.78 93.15,163.39 93.39,163.64 94.23,163.64 95.45,162.42 98.81,162.42 99.36,162.97 108.55,162.97 108.68,163.1 108.68,163.35 108.94,163.61 109.51,163.61 109.77,163.35 109.77,162.46 109.9,162.33 110.41,162.33 110.54,162.46 110.54,163.35 110.8,163.61 111.93,163.61 112.89,162.66 118.06,162.66 119.56,164.16 127.95,164.16 128.43,163.68 136.11,163.68 137.61,162.18 140.27,162.18 140.67,161.79 146.88,161.79 147.84,162.75 152.28,162.75 152.87,163.35 160.05,163.35 161.04,162.36 163.08,162.36 165.44,159.99 165.44,148.95 165.13,148.64 165.13,140.96 165.44,140.65 165.44,129.54 155.56,119.65 155.56,119.39 155.05,118.88 153.99,118.88 153.65,118.54 153.52,118.42 153.52,115.76 153.35,115.59 153.35,115.46
  BOTTOM w0.089: v2(155.73,109.92) JCPU1.U31
TMDSB_CPU_N0: length 225.6
  TOP w0.102: C350.2 33.49,197.84 33.61,197.84 v2(33.8,198.03)
  IN1 w0.089: v2(155.73,107.92) 155.32,107.51 154.4,107.51 154.34,107.56 154.34,108.2 154.02,108.52 153.45,108.52 153.35,108.62 153.35,109.18 153.01,109.52 152.45,109.52 152.33,109.64 152.33,110.18 152,110.52 151.57,110.52 151.32,110.76 151.32,111.2 151,111.52 150.44,111.52 150.33,111.63 150.33,114.83 150.26,114.89 150.26,115.42 150.27,115.43 150.27,115.46
  IN1 w0.114: v2(33.8,198.03) 34.02,197.81 34.2,197.81 34.55,197.46 34.55,196.44 32.81,194.7 32.81,185.01 34.2,183.63 34.2,179.45 44.86,168.78 82.04,168.78 82.23,168.78 85.58,165.43 85.58,164.19 88.57,161.2 90.19,161.2 90.99,160.4 90.99,160.18 92.18,158.99 94.2,158.99 95.14,159.93 101.99,159.93 102.37,160.31 104.4,160.31 104.78,159.93 110.57,159.93 110.78,159.71 115.19,159.71 115.83,159.08 116.77,159.08 117.72,160.03 124.74,160.03 125.42,160.72 126.9,160.72 127.69,161.51 129.32,161.51 135.21,161.51 137.93,158.78 154.85,158.78 155.05,158.98 162.79,158.98 163.17,158.6 163.17,150.3 162.89,150.02 162.89,138.82 162.99,138.71 163.13,138.58 163.13,130.42 155.75,123.04 154.32,123.04 152.17,120.88 152.1,120.88 150.34,119.13 150.34,115.93 150.27,115.86 150.27,115.46
  BOTTOM w0.089: JCPU1.U29 v2(155.73,107.92)
TMDSB_CPU_N1: length 225.3
  TOP w0.102: C346.2 33.46,200.93 33.87,200.93 v2(34.05,201.1)
  IN1 w0.089: 152.32,115.36 152.36,115.32 152.36,111.74 152.58,111.52 152.95,111.52 153.32,111.15 153.32,110.78 153.58,110.52 153.98,110.52 154.33,110.17 154.33,109.73 154.54,109.51 155.99,109.51 156.58,108.92 v2(156.73,108.92)
  IN1 w0.114: v2(34.05,201.1) 34.64,201.1 36.46,199.29 36.46,182.14 42.12,176.48 43.36,176.48 44.62,175.22 45.39,175.22 48.79,171.82 59.58,171.82 61.37,173.61 67.26,173.61 69.09,171.78 78.59,171.78 78.98,171.39 81.68,171.39 87.08,165.99 87.08,164.86 88.9,163.04 90.92,163.04 92.46,161.51 98.95,161.51 99.64,162.19 107.93,162.19 108.55,161.57 111.04,161.57 111.34,161.26 115.85,161.26 116.44,161.86 118.33,161.86 119.89,163.42 127.66,163.42 127.84,163.24 128.13,162.95 135.81,162.95 137.31,161.45 139.97,161.45 140.37,161.06 140.37,161.06 140.41,161.02 147.25,161.02 148.06,161.84 152.54,161.84 153.28,162.59 159.41,162.59 160.4,161.59 162.74,161.59 164.69,159.64 164.69,149.33 164.37,149.01 164.37,140.26 164.56,140.08 164.69,139.95 164.69,130.07 164.69,129.88 154.87,120.06 154.73,119.93 154,119.93 153.84,119.76 153.28,119.2 152.79,118.71 152.71,118.71 152.47,118.47 152.47,115.85 152.32,115.7 152.32,115.36
  BOTTOM w0.089: v2(156.73,108.92) JCPU1.T30
TMDSB_CPU_N2: length 231.9
  TOP w0.102: v2(34.04,203.12) 33.85,202.93 33.49,202.93 C348.2
  IN1 w0.089: 151.3,115.46 151.29,115.44 151.29,114.83 151.31,114.81 151.31,111.8 151.61,111.51 151.97,111.51 152.32,111.16 152.32,110.79 152.57,110.54 152.97,110.54 153.34,110.17 153.34,109.79 153.6,109.52 153.97,109.52 154.35,109.14 154.35,108.77 154.61,108.51 156.07,108.51 156.33,108.25 156.33,107.76 156.56,107.53 157.13,107.53 157.45,107.21 157.45,107.01 157.54,106.92 v2(157.73,106.92)
  IN1 w0.114: v2(34.04,203.12) 34.56,203.12 34.87,202.82 34.87,201.98 34.49,201.6 33.55,201.6 33.3,201.34 33.3,200.29 35.61,197.98 35.61,179.99 46.09,169.51 81.74,169.51 82.53,169.51 85.5,166.53 86.34,165.69 86.34,164.5 88.57,162.28 90.44,162.28 92.03,160.69 101.61,160.69 101.95,161.04 102.67,161.04 104.73,161.04 105.08,160.69 110.85,160.69 111.09,160.45 116.98,160.45 117.64,161.11 118.68,161.11 119.68,162.12 123.31,162.12 123.83,162.64 127.43,162.64 127.83,162.23 129.02,162.23 135.51,162.23 138.23,159.51 146.01,159.51 146.73,160.22 151.56,160.22 152,160.67 162.53,160.67 163.91,159.28 163.91,149.69 163.62,149.4 163.62,139.4 163.86,139.16 163.86,130.12 155.71,121.96 154.28,121.96 153.75,121.44 153.75,120.7 152.49,119.43 152.23,119.43 151.4,118.6 151.4,115.55 151.3,115.46
  BOTTOM w0.089: v2(157.73,106.92) 157.67,106.92 JCPU1.T28
TMDSB_CPU_P0: length 225.6
  TOP w0.102: C351.2 33.47,197.63 33.61,197.63 v2(33.8,197.45)
  IN1 w0.089: 150.05,115.46 150.06,115.44 150.06,114.81 150.12,114.74 150.12,111.55 150.36,111.32 150.91,111.32 151.11,111.12 151.11,110.68 151.48,110.31 151.92,110.31 152.13,110.1 152.13,109.55 152.36,109.32 152.92,109.32 153.14,109.1 153.14,108.54 153.37,108.32 153.94,108.32 154.14,108.12 154.14,107.48 154.31,107.3 155.38,107.3 155.73,106.95 v2(155.73,106.92)
  IN1 w0.114: v2(33.8,197.45) 33.94,197.59 34.1,197.59 34.32,197.36 34.32,196.54 32.58,194.8 32.58,184.92 33.97,183.53 33.97,179.36 44.77,168.55 82.13,168.55 85.35,165.33 85.35,164.1 88.48,160.97 90.1,160.97 90.76,160.31 90.76,160.09 92.09,158.76 94.29,158.76 95.23,159.7 102.08,159.7 102.47,160.08 104.31,160.08 104.69,159.7 110.47,159.7 110.69,159.49 115.1,159.49 115.73,158.85 116.87,158.85 117.82,159.8 124.83,159.8 125.52,160.49 127,160.49 127.78,161.28 129.41,161.28 135.11,161.28 137.84,158.55 154.98,158.55 155.18,158.75 162.7,158.75 162.94,158.51 162.94,150.4 162.66,150.12 162.66,138.72 162.83,138.55 162.9,138.48 162.9,130.51 155.65,123.27 154.22,123.27 152.07,121.11 152,121.11 150.11,119.22 150.11,116.02 150.05,115.96 150.05,115.46
  BOTTOM w0.089: JCPU1.V29 v2(155.73,106.92)
TMDSB_CPU_P1: length 225.3
  TOP w0.102: v2(34.05,200.52) 33.86,200.72 33.5,200.72 C347.2
  IN1 w0.089: v2(155.73,108.92) 155.82,108.84 156.04,108.84 156.14,108.94 156.14,109.07 155.9,109.31 154.46,109.31 154.12,109.64 154.12,110.09 153.9,110.31 153.5,110.31 153.12,110.69 153.12,111.07 152.87,111.32 152.5,111.32 152.15,111.66 152.15,115.22 152.09,115.28 152.09,115.36
  IN1 w0.114: v2(34.05,200.52) 34.41,200.88 34.55,200.88 36.23,199.19 36.23,182.05 42.02,176.25 43.26,176.25 44.52,174.99 45.3,174.99 48.7,171.59 59.68,171.59 61.47,173.38 67.17,173.38 68.99,171.55 78.49,171.55 78.89,171.16 81.59,171.16 86.85,165.89 86.85,164.76 88.8,162.81 90.83,162.81 92.36,161.28 99.05,161.28 99.73,161.96 107.83,161.96 108.45,161.34 110.94,161.34 111.25,161.04 115.94,161.04 116.54,161.63 118.42,161.63 119.99,163.19 127.57,163.19 128.04,162.72 135.71,162.72 137.21,161.23 139.88,161.23 140.31,160.79 147.38,160.79 148.19,161.61 152.63,161.61 153.38,162.36 159.32,162.36 160.31,161.37 162.64,161.37 164.46,159.55 164.46,149.42 164.14,149.1 164.14,140.17 164.46,139.85 164.46,129.98 154.64,120.15 153.91,120.15 153.61,119.85 153.61,119.85 153.19,119.43 152.69,118.94 152.62,118.94 152.24,118.56 152.24,115.95 152.09,115.8 152.09,115.36
  BOTTOM w0.089: v2(155.73,108.92) JCPU1.U30
TMDSB_CPU_P2: length 231.9
  TOP w0.102: v2(34.04,202.54) 33.86,202.72 33.48,202.72 C349.2
  IN1 w0.089: 151.07,115.46 151.07,115.43 151.09,115.42 151.09,114.75 151.11,114.73 151.11,111.72 151.52,111.3 151.89,111.3 152.12,111.07 152.12,110.71 152.48,110.34 152.88,110.34 153.13,110.09 153.13,109.7 153.51,109.32 153.89,109.32 154.15,109.06 154.15,108.69 154.53,108.31 155.99,108.31 156.13,108.17 156.13,107.67 156.48,107.33 157.05,107.33 157.25,107.13 157.25,107 157.17,106.92 156.74,106.92 v2(156.73,106.92)
  IN1 w0.114: 151.07,115.46 151.07,115.67 151.17,115.76 151.17,118.69 152.14,119.66 152.39,119.66 153.53,120.8 153.53,121.53 154.19,122.19 155.62,122.19 163.64,130.21 163.64,139.06 163.39,139.31 163.39,149.5 163.69,149.79 163.69,159.19 162.44,160.44 152.13,160.44 151.68,159.99 146.83,159.99 146.11,159.28 138.14,159.28 135.41,162 129.11,162 127.74,162 127.33,162.41 123.93,162.41 123.41,161.89 119.78,161.89 118.77,160.88 117.74,160.88 117.08,160.22 110.99,160.22 110.75,160.46 104.98,160.46 104.64,160.81 102.58,160.81 102.05,160.81 101.7,160.46 91.93,160.46 90.34,162.05 88.47,162.05 86.11,164.41 86.11,165.59 85.27,166.44 85.27,166.44 82.43,169.28 81.83,169.28 46,169.28 35.38,179.9 35.38,197.89 33.07,200.2 33.07,201.43 33.46,201.83 34.39,201.83 34.64,202.08 34.64,202.72 34.47,202.9 34.4,202.9 v2(34.04,202.54)
  BOTTOM w0.089: v2(156.73,106.92) 156.67,106.92 JCPU1.U28
TMDSE_CON_CLK: length 8.8
  BOTTOM w0.102: R63.2 17.6,204.44 L1.2 16.98,204.44 16.66,204.76 16.01,204.76 15.88,204.63 15.42,204.63 CE5.1 14.77,204.63 14.42,204.63 14.17,204.88 14.17,205.27 14.07,205.37 13.6,205.37 13.5,205.27 13.5,204.7 13.25,204.45 12.66,204.45 12.41,204.7 12.41,205.33 12.25,205.49 11.99,205.49 JHDMI1.10
TMDSE_CON_CLK#: length 8.8
  BOTTOM w0.102: JHDMI1.12 11.99,205.7 12.34,205.7 12.62,205.42 12.62,204.79 12.75,204.66 13.16,204.66 13.28,204.79 13.28,205.36 13.54,205.61 v4(13.81,205.61) 14.13,205.61 14.38,205.36 14.38,204.97 14.51,204.84 14.77,204.84 CE7.1 15.42,204.84 15.79,204.84 15.92,204.97 16.6,204.97 16.92,205.29 L1.3 17.6,205.29 R62.2
TMDSE_CON_N0: length 14.5
  BOTTOM w0.102: R68.2 17.6,207.57 L2.3 16.98,207.57 16.75,207.34 16.35,207.34 16.11,207.58 CE16.1 15.51,207.36 15.28,207.36 15.23,207.41 15.23,207.43 14.85,207.82 14.82,207.82 v4(13.95,208.69) 12.73,209.91 11.27,209.91 10.65,209.28 10.65,204.7 10.55,204.59 JHDMI1.9
TMDSE_CON_N1: length 14.5
  BOTTOM w0.102: R74.2 17.6,202.49 L3.3 17.03,202.49 16.79,202.25 16.49,202.25 CE18.1 15.79,202.3 15.66,202.3 15.25,202.72 14.82,202.72 14.6,202.49 14.6,201.79 14.47,201.66 14.22,201.66 14.09,201.79 14.09,202.12 14.11,202.14 14.11,202.72 14.09,202.74 14.09,203.46 13.84,203.72 13.41,203.72 13.16,203.46 13.16,200.67 13.04,200.55 12.78,200.55 12.65,200.67 12.65,202.49 12.43,202.72 11.98,202.72 JHDMI1.6
TMDSE_CON_N2: length 8.9
  BOTTOM w0.102: JHDMI1.3 10.49,201.16 10.65,201.16 12.04,199.76 13.69,199.76 13.7,199.78 14.25,199.78 14.27,199.76 14.77,199.76 CE14.1 15.4,199.78 16.07,199.78 16.22,199.63 16.5,199.63 16.82,199.95 L4.3 17.6,199.95 R78.2
TMDSE_CON_P0: length 14.5
  BOTTOM w0.102: JHDMI1.7 10.86,204.41 10.86,209.2 11.36,209.69 12.65,209.69 13.6,208.74 13.6,208.72 14.01,208.31 14.04,208.31 v4(14.88,207.46) 15.19,207.15 15.72,207.15 16.02,206.84 CE17.1 16.4,207.13 16.7,207.13 17.1,206.72 L2.2 17.6,206.72 R64.2
TMDSE_CON_P1: length 14.5
  BOTTOM w0.102: JHDMI1.4 12.01,202.51 12.34,202.51 12.44,202.4 12.44,200.59 12.69,200.33 13.12,200.33 13.37,200.59 13.37,203.38 13.5,203.5 13.75,203.5 13.88,203.38 v4(13.88,202.45) 13.88,201.7 14.13,201.45 14.56,201.45 14.81,201.7 14.81,202.4 14.91,202.51 15.16,202.51 15.58,202.09 15.79,202.09 CE13.1 16.38,202.03 16.41,202.03 16.41,202.04 16.68,202.04 17.08,201.64 L3.2 17.6,201.64 R71.2
TMDSE_CON_P2: length 8.9
  BOTTOM w0.102: JHDMI1.1 10.39,200.94 10.52,200.94 11.91,199.55 v4(13.98,199.55) 14.77,199.55 CE15.1 15.44,199.57 15.99,199.57 16.14,199.42 16.5,199.42 16.82,199.1 L4.2 17.6,199.1 R77.2
TMDSE_CPU_CLK#_C: length 4.3
  TOP w0.102: U19.10 29.25,203.36 29.35,203.27 29.48,203.27 30.01,203.8 30.04,203.8 30.32,204.08 30.54,204.08 v4(31.03,204.57) 31.38,204.92 31.72,204.92 C353.1
TMDSE_CPU_CLK_C: length 4.3
  TOP w0.102: U19.9 29.25,202.96 29.35,203.06 29.6,203.06 v4(29.98,203.44) 30.41,203.87 30.63,203.87 30.97,204.22 31,204.22 31.39,204.61 31.39,204.63 31.45,204.7 31.79,204.7 C352.1
TMDSE_CPU_N0_C: length 4.5
  TOP w0.102: C350.1 31.78,197.87 31.72,197.87 31.59,198 31.59,198.02 31.21,198.41 31.18,198.41 v4(30.47,199.13) 29.54,200.05 29.4,200.05 29.29,200.16 U19.2
TMDSE_CPU_N1_C: length 4.5
  TOP w0.102: C346.1 31.8,200.95 31.64,200.95 31.56,201.03 31.56,201.6 31.35,201.8 31.04,201.8 30.49,201.26 30.31,201.26 30.29,201.27 29.74,201.27 29.73,201.26 29.32,201.26 29.22,201.36 U19.5
TMDSE_CPU_N2_C: length 4.3
  TOP w0.102: C348.1 31.8,202.97 31.36,202.97 31.35,202.99 30.8,202.99 30.78,202.97 30.44,202.97 30.2,202.73 30.2,202.14 30.12,202.07 29.52,202.07 29.42,202.16 U19.7
TMDSE_CPU_P0_C: length 4.5
  TOP w0.102: U19.1 29.29,199.76 29.36,199.84 29.45,199.84 30.11,199.18 30.11,199.16 30.5,198.77 30.52,198.77 v4(31.24,198.06) 31.63,197.66 31.75,197.66 C351.1
TMDSE_CPU_P1_C: length 4.5
  TOP w0.102: C347.1 31.72,200.74 31.56,200.74 31.34,200.95 31.34,201.51 31.26,201.59 31.13,201.59 30.58,201.05 v4(30.02,201.05) 29.3,201.05 29.22,200.96 U19.4
TMDSE_CPU_P2_C: length 4.3
  TOP w0.102: C349.1 31.73,202.76 v4(31.07,202.76) 30.53,202.76 30.41,202.64 30.41,202.06 30.21,201.86 29.52,201.86 29.42,201.76 U19.6
TMDSE_RP_CLK: length 13.7
  TOP w0.102: v2(22.27,203.47) 22.39,203.59 22.63,203.59 23.26,202.96 U19.22
  BOTTOM w0.102: v2(22.27,203.47) 22.06,203.67 21.6,203.67 21.49,203.57 21.49,202.67 21.24,202.42 20.37,202.42 19.97,202.83 19.97,203.71 20.36,204.1 20.36,204.58 20.61,204.83 21.14,204.83 21.27,204.96 21.27,206.08 21.14,206.21 20.41,206.21 20.29,206.08 20.29,204.97 20.03,204.72 19.75,204.72 19.47,204.44 L1.1 18.68,204.44 R63.1
TMDSE_RP_CLK#: length 13.7
  TOP w0.102: v2(22.27,204.05) 22.5,203.82 22.7,203.82 23.16,203.36 U19.21
  BOTTOM w0.102: R62.1 18.68,205.29 L1.4 19.47,205.29 19.83,204.93 19.95,204.93 20.07,205.06 20.07,206.17 20.32,206.42 21.23,206.42 21.48,206.17 21.48,204.87 21.23,204.62 20.7,204.62 20.57,204.5 20.57,204.01 20.18,203.62 20.18,202.91 20.46,202.63 21.15,202.63 21.28,202.76 21.28,203.66 21.51,203.89 22.1,203.89 v2(22.27,204.05)
TMDSE_RP_N0: length 13.7
  TOP w0.102: v2(20.02,207.4) 20.02,207.39 20.15,207.26 20.48,207.26 20.65,207.1 20.65,206.54 20.21,206.1 19.76,206.1 19.5,205.84 v4(19.5,204.69) 19.5,201.6 21.08,200.02 23.1,200.02 23.24,200.16 U19.29
  BOTTOM w0.102: v2(20.02,207.4) 19.83,207.22 19.71,207.22 19.36,207.57 L2.4 18.68,207.57 R68.1
TMDSE_RP_N1: length 13.6
  TOP w0.102: U19.26 23.12,201.36 23.05,201.29 21.95,201.29 21.79,201.44 21.53,201.44 v2(21.32,201.65)
  BOTTOM w0.102: R74.1 18.68,202.49 L3.4 19.45,202.49 19.79,202.15 19.91,202.15 20.15,201.9 20.15,200.45 21.01,199.59 21.01,198.16 21.14,198.03 21.53,198.03 21.65,198.16 21.65,199.43 21.19,199.89 21.19,200.29 20.69,200.79 20.69,201.29 20.88,201.47 21.14,201.47 v2(21.32,201.65)
TMDSE_RP_N2: length 13.6
  TOP w0.102: U19.24 22.88,202.16 v2(22.73,202.31)
  BOTTOM w0.102: R78.1 18.68,199.95 L4.4 19.38,199.95 19.69,199.65 19.96,199.65 20.28,199.33 20.28,197.4 20.56,197.12 22.49,197.12 22.61,197.24 v4(22.61,198.88) 22.61,199.83 22.49,199.95 22.14,199.95 21.89,200.2 21.89,201.8 22.24,202.15 22.56,202.15 v2(22.73,202.31)
TMDSE_RP_P0: length 13.6
  TOP w0.102: U19.30 23.25,199.76 23.2,199.81 21,199.81 19.29,201.51 19.29,204.39 19.27,204.41 19.27,204.96 19.29,204.98 19.29,205.93 19.67,206.31 20.12,206.31 20.44,206.63 20.44,207.01 20.39,207.05 20.25,207.05 v2(20.02,206.82)
  BOTTOM w0.102: R64.1 18.68,206.72 L2.1 19.32,206.72 19.6,207.01 19.83,207.01 v2(20.02,206.82)
TMDSE_RP_P1: length 13.6
  TOP w0.102: v2(21.32,201.07) 21.48,201.23 21.71,201.23 21.86,201.08 23.19,201.08 23.3,200.96 U19.27
  BOTTOM w0.102: R71.1 18.68,201.64 L3.1 19.47,201.64 19.76,201.93 19.82,201.93 19.94,201.82 19.94,200.36 20.8,199.5 20.8,198.07 21.05,197.82 21.61,197.82 21.87,198.07 21.87,199.52 21.4,199.98 21.4,200.37 20.9,200.88 20.9,201.2 20.96,201.26 21.12,201.26 v2(21.32,201.07)
TMDSE_RP_P2: length 13.6
  TOP w0.102: v2(22.73,201.73) 22.76,201.76 U19.25
  BOTTOM w0.102: v2(22.73,201.73) 22.52,201.93 22.33,201.93 22.1,201.71 22.1,200.29 22.23,200.16 22.57,200.16 22.83,199.91 22.83,199.17 22.84,199.16 22.84,198.61 22.83,198.59 22.83,197.16 22.57,196.91 20.48,196.91 20.07,197.31 20.07,199.24 19.87,199.44 19.77,199.44 19.43,199.1 L4.1 18.68,199.1 R77.1
TOUCH_SCREEN_PD#: length 9.1
  TOP w0.102: U46.B55 265.69,49.14 v2(265.9,49.35) ; v2(266.8,42.98) 266.62,43.15 T144.1
  IN1 w0.102: v2(266.8,42.98) 266.8,46.89 265.68,48.01 265.68,49.14 v2(265.9,49.35)
TP_CLK: length 12.6
  TOP w0.102: R1164.2 265.7,98.32 265.5,98.12 265.15,98.12 C749.1 264.05,98.74 263.95,98.64 263.95,97.37 263.61,97.03 262.68,97.03 260.65,99.06 D37.2 260.13,99.29 259.34,98.5 v1(258.91,98.5) 258.89,98.53 JTP1.2
TP_DATA: length 11
  TOP w0.102: R1163.2 265.7,97.66 265.48,97.88 265.29,97.88 C750.1 264.02,96.61 v1(263.52,96.61) 262.72,96.61 261.4,97.93 261.22,97.93 D37.3 259.93,98.08 257.9,98.08 257.85,98.03 JTP1.3
TP_LAN_JTAG_TCK: length 4.1
  BOTTOM w0.102: U31.35 317.12,202.98 317.61,203.47 R546.2 317.81,204.41 318.37,203.85 v1(318.88,203.85)
TP_LAN_JTAG_TDI: length 1.4
  BOTTOM w0.102: U31.32 315.92,203.02 T142.1
TP_LAN_JTAG_TDO: length 1.6
  BOTTOM w0.102: T143.1 316.72,203.08 U31.34
TP_LAN_JTAG_TMS: length 2.5
  BOTTOM w0.102: U31.33 316.34,202.01 316.34,203.38 316.42,203.46 316.42,204.23 R545.2
TPM_ID0: length 12.9
  TOP w0.089: 193.62,71.55 193.7,71.64 195.06,71.64 195.94,70.75 197.47,70.75 198.99,72.27 v2(198.99,72.48)
  TOP w0.102: RH199.2 190.07,69.57 190.07,70.01 v1(190.51,70.45) 191.37,71.31 193.37,71.31 193.62,71.55
  BOTTOM w0.089: UH1.AT7 199.28,71.47 199.28,72.18 v2(198.99,72.48)
TPM_ID1: length 8.3
  BOTTOM w0.089: 197.58,67.59 198.06,67.59 198.64,68.17 198.85,68.17 199.02,68.35 199.02,68.64 199.35,68.96 UH1.AM3
  BOTTOM w0.102: 197.58,67.59 196.31,67.59 195.52,66.8 v1(195.52,65.84) 195.52,65.19 195.83,64.88 195.83,64.43 195.32,63.93
TRIP_+1.05VSP: length 2.8
  TOP w0.254: PR302.2 v1(238.16,5.98) 238.61,6.43 PU300.2
