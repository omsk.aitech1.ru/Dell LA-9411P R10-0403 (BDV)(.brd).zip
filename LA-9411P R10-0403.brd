# Allegro board LA-9411P R10-0403.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
GND_CHASSIS:
  vias: v1(301.73,215.28)
GNDA: length 30.7
  TOP w0.102: v3(338.64,161.71) 338.41,161.48 v2(338.41,160.87) ; v3(350.45,164.66) 350.43,164.68 v2(350.43,165.44) ; v2(352.48,182.88) 351.89,182.88 v3(351.87,182.89)
  TOP w0.254: v2(345.6,174.09) U74.36 ; v2(345.7,168.9) 345.51,169.09 U74.26
  TOP w0.381: Q327.4 351.32,172.93 351.72,173.33 v2(351.72,173.38) ; Q327.1 350.02,170.38 v2(349.7,170.07)
  TOP w0.508: R1642.2 v2(343.9,163.59) ; Q324.3 346.17,163.9 v2(346.06,163.79) ; C957.2 346.63,168.47 v2(346.52,168.58) ; v2(355.71,173.37) 355.25,173.82 C1212.2 ; v2(342.93,162.5) 342.84,162.5 342.45,162.89 342.45,163.68 C963.2 342.86,163.73 343.31,163.27 343.31,163.04 343.77,162.59 v2(343.89,162.59) ; v2(346.6,166.79) 347.23,166.79 C1107.2 ; v2(343.78,160.96) 343.73,161.01 343.01,161.01 C1247.2 ; v2(354.68,157.2) 354.68,156.34 R5.1 ; R6.1 v2(336.41,158.66) ; v2(341.75,160.71) 341.66,160.62 C972.2 ; C970.2 353.02,168.67 v2(353.37,169.02)
  BOTTOM w0.457: Q106.4 338.7,161.16 v2(338.41,160.87) ; v2(341.6,162.6) 341.59,162.6 341.45,162.46 Q106.1
  BOTTOM w0.508: v2(354.49,176.14) 353.91,175.55 D83.1 ; C1211.2 356,168.31 v2(356.03,168.29) ; v2(349.89,176.24) 350.71,176.24 R1088.2 ; R15.1 352.61,184.82 353.11,184.33 v2(353.11,184.2) ; D82.1 353.07,171.41 v2(353.07,170.76) ; R1676.2 v2(351.72,178) ; C1213.2 351.38,179.08 v2(351.68,178.78) ; C956.2 v2(346.46,177.42) ; v2(353.78,180.56) 353.7,180.48 D81.1 ; C1215.2 v2(352.48,182.88) ; C968.2 v2(345.09,178.21)
  vias: v2(335.8,159.74) v2(348.85,176.02) v2(348.85,175.42) v2(349.17,171.34) v2(349.18,170.75) v2(349.79,166.08) v2(349.79,165.44) v2(350.43,166.08)
GNDA_CHG:
  vias: v1(77.12,186.22) v4(77.07,185.05) v4(77.07,184.29) v4(77.96,184.29)
GNDA_GPU_CORE: length 39.7
  TOP w0.102: v4(314.03,152.46) v1(314.77,152.46)
  TOP w0.254: v2(297.04,145.68) 296.05,144.69 PR634.2
  IN1 w0.254: v4(314.03,152.46) 314.18,152.62 314.23,152.62 314.85,153.24 314.85,157.56 315.24,157.94 315.24,158.98 314.33,159.89 313.53,159.89 311.39,162.03 v4(311.39,162.7)
  IN3 w0.254: v2(297.04,145.68) 297.12,145.68 297.6,145.2 297.65,145.2 297.83,145.02 303.1,145.02 305.93,147.84 309.73,147.84 312.4,150.51 312.4,151.52 313.29,152.41 313.81,152.41 313.86,152.46 v4(314.03,152.46)
  BOTTOM w0.254: v4(314.03,152.46) 313.86,152.46 312.94,151.54 312.12,151.54 PC632.2
  vias: v4(310.24,163.72) v4(310.24,162.95) v4(310.24,162.32) v4(311.39,163.59)
V1N: length 70.5
  TOP w0.254: PR546.2 118.99,147.8 121.04,147.8 121.24,148 121.24,148.7 124.05,151.51 127.68,151.51 128.18,152.01 128.18,155.63 129.57,157.02 v1(129.57,157.62) v4(129.57,158.51)
  IN1 w0.254: v4(141.59,133.36) 141.71,133.36 141.91,133.17 146,133.17 147.31,134.48 147.31,134.85 148.37,135.92 148.37,138.34 147.94,138.77 147.94,151.18 145.65,153.47 144.79,153.47 142.11,156.15 136.53,156.15 135.72,155.33 v4(135.72,155.21)
  IN2 w0.254: v4(135.72,155.21) 135.05,154.53 133.9,154.53 131.54,156.9 130.59,156.9 129.57,157.91 v4(129.57,158.51)
  BOTTOM w0.254: PR516.1 v4(129.57,158.51) ; v4(135.72,155.21) 135.72,154.6 PR556.1 ; PL503.2 v4(141.59,133.36)
V1N_VGA: length 46.3
  TOP w0.254: v4(308.54,154.11) 308.8,154.11 309.08,153.83 309.08,153.25 308.35,152.53 305.72,152.53 305.21,152.02 v1(305.21,151.78) 305.21,150.95 304.72,150.45 v4(304.51,150.45)
  IN4 w0.254: v4(304.51,150.45) 304.51,148.12 302.14,145.74 300.75,145.74 299.67,144.67 288.12,144.67 284.46,148.32 284.46,148.63 284.46,152.54 285.22,153.3 286.24,153.3 286.75,153.81 v4(286.88,153.81)
  BOTTOM w0.254: PR654.1 305.16,150.89 304.73,150.45 v4(304.51,150.45) ; PL601.2 286.65,153.56 286.88,153.78 v4(286.88,153.81) ; v4(308.54,154.11) PR626.2
V1P_VGA: length 38.6
  IN4 w0.254: v4(287.64,153.81) 286.62,152.79 285.35,152.79 284.84,152.29 284.84,148.48 288.27,145.05 299.51,145.05 300.7,146.23 302.08,146.23 303.99,148.13 303.99,149.9 303.89,150 303.89,150.55 304.3,150.96 304.4,150.96 v4(304.6,151.16)
  BOTTOM w0.102: PR651.1 303.13,151.04 v1(303.58,150.6)
  BOTTOM w0.254: v4(304.6,151.16) 304.6,151.38 PR652.1 PR651.1 ; v4(287.64,153.81) 287.64,153.68 287.76,153.56 PL601.3
V2N: length 51.4
  TOP w0.254: v4(117.84,143.52) v1(121.2,146.89) 122,147.69 122,148.32 124.4,150.72 127.97,150.72 129.01,151.77 129.01,155.11 130.34,156.44 131.24,156.44 v4(131.76,155.92)
  IN2 w0.254: v4(128.89,158.51) 128.89,157.75 130.15,156.49 131.19,156.49 v4(131.76,155.92)
  IN4 w0.254: v4(117.84,143.52) 118.09,143.27 118.09,136.28 120.76,133.62 121.08,133.62 128.13,133.62 v2(128.38,133.36)
  BOTTOM w0.254: PR555.2 v4(131.76,155.92) ; v4(128.89,158.51) 128.89,159.6 PR518.1 ; PL502.2 v2(128.38,133.36) ; PR544.1 117.79,143.57 v4(117.84,143.52)
V2N_VGA: length 69.6
  TOP w0.102: v4(308.85,151.02) v1(308.85,151.65)
  IN4 w0.254: v4(286.11,163.7) 286.11,164.72 285.26,165.57 282.72,165.57 279.87,162.71 279.87,149.21 281.96,147.12 283.52,147.12 286.36,144.28 299.83,144.28 300.72,145.17 303.23,145.17 305.34,147.29 305.34,148.99 306.36,150 308.02,150 308.04,149.98 308.34,150.28 308.34,150.51 v4(308.85,151.02) 308.06,151.8 305.09,151.8 304.52,152.37 304.52,154.5 304.83,154.81 v4(304.83,155.03)
  BOTTOM w0.254: v4(286.11,163.7) 285.87,163.46 PL600.2 ; v4(304.83,155.03) PR656.2 ; v4(308.85,151.02) 308.21,151.65 PR624.1
V2P_VGA: length 66
  IN4 w0.254: v4(286.88,163.72) 286.88,164.55 285.44,165.99 282.6,165.99 279.47,162.86 279.47,148.93 281.67,146.74 283.28,146.74 286.11,143.9 299.99,143.9 300.88,144.79 303.39,144.79 305.72,147.13 305.72,147.13 305.72,148.83 306.5,149.6 308.2,149.6 v4(308.85,150.25)
  BOTTOM w0.254: PR619.1 PR623.1 307.27,151.83 v1(308.34,150.76) v4(308.85,150.25) ; v4(286.88,163.72) 286.88,163.69 287.1,163.46 PL600.3
V3N: length 69.8
  TOP w0.254: v4(119.63,147.27) 121.05,147.27 121.62,147.85 121.62,148.55 124.21,151.13 127.84,151.13 128.6,151.89 v1(128.6,153.78) 128.6,155.23 130.26,156.9 131.59,156.9 PR557.2 133.24,155.92 133.46,156.13 133.46,158.09 v4(133.55,158.18)
  IN2 w0.254: v4(133.55,158.18) 133.55,157.78 134.95,156.37 141.87,156.37 144.75,153.49 145.6,153.49 147.94,151.16 147.94,138.77 148.38,138.32 148.38,135.93 147.94,135.48 147.94,133.84 148.67,133.11 153.91,133.11 v4(154.41,133.62)
  BOTTOM w0.254: v4(133.55,158.18) 132.86,157.49 PR515.2 ; v4(119.63,147.27) 119.3,147.6 118.92,147.6 PR547.2 ; PL501.2 v4(154.41,133.62)
VCC_PGOOD: length 3.2
  BOTTOM w0.203: PU500.3 117.24,154.23
  BOTTOM w0.254: 116.98,153.96 116.67,153.96 PR522.2 ; 116.98,153.96 v1(116.98,153.86) ; 116.98,153.96 117.24,154.23
VCCPWRGOOD_0_R: length 13.5
  TOP w0.102: RC33.2 RC56.1 137.4,122.75 137.4,119.05 v3(140.88,115.56) 141.67,114.78 141.67,112.99 v2(141.73,112.92)
  BOTTOM w0.089: v2(141.73,112.92) JCPU1.AL34
VCCSENSE: length 67.3
  TOP w0.254: PC545.1 v1(117.7,160.49) v4(117.01,161.18)
  IN4 w0.254: v4(117.01,161.18) 117.2,161.18 117.58,160.79 117.58,159.05 115.43,156.89 115.43,156.57 115.43,151.3 113.31,149.18 113.31,148.93 113.31,148.93 113.31,146.78 115.17,144.92 115.17,129.84 115.17,129.68 121.27,123.58 134.73,123.58 136.38,121.93 136.38,121.48 v2(136.14,121.23)
  BOTTOM w0.254: RC91.2 135.49,121.81 136.06,121.23 v2(136.14,121.23) 136.14,120.99 136,120.85 136,120.48 RC92.2 ; 117.01,161.16 117,161.16 117,161.18 117.2,161.38 PC541.2 PR540.2 ; 117.01,161.16 v4(117.01,161.18) ; 117.01,161.16 117.2,160.97 PR531.1
VCCSENSE_R: length 10
  BOTTOM w0.254: RC92.1 135.86,118.69 v1(135.86,118.1) 135.86,117.8 136.37,117.28 139.12,117.28 140.95,115.46
  BOTTOM w0.305: 140.95,115.46 142.2,114.21 JCPU1.AL35
VDD_1.35V: length 11.3
  TOP w0.102: v1(206.52,19.13) PC210.1
  TOP w0.254: PC210.1 PR203.2 210.4,19.99 v4(210.4,20.1) ; PR201.1 v4(212.2,16.65) 211.22,15.67 PU200.11
  IN1 w0.254: v4(212.2,16.65) 210.4,18.45 v4(210.4,20.1)
VDDCI_VID: length 1.6
  BOTTOM w0.102: v1(248.46,136.54) v2(247.67,136.54) 247.42,136.79 RV64.1
VSSSENSE: length 66.8
  TOP w0.254: PC546.2 120.76,157.06 120.76,157.57 120.56,157.77 120.56,157.96 120.07,158.44 v4(119.88,158.44) 119.24,159.09 PC545.2
  IN4 w0.254: v4(119.88,158.44) 119.53,158.8 118.06,158.8 115.93,156.68 115.93,151.09 113.82,148.97 113.82,148.72 113.81,148.72 113.81,147 115.68,145.13 115.68,129.89 121.48,124.09 134.94,124.09 136.89,122.14 136.89,121.42 136.91,121.4 v2(136.91,121.22)
  BOTTOM w0.203: PU500.13 120.45,157.42 120.54,157.51 v1(120.54,158.22) 120.32,158.44 v4(119.88,158.44)
  BOTTOM w0.254: RC93.2 136.38,120.1 136.38,120.69 v2(136.91,121.22) 136.91,121.45 RC94.1
VSSSENSE_R: length 10.1
  BOTTOM w0.254: 142.76,114.42 142.76,114.44 141.18,116.01 141.17,116.01 139.39,117.79 v1(137.71,117.79) 136.65,117.79 136.37,118.07 136.37,118.92 RC93.1
  BOTTOM w0.305: JCPU1.AK35 143.01,113.65 143.01,114.18 142.76,114.42
3301_ACAV_IN_NB: length 3.1
  TOP w0.254: PU800.24 151.25,171.21 151.16,171.29 v1(151.16,171.92) 151.16,172.91 151.24,172.99 PR855.1
3301_DSCHRG_FET_GC: length 36.4
  TOP w0.254: PR893.1 144.74,168.92 144.32,169.34 144.32,173.25 143.48,174.09 143.48,179.5 144.06,180.09 144.59,180.09 146.33,181.83 146.33,182.02 147.19,182.88 147.19,187.08 144.15,190.12 v1(137.78,190.12) 136.62,190.12 134.68,188.18 PR892.2
+BATT_SUM:
  vias: v1(124.38,182.07) v2(244.84,82.37) v2(244.94,83.01) v2(245.47,82.37) v2(245.58,83.01) v2(246.06,82.58) v2(246.2,83.15) v2(278.77,147.56) v2(278.75,146.98) v2(279.38,147.55) v2(279.4,146.96) v2(279.98,147.55) v2(279.99,146.96) v4(118.09,180.23) v4(118.09,179.59) v4(118.09,178.96) v4(118.85,180.23) v4(118.85,179.59) v4(118.85,178.96) v4(119.62,180.23) v4(119.62,179.59) v4(119.62,178.96) v4(120.38,180.23) v4(120.38,179.59) v4(120.38,178.96) v4(121.14,180.23) v4(121.14,179.59) v4(121.14,178.96) v4(121.9,180.23) v4(121.9,179.59) v4(121.9,178.96) v4(146.41,189.24) v4(146.41,188.61) v4(147.18,189.24) v4(147.18,188.61) v4(167.62,186.07) v4(168.38,186.07) v4(169.02,185.69) v4(271.03,191) v4(271.58,190.46) v4(271.93,191) v4(272.26,190.4) v4(272.56,191.01) v4(273.26,191.02)
+BL_PWR_SRC: length 2.6
  BOTTOM w0.102: Q21.1 180.73,148.73 181.03,149.03 181.23,149.03 181.75,149.54 181.75,150.43 v3(181.72,150.46)
+CAMERA_VDD: length 2.1
  TOP w0.102: Q23.1 192.78,166.09 192.79,166.09 193.63,166.93 v3(193.63,167.68)
  vias: v2(192.77,164.64) v2(193.39,164.63)
+CAP_LDO: length 10.2
  TOP w0.102: v1(256.08,52.91) C714.1
  TOP w0.254: U46.B46 264.17,51.14 v2(264.26,51.22)
  TOP w0.508: v2(258.64,51.08) 258.58,51.14 258.58,51.98 257.67,52.9 C714.1
  IN2 w0.508: v2(258.64,51.08) 258.67,51.1 262.3,51.1 262.41,51.22 v2(264.26,51.22)
+CHGR_DC_IN: length 86.3
  TOP w0.102: v4(84.88,187.59) 84.88,187.68 85.33,188.12 v1(85.33,188.35)
  TOP w0.508: PR833.1 v2(146.22,165.25) ; PR708.1 v4(84.88,187.59)
  IN2 w0.508: v4(84.88,187.59) 84.88,188.62 87.13,190.87 97.49,190.87 98.44,189.92 103.11,189.92 106.99,186.03 113.08,186.03 114.31,184.8 120.32,184.8 121.05,185.53 137.55,185.53 137.9,185.18 137.9,182.98 141.28,179.6 v2(144.27,179.6)
  IN4 w0.508: v2(146.22,165.25) 146.22,166.3 145.78,166.75 145.78,169.21 145,169.98 145,172.99 145.8,173.79 145.8,178.07 v2(144.27,179.6)
+COINCELL: length 4.6
  BOTTOM w0.508: JRTC1.1 322.08,152.23 322.47,152.62 v1(322.47,154.48) PR1.1
+DC1_PWR_SRC:
  vias: v1(140.7,7.63) v4(140.19,11.44) v4(140.19,10.81) v4(140.32,9.92) v4(140.32,9.16) v4(141.08,9.92) v4(141.08,9.16) v4(141.84,9.92) v4(141.84,9.16) v4(149.59,9.41) v4(163.3,9.54) v4(163.43,8.78) v4(163.94,12.97) v4(164.07,9.54) v4(164.18,8.8) v4(164.7,12.97) v4(164.7,9.54) v4(164.82,8.8) v4(165.34,9.54) v4(165.45,8.8) v4(166.09,8.81) v4(166.73,8.78)
+DC_IN: length 65.3
  TOP w0.254: v2(148.06,159.47) 147.68,159.85 PR835.1 ; v2(104.03,164.68) 104.03,164.01 103.23,163.21 PR732.1
  IN1 w0.254: v2(147.14,167.8) 146.2,167.8 145.07,168.94 139.79,168.94 137.82,166.96 v2(136.54,166.96)
  IN3 w0.254: v2(136.54,166.96) 134.73,165.15 122.57,165.15 121.97,165.75 112.63,165.75 109.93,168.45 103.39,168.45 v2(102.78,169.06)
  IN4 w0.254: v2(148.06,159.47) 147.58,159.96 147.58,166.56 147.14,167 v2(147.14,167.8) ; v2(104.03,164.68) 104.03,167.74 102.78,169 v2(102.78,169.06)
  vias: v3(135.26,162.37) v3(136.3,160.64) v3(137.42,162.47)
+DC_IN_SS: length 105.9
  TOP w0.102: v3(50.02,180.89) 50.53,180.38 51.14,180.38
  TOP w0.508: PR831.1 144.28,166.05 v2(144.76,165.57) ; v2(89.52,169.42) 89.48,169.46 88.44,169.46 87.63,168.64 87.63,167.78 87.29,167.45 PD701.3
  IN1 w0.508: v2(52.24,179.26) 52.26,179.25 52.26,177.58 53.91,175.93 57.6,175.93 58.96,177.29 60.3,177.29 60.85,176.73 69.16,176.73 69.94,175.95 82.3,175.95 88.71,169.54 89.39,169.54 v2(89.52,169.42) 89.52,169.29 91.59,167.21 98.9,167.21 99.07,167.04 100.92,167.04 101.18,167.3 122.09,167.3 v4(122.54,167.75)
  IN3 w0.508: v2(144.76,165.57) 144.43,165.9 144.43,166.32 145.17,167.06 145.17,168.26 144.88,168.55 135.5,168.55 134.25,167.31 128.32,167.31 v4(127.86,167.77)
  vias: v4(122.54,168.41) v4(123.3,168.41) v4(123.3,167.75) v4(124.06,168.41) v4(124.06,167.75) v4(124.82,168.41) v4(125.59,168.41) v4(126.35,168.41) v4(127.11,168.41) v4(127.1,167.77) v4(127.87,168.41)
+DCIN: length 2
  BOTTOM w0.508: v4(81.33,186.13) 81.9,186.13 82.66,185.37 PR742.2
  vias: v1(80.81,186.83)
+DCIN_JACK: length 1.5
  TOP w0.102: 135.67,177.63 v3(135.67,179.13)
  vias: v3(135.71,177.25) v3(137.49,177.23) v4(135.87,176.29) v4(135.87,175.53) v4(136.51,176.29) v4(136.51,175.53) v4(137.27,176.29) v4(137.27,175.53) v4(138.03,176.29) v4(138.03,175.53) v4(138.67,176.29) v4(138.67,175.53) v4(139.3,176.29) v4(139.3,175.53)
+DDR_CHG: length 3.6
  TOP w0.102: v1(190.47,17.53) R927.2
  TOP w0.508: Q72.1 189.55,18.82 189.02,18.3 R927.2
+DIMM1_VREF_CA: length 22.8
  TOP w0.508: RD13.2 165.72,25.07 165.25,25.54 v1(163.72,25.54) 162.97,24.79 CD16.1 CD15.1 RD5.2 v2(162.97,21.01)
  IN3 w0.508: v2(162.97,21.01) 162.97,27.53 164.93,29.49 v2(165.71,29.49)
  BOTTOM w0.356: JDIMM1.126 162.8,29.73 163.05,29.48 165.7,29.48 v2(165.71,29.49)
+DIMM1_VREF_DQ: length 7.8
  TOP w0.102: CD1.1 123,39.36 v1(123.17,39.53)
  TOP w0.508: RD3.2 RD1.2 CD2.1 ; CD2.1 CD1.1 ; CD2.1 122.05,38.59 v2(121.66,38.98)
  BOTTOM w0.356: JDIMM1.1 122.9,38.28 122.65,38.03 122.15,38.03 121.66,38.52 v2(121.66,38.98)
+DIMM2_VREF_CA: length 7
  TOP w0.127: v1(164.03,19.35) RD10.2
  TOP w0.508: RD23.2 CD37.1 163.18,16.29 v2(163.25,16.36) 163.13,16.47 CD38.1 163.13,17.3 164.03,18.2 RD10.2
  BOTTOM w0.356: JDIMM2.126 162.8,16.8 v2(163.25,16.36)
+DIMM2_VREF_DQ: length 8.2
  TOP w0.102: v1(121.55,23.58) 121.81,23.85 v2(121.81,24.47)
  TOP w0.508: RD8.2 CD23.1 ; CD23.1 RD9.2 ; CD23.1 CD24.1 123.67,25.06 123.43,25.3 123.28,25.3 123.27,25.31 122.65,25.31 v2(121.81,24.47)
  BOTTOM w0.356: JDIMM2.1 122.9,25.38 122.55,25.03 122.37,25.03 v2(121.81,24.47)
+DOCK_PWR_BAR: length 69.4
  TOP w0.508: PD701.2 85.96,168.75 85.82,168.88 v2(85.81,168.88) ; v2(144.36,167.94) 144.45,168.03 PR832.1 ; v2(115.43,168.52) v1(116.39,169.48) 116.96,170.05 116.96,170.65 118.58,172.27 v2(118.58,172.61) 118.92,172.61 119.63,173.32 PR814.2
  BOTTOM w0.508: v4(157.34,185.05) 156.55,184.26 156.49,184.26 152.88,180.66 146.54,180.66 144.98,179.1 144.98,171.89 144.36,171.27 v2(144.36,167.94) ; v2(115.43,168.52) 110.8,168.52 105.85,163.56 97.44,163.56 96.92,163.04 92.49,163.04 87.28,168.26 86.45,168.26 85.82,168.88 v2(85.81,168.88)
  vias: v4(115.91,184.06) v4(115.91,183.43) v4(115.95,182.75) v4(116.57,184.11) v4(116.57,183.48) v4(116.61,182.8) v4(117.31,184.12) v4(117.31,183.49) v4(117.34,182.82) v4(118,184.12) v4(118,183.49) v4(118.69,184.14) v4(118.69,183.5) v4(157.36,187.34) v4(157.34,186.58) v4(157.34,185.81) v4(157.39,188.86) v4(157.39,188.1) v4(157.97,186.19) v4(157.97,185.43) v4(158,189.27) v4(158,188.48) v4(158,187.72) v4(158,186.96) v4(158.63,188.99) v4(158.63,188.1) v4(158.63,187.34) v4(158.61,186.58) v4(158.61,185.81) v4(158.61,185.05)
+GPU_CORE: length 108
  TOP w0.381: PC954.1 223.95,127.22 v2(223.45,126.72) ; v2(217.5,136.68) 217.2,136.38 PCV183.1 ; PC929.1 221.1,127.23 v2(220.59,127.74) ; PC960.1 227.16,126.3 226.82,126.64 v2(226.45,126.64) ; PC950.1 223.9,131.15 v2(223.43,130.68) ; v2(226.5,129.64) 226.25,129.38 PC967.1 ; v2(227.52,134.6) 228.01,134.12 PC959.1 ; v2(224.58,127.79) 225.02,127.35 PC953.1
  TOP w0.508: v2(219.52,130.73) 219.52,130.72 219.96,130.27 PC931.1 ; PC969.1 218.08,133.21 v2(218.6,133.73) ; PC947.1 222.18,129.2 v2(222.65,129.68) ; PC955.1 222.11,135.17 v2(222.64,135.7) ; PC968.1 223.85,133.21 223.41,132.77 v2(223.41,132.72) ; v2(226.6,131.75) 226.07,131.21 PC951.1 ; PC945.1 222.18,131.2 222.68,131.71 v2(222.69,131.71) ; v2(222.62,133.66) 222.14,133.19 PC944.1 221.99,133.13 PC930.1 PC932.1 ; v2(224.61,135.73) 224.08,135.2 PC956.1 ; PC946.1 224.04,129.18 v2(224.57,129.71) ; PC952.1 226.03,133.18 v2(226.55,133.7) ; v2(221.43,128.68) 221.42,128.68 220.97,129.13 PC928.1 ; PC934.1 219.88,128.26 219.43,128.71 v2(219.41,128.71) ; v2(222.64,127.71) 222.13,127.2 PC948.1 ; v2(221.44,130.72) 220.91,131.24 PC927.1 ; v2(219.46,132.71) 219.46,132.59 219.83,132.22 PC933.1 ; v2(228.6,129.74) 228.22,130.12 PC958.1 227.69,130.84 v2(227.53,130.69)
  BOTTOM w0.381: UV1.AG18 228.05,133.13 v2(227.53,132.62) 227.47,132.62 UV1.AF20 226.99,132.2 226.6,131.81 v2(226.6,131.75) 226.6,131.75 UV1.AD21 225.96,131.2 225.47,130.7 225.46,130.7 ; v2(227.53,130.69) 227.05,130.21 UV1.AF22 227.05,130.19 v2(226.5,129.64) 226.06,129.2 UV1.AD23 225.94,129.2 225.05,128.31 UV1.AC24 225.01,128.2 224.58,127.76 ; UV1.AD16 225.99,135.2 v2(225.51,135.67) 225.05,136.13 UV1.AC15 ; UV1.R26 218.05,127.2 v2(218.58,127.72) 219.05,128.19 UV1.T24 219.05,128.35 v2(219.41,128.71) 219.56,128.71 UV1.U23 UV1.V22 221.05,130.33 v2(221.44,130.72) 221.91,131.2 UV1.Y21 222.17,131.2 222.68,131.71 v2(222.69,131.71) 222.69,131.71 222.69,131.72 223.05,132.07 UV1.AA20 223.05,132.3 223.41,132.65 v2(223.41,132.72) 223.57,132.72 UV1.AB18 224.09,133.2 v2(224.62,133.73) 225.05,134.16 UV1.AC17 ; v2(221.62,137.7) 222.05,137.28 UV1.Y13 UV1.AA13 223.18,137.07 223.92,137.07 UV1.AB13 UV1.AC12 ; UV1.M26 UV1.N24 v2(217.55,128.69) UV1.R23 218.07,129.2 v2(218.62,129.74) 218.66,129.79 218.66,129.81 219.05,130.2 UV1.T22 219.05,130.26 v2(219.52,130.73) 219.58,130.73 220.04,131.2 UV1.U21 UV1.V20 UV1.Y18 222.15,133.2 v2(222.62,133.66) 223.05,134.1 UV1.AA17 223.46,134.61 223.46,134.66 v2(223.45,134.67) 223.97,135.2 UV1.AB16 224.59,135.73 v2(224.61,135.73) 224.61,135.76 UV1.AC15 ; UV1.AC15 225.29,136.44 225.29,136.44 225.45,136.6 v2(225.52,136.6) 226.05,137.13 UV1.AD13 ; UV1.Y28 222.05,125.2 v2(222.5,125.65) 223.05,126.2 UV1.AA27 223.45,126.6 v2(223.45,126.72) 223.93,127.2 UV1.AB26 224.05,127.23 224.58,127.76 ; 222.61,129.68 223.05,130.12 UV1.AA22 223.05,130.3 v2(223.43,130.68) 223.95,131.2 UV1.AB21 224.53,131.68 v2(224.53,131.73) 225,132.2 UV1.AC20 225.05,132.29 225.41,132.65 v2(225.41,132.71) 225.89,133.2 UV1.AD18 226.05,133.21 226.54,133.7 v2(226.55,133.7) 226.55,133.71 227.03,134.2 UV1.AF17 227.05,134.26 227.39,134.6 v2(227.52,134.6) 227.56,134.64 227.56,134.77 227.99,135.2 UV1.AG16 ; 222.61,129.68 222.53,129.68 222.05,129.2 UV1.Y23 221.94,129.2 v2(221.43,128.68) 221.05,128.3 UV1.V24 221.05,128.18 220.59,127.73 ; 222.61,129.68 v2(222.65,129.68) ; 225.46,130.7 v2(225.46,130.7) ; 225.46,130.7 225.46,130.69 225.05,130.28 UV1.AC22 225.04,130.2 224.57,129.73 v2(224.57,129.71) 224.56,129.71 224.05,129.21 UV1.AB23 224.05,129.08 223.66,128.7 v2(223.43,128.7) 223.43,128.57 223.06,128.2 UV1.AA24 223.05,128.12 v2(222.64,127.71) 222.63,127.71 222.11,127.2 UV1.Y26 222,127.2 221.54,126.73 221.54,126.68 UV1.V27 ; v2(220.59,127.74) 220.59,127.73 ; 220.59,127.73 220.06,127.2 UV1.U26 v2(219.53,126.67) ; 219.47,132.71 219.47,132.72 219.95,133.2 UV1.U18 220.07,133.2 220.61,133.73 220.61,133.74 221.05,134.19 UV1.V17 221.05,134.23 v2(221.47,134.65) 222.01,135.2 UV1.Y16 222.05,135.21 222.54,135.7 v2(222.64,135.7) 223.05,136.11 UV1.AA15 ; 219.47,132.71 219.05,132.29 UV1.T20 219.02,132.2 v2(218.59,131.77) 218.05,131.23 UV1.R21 ; 219.47,132.71 v2(219.46,132.71) ; UV1.U16 UV1.T17 219.05,134.18 v2(218.6,133.73) 218.59,133.73 UV1.R18 ; v2(221.6,136.71) 221.6,136.71 221.08,136.2 UV1.V15 ; UV1.M23 216.06,129.2 216.58,129.71 v2(216.6,129.71) ; UV1.M18 UV1.N17 UV1.R16 218.05,135.2 218.48,135.63 v2(218.61,135.63) 219.05,136.07 UV1.T15 ; v2(228.48,126.69) 228.48,126.58 228.87,126.2 UV1.AH27 UV1.AH28 ; v2(217.45,132.69) 217.05,132.29 UV1.N20 ; v2(228.6,129.74) 228.61,129.74 229.05,130.18 UV1.AH22 ; UV1.AB28 224.05,125.2 v2(224.56,125.71) 225.04,126.2 UV1.AC27 225.15,126.2 225.6,126.64 ; 224.58,127.76 v2(224.58,127.79) ; UV1.N22 217.05,130.31 v2(217.42,130.68) ; 225.6,126.64 v2(225.63,126.64) ; 225.6,126.64 225.6,126.71 226.05,127.16 UV1.AD26 226.45,126.8 v2(226.45,126.64)
  vias: v3(254.74,153.28) v4(246.92,158.97) v4(246.97,158.23) v4(246.97,157.47) v4(247.02,163.69) v4(247.02,162.8) v4(247.05,161.86) v4(247.02,160.77) v4(247,159.83) v4(247.12,156.68) v4(247.33,155.94) v4(247.66,158.97) v4(247.63,147.21) v4(247.73,163.68) v4(247.73,162.79) v4(247.76,161.85) v4(247.73,160.76) v4(247.71,159.84) v4(247.71,158.18) v4(247.68,157.49) v4(247.7,155.22) v4(247.81,156.65) v4(247.81,147.87) v4(247.93,148.63) v4(248.14,155.92) v4(248.1,154.37) v4(248.37,155.18) v4(248.37,147.15) v4(248.39,163.66) v4(248.39,162.78) v4(248.42,161.84) v4(248.39,160.74) v4(248.39,159.84) v4(248.39,157.42) v4(248.43,149.67) v4(248.52,158.98) v4(248.52,158.15) v4(248.52,156.68) v4(248.57,148.09) v4(248.6,153.5) v4(248.67,152.03) v4(248.6,150.43) v4(248.64,148.97) v4(248.74,154.37) v4(248.75,152.79) v4(248.69,151.18) v4(248.93,155.92) v4(249.06,159.79) v4(249.08,163.66) v4(249.08,162.78) v4(249.11,161.84) v4(249.08,160.74) v4(249.13,157.39) v4(249.08,155.23) v4(249.11,149.57) v4(249.18,158.93) v4(249.18,158.1) v4(249.23,153.5) v4(249.31,156.65) v4(249.37,152.01) v4(249.33,151.14) v4(249.31,150.38) v4(249.28,148.95) v4(249.33,148.17) v4(249.51,154.37) v4(249.61,152.82) v4(249.74,163.64) v4(249.74,162.75) v4(249.77,161.81) v4(249.74,160.72) v4(249.69,155.92) v4(249.79,159.83) v4(249.79,155.24) v4(249.83,149.64) v4(249.92,158.97) v4(249.92,158.14) v4(249.92,157.38) v4(249.94,153.48) v4(250.02,156.65) v4(250.06,151.96) v4(250,151.23) v4(250.02,150.41) v4(250.03,148.93) v4(250.3,154.29) v4(250.45,155.97) v4(250.48,155.24) v4(250.4,152.79) v4(250.63,151.24) v4(250.62,149.59) v4(250.68,153.48) v4(250.76,152.13) v4(250.68,150.36) v4(265.86,164.54) v4(265.86,163.91) v4(265.86,163.27) v4(265.86,162.64) v4(265.86,162) v4(265.89,160.49) v4(265.89,159.85) v4(265.89,159.22) v4(265.89,158.58) v4(265.89,157.95) v4(266.07,153.68) v4(266.07,153.05) v4(266.07,152.41) v4(266.07,151.78) v4(266.07,151.14) v4(266.5,164.54) v4(266.5,163.91) v4(266.5,163.27) v4(266.5,162.64) v4(266.5,162) v4(266.52,160.49) v4(266.52,159.85) v4(266.52,159.22) v4(266.52,158.58) v4(266.52,157.95) v4(266.71,153.68) v4(266.71,153.05) v4(266.71,152.41) v4(266.71,151.78) v4(266.71,151.14)
+LCDVDD:
  vias: v2(174.18,167.32) v2(174.28,166.74) v2(174.72,167.58) v2(174.81,168.19) v2(174.81,166.99) v3(174.46,169.99)
+LOM_VCT: length 5
  TOP w0.102: C701.1 198.78,189.32 v1(198.92,189.18)
  TOP w0.508: v2(198.01,190.13) 197.72,189.84 C701.1
  BOTTOM w0.254: JDOCK1.118 198.25,189.9 v2(198.01,190.13) 197.75,189.87 JDOCK1.116
+MBATT: length 161.1
  TOP w0.102: v2(237.14,97.6) v1(237.9,97.6)
  TOP w0.508: PR842.1 162.67,167.76 v4(162.61,167.7)
  IN2 w0.508: v2(167.09,147.33) 169.06,147.33 170.43,148.7 173.67,148.7 175,147.37 v2(175.97,147.37)
  IN3 w0.508: v2(237.14,97.6) 236.33,97.6 235.52,96.79 223.81,96.79 220.92,99.67 219.72,99.67 216.42,102.97 205.81,102.97 204.17,104.61 195.44,104.61 195.32,104.5 187.69,104.5 187.52,104.33 182.82,104.33 181.96,105.19 181.96,107.91 180.58,109.3 180.58,111.28 176.49,115.37 176.49,121.03 177.2,121.74 177.2,131.86 178.43,133.1 178.43,134.62 177.78,135.27 177.78,140.96 178.94,142.11 178.94,143.43 175.97,146.4 v2(175.97,147.37)
  IN4 w0.508: v2(167.09,147.33) 166.66,147.33 165.88,148.11 165.88,160.13 164.31,161.71 164.31,163.55 162.61,165.24 v4(162.61,167.7)
  BOTTOM w0.508: v2(241.55,79.72) 242.03,80.2 242.03,86.61 241.22,87.43 241.22,94.67 238.29,97.6 v2(237.14,97.6)
+MBATT_C:
  vias: v1(240.51,73.58) v4(237.75,74.83) v4(238.07,75.39) v4(238.18,76.17) v4(238.44,76.76) v4(238.54,74.78) v4(238.64,75.69)
+MBATT_C2: length 2.4
  TOP w0.102: PR842.2 162.67,169.16 163.2,168.63 163.2,167.33 v1(162.99,167.12)
+MIC1_VREF_OUT: length 5.4
  TOP w0.102: v2(346.82,170.41) 346.82,170.81 346.5,171.13 345.23,171.13 345.19,171.09 U74.30
  BOTTOM w0.254: v2(346.82,170.41) 346.82,170.68 346.69,170.8 D12.2 D11.2
+MPBATT_IN_SS: length 226.1
  TOP w0.508: PR806.1 241.36,86.21 v2(241.03,86.54) ; v2(175.78,113.4) 173.55,115.62 v1(173.55,117.36) 173.55,120.18 172.91,120.83 v2(170.49,120.83) ; v2(220.25,100.77) 221.27,100.77 225.2,96.84 230.27,96.84 231.66,95.45 244.83,95.45 PD802.2
  IN2 w0.508: v2(241.03,86.54) 242.18,86.54 244.34,88.7 249.27,88.7 250.99,90.41 v2(250.99,91)
  IN3 w0.508: v2(158.9,176.86) 158.9,176.28 158.53,175.91 158.05,175.91 155.61,173.47 155.13,173.47 153.48,171.82 153.48,171.25 151,168.77 150.14,168.77 149.16,167.79 149.16,166.93 146.12,163.89 146.09,163.89 145.99,163.79 141.75,163.79 141.07,164.48 138.41,164.48 137.15,165.74 137.15,167.21 136.79,167.57 135.41,167.57 133.61,165.77 122.8,165.77 119.62,168.96 119.62,170.96 119.19,171.39 118.55,171.39 117.85,172.09 v4(117.85,172.64)
  IN4 w0.508: v2(158.9,176.86) 159.19,176.86 160.42,175.62 160.42,172.26 161.46,171.22 161.46,164.95 163.23,163.19 163.23,161.29 164.87,159.65 164.87,129.96 167.81,127.01 167.81,123.33 170.32,120.83 v2(170.49,120.83) ; v2(175.78,113.4) 176.13,113.4 179.83,109.7 181.63,109.7 182.16,109.17 183.09,109.17 184.58,110.65 189.15,110.65 189.86,109.94 189.86,107.86 190.42,107.3 198.69,107.3 203.96,102.03 214.87,102.03 216.12,100.77 v2(220.25,100.77)
  BOTTOM w0.508: PD809.2 117.91,172.7 v4(117.85,172.64)
+NBDOCK_DC_IN_SS: length 320.9
  TOP w0.254: PQ801.1 238.77,92.65 v2(238.77,90.56)
  TOP w0.508: v2(156.74,179.46) 156.51,179.23 156.51,178.42 156.74,178.19 PQ823.1 ; v2(72.56,180.34) 71.97,179.74 64.9,179.74 v1(64.63,179.47) v2(61.55,179.47) ; v2(49.78,177.08) 49.78,175.01 50.2,174.59 PQ814.3 52.01,174.59 52.4,174.97 PR827.2
  IN2 w0.508: v2(156.74,179.46) 151.62,179.46 149.31,177.15 147.24,177.15 145.22,175.13 145.22,173.95 143.09,171.82 130.87,171.82 130.56,172.12 122.98,172.12 122.68,172.43 120.79,172.43 120.08,171.72 117.76,171.72 116.59,170.55 113.12,170.55 112.7,170.13 91.7,170.13 90.64,171.2 89.56,171.2 87.63,173.13 87.23,173.13 82.58,177.77 77.62,177.77 76.93,178.46 73.63,178.46 72.56,179.53 v2(72.56,180.34)
  IN3 w0.508: v2(170.9,154.32) 170.9,151.99 172.32,150.57 172.32,135.47 171.71,134.86 171.71,132.98 172.37,132.33 173.41,132.33 174.14,131.59 174.14,130.98 175.79,129.34 175.79,122.12 175.22,121.55 175.22,114.85 179.31,110.76 179.31,107.71 178.67,107.07 178.67,104.83 179.66,103.84 179.66,102.98 180.06,102.58 180.06,98.04 181.29,96.81 186.36,96.81 187.27,95.9 187.27,88.15 187.97,87.45 196.9,87.45 202.41,92.96 202.41,97.56 203.75,98.91 213.68,98.91 216.7,95.88 218.34,95.88 222.17,92.05 226.86,92.05 227.87,91.03 231.2,91.03 231.94,91.77 237.87,91.77 238.77,90.87 v2(238.77,90.56) ; v2(165.55,177.62) 168.09,177.62 171.08,180.61 172.58,180.61 172.83,180.86 173.57,180.86 174.08,181.37 174.61,181.37 175.15,181.91 175.15,182.17 175.65,182.67 176.74,182.67 177.11,182.3 v2(177.11,182.19)
  IN4 w0.508: v2(156.74,179.46) 157.32,178.88 163.06,178.88 164.05,177.89 165.24,177.89 165.5,177.62 v2(165.55,177.62) 165.71,177.62 166.57,176.76 166.57,170.14 167.38,169.33 167.38,167.47 169.79,165.06 169.79,162.71 170.02,162.48 170.02,155.19 v2(170.9,154.32) ; v2(49.78,177.08) 53.27,177.08 55.98,179.79 61.23,179.79 v2(61.55,179.47)
  BOTTOM w0.254: JDOCK1.41 177.25,182.05 v2(177.11,182.19)
+PBATT: length 178.6
  TOP w0.102: v2(147.16,179.84) v1(147.16,180.97)
  TOP w0.508: PR896.1 39.62,176.06 38.87,175.31 PQ820.3 39.28,174.24 40.5,173.02 41.6,173.02 43.71,175.13 43.71,187.81 43.58,187.93 43.58,194.6 v2(43.59,194.61) ; PR837.1 161.65,167.28 v4(160.77,166.4) ; v4(146.27,170.51) 145.63,170.51 145.19,170.08 PR838.1
  IN1 w0.508: v2(113.37,184.63) 112.5,185.5 106.87,185.5 104.31,188.05 104.31,188.72 103.51,189.52 99.17,189.52 98.42,190.27 89.94,190.27 89.54,189.88 78.68,189.88 76.92,188.11 73,188.11 66.18,194.93 43.91,194.93 v2(43.59,194.61)
  IN2 w0.508: v2(113.37,184.63) 114.27,183.73 114.27,183.5 115.82,181.95 119.85,181.95 122.27,184.38 123.54,184.38 123.96,183.96 123.96,181.01 124.48,180.49 129.51,180.49 131.95,182.93 v4(132.34,182.93) ; v4(136.63,182.51) 137.78,181.37 138.51,181.37 140.95,178.93 146.25,178.93 v2(147.16,179.84)
  BOTTOM w0.508: v2(147.16,179.84) 146.93,179.84 145.63,178.54 145.63,170.81 145.93,170.51 v4(146.27,170.51) 146.27,167.81 148.59,165.49 153.41,165.49 154.29,166.38 154.29,166.38 154.66,166.75 157.47,166.75 159.26,164.96 159.94,164.96 160.77,165.79 v4(160.77,166.4)
  vias: v4(132.34,184.84) v4(132.34,184.2) v4(132.34,183.57) v4(132.34,182.3) v4(132.34,181.53) v4(133.08,181.62) v4(133.1,184.84) v4(133.1,184.2) v4(133.1,183.57) v4(133.1,182.93) v4(133.1,182.3) v4(135.87,184.8) v4(135.87,184.04) v4(135.87,183.27) v4(135.87,182.51) v4(135.87,181.88) v4(136.63,183.27)
+PBATT_C:
  vias: v1(127.3,182.36) v4(124.07,188.32) v4(124.58,187.77) v4(124.96,188.32) v4(125.34,187.77) v4(125.73,188.32) v4(126.03,182.7) v4(126.01,182) v4(126.11,187.77) v4(126.23,184.66) v4(126.2,184) v4(126.49,188.32) v4(126.75,182.7) v4(126.73,182) v4(126.96,184) v4(127,184.66)
+PBATT_C2:
  vias: v1(161.74,170.32)
+PBATT_IN_SS:
  vias: v1(133.71,179.72) v4(130.92,179.46) v4(130.92,178.83) v4(130.92,178.19) v4(130.92,177.56) v4(131.57,177.55) v4(131.68,179.46) v4(131.68,178.83) v4(131.68,178.19) v4(132.32,179.46) v4(132.32,178.83) v4(132.32,178.19) v4(132.32,177.56) v4(132.95,179.46) v4(132.95,178.83) v4(132.95,178.19) v4(132.95,177.56) v4(133.59,178.83) v4(133.59,178.19)
+PCH_DCPRTC: length 1.8
  TOP w0.508: CH54.1 207.64,67.35 v2(207.92,67.64)
  BOTTOM w0.254: UH1.P14 207.87,67.59 v2(207.92,67.64) 207.97,67.68 UH1.P16
+PCH_USB_DCPSUS1: length 9.8
  TOP w0.089: v1(201.23,65.27) 201.27,65.27 201.92,65.92 CH39.1
  TOP w0.254: CH39.1 202.37,65.57 202.64,65.57 203.13,66.06 203.33,66.06 204.82,67.55 204.89,67.55 205.2,67.86 205.87,67.86 v2(205.87,67.87)
  TOP w0.305: RH234.2 206.35,69.73 205.93,69.3 205.93,68.72 206.09,68.55 206.09,68.16 205.87,67.94 v2(205.87,67.87)
  BOTTOM w0.254: v2(205.87,67.87) 205.87,68.26 UH1.Y12
+PCH_USB_DCPSUS2: length 5.5
  TOP w0.254: v2(212.84,74.92) 212.84,74.95 213.34,75.45 v1(213.34,75.7) 213.34,76.09 213.76,76.5 213.76,76.96 CH58.1 215.44,78.64 RH239.2
  BOTTOM w0.254: v2(212.84,74.92) 212.74,75.02 212.39,75.02 UH1.Y35
+PCH_USB_DCPSUS3: length 5.2
  TOP w0.254: CH42.1 205.65,77.92 205.65,77.97
  TOP w0.508: CH42.1 207.39,75.74 207.39,75.06 v2(207.64,74.81)
  BOTTOM w0.254: UH1.AJ28 207.7,74.86 v2(207.64,74.81) 207.59,74.75 UH1.AJ26
  vias: v1(207.12,81.04)
+PCH_VCC: length 9.4
  BOTTOM w0.102: RH241.2 213.21,90.13 v1(213.52,90.13)
  BOTTOM w0.254: CH64.1 211.51,86.94 211.51,86.23 211.67,86.07 211.67,82.59 211.47,82.39 211.47,82.38 UH1.AP45
  BOTTOM w0.508: CH64.1 211.61,87.4 211.3,87.72 CH63.1 211.8,88.67 RH241.2
+PCH_VCCCFUSE: length 39.3
  TOP w0.508: v2(218.61,63.08) 218.8,63.27 RH243.2 RH242.2 221.38,61.59 221.38,60.43 221.82,59.99 221.82,58.86 218.08,55.12 218.08,54.37 218.07,54.36 218.07,54.26 v1(217.22,53.41) 216.41,52.6 215.87,52.6 215.58,52.9 v2(215.58,53.38) ; v2(217.07,62.37) 217.44,62.75 CH66.1
  IN2 w0.508: v2(218.61,63.08) 217.79,63.08 217.08,62.37 v2(217.07,62.37)
  IN4 w0.254: v2(209.08,68.76) 209.08,68.08 212.43,64.73 212.43,63.09 216.85,58.67 216.85,55.14 215.58,53.87 v2(215.58,53.38)
  BOTTOM w0.254: UH1.P18 209.02,68.71 v2(209.08,68.76) 209.15,68.83 UH1.P20
+PCH_VCCCLK: length 44.9
  TOP w0.254: CH70.1 212.28,79.91 211.92,79.55 211.92,79.17 212.17,78.92 212.17,78.53 211.03,77.38 v2(211.03,76.73)
  TOP w0.381: CH69.1 209.89,73.9 210.47,73.9 v2(210.65,74.08)
  TOP w0.508: CH67.1 209.46,75.69 v2(209.26,75.49) ; v2(217.23,82.85) v1(216.24,82.85) 214.83,81.45 RH244.2 213.89,80.82 213.81,80.82 CH68.1 CH70.1 ; CH71.1 210.9,75.94 v2(210.57,76.27)
  IN1 w0.254: v2(217.27,83.48) 216.76,83.48 213.13,79.84 213.13,79.12 212.76,78.75 212.39,78.75 209.26,75.62 v2(209.26,75.49)
  IN1 w0.381: 210.71,75.37 210.71,74.14 v2(210.65,74.08)
  IN1 w0.508: 210.71,75.37 213.76,78.42 213.76,79.53 v2(215.81,81.57)
  IN2 w0.254: v2(215.81,81.57) 215.81,81.6 215.31,81.1 215.31,81.03 213.58,79.3 213.58,77.74 211.94,76.09 211.28,76.09 211.1,76.27 v2(210.57,76.27)
  BOTTOM w0.254: UH1.AD34 210.77,75.9 210.57,76.11 v2(210.57,76.27) ; v2(210.65,74.08) 210.65,74.55 UH1.AA32 ; v2(210.65,74.08) 210.71,74.14 UH1.Y32 ; v2(210.65,74.08) 210.19,74.08 UH1.AA30
+PCH_VCCCLK3_3: length 77.3
  TOP w0.254: 213.6,70.64 214.28,70.64 215.8,69.12 CH75.1 215.38,68.15 213.6,69.93 213.6,70.64 ; 213.6,70.64 v2(213.53,70.7)
  TOP w0.508: CH73.1 211.54,70.43 212.43,70.43 v2(212.47,70.38)
  IN1 w0.254: v2(222.54,58.86) 222.54,59.51 219.77,62.28 219.77,62.78 217.69,64.86 217.69,65.33 215.72,67.29 214.62,67.29 214.12,67.79 214.12,68.05 212.47,69.69 v2(212.47,70.38)
  IN4 w0.254: v2(213.12,71.12) 213.27,71.27 213.7,71.27 215.86,69.11 215.86,68.54 221.7,62.7 224.62,62.7 v2(225.12,62.2) ; v2(225.99,62.23) 225.08,63.14 223.2,63.14 222.77,63.57 222.77,63.75 217.58,68.94 217.38,68.94 214.04,72.28 213.22,72.28 212.79,72.7 212.08,72.7 v2(212.06,72.69) ; v2(223.36,60.3) 221.26,62.41 220.11,62.41 217.42,65.1 217.42,65.54 215.3,67.67 215.3,68.26 213.53,70.03 v2(213.53,70.7)
  BOTTOM w0.254: UH1.M26 212.01,70.38 v2(212.47,70.38) 212.47,70 UH1.L26 ; UH1.M29 212.75,71.12 v2(213.12,71.12) ; UH1.L29 213.36,70.54 v2(213.53,70.7)
  vias: v1(226.42,61.35)
+PCH_VCCDSW: length 9.5
  TOP w0.089: v2(209.66,66.81) 209.04,66.81 208.73,67.12 v1(208.73,67.49)
  TOP w0.254: v2(209.66,66.81) 209.42,66.57 209.42,66.32 210.8,64.93 211.49,64.93 RH232.2
  IN3 w0.254: v2(209.66,66.81) 209.54,66.68 209.08,66.68 208.67,67.1
  IN3 w0.381: v2(206.99,68.56) 207.16,68.72 207.83,68.72 208.67,67.89 208.67,67.1
  BOTTOM w0.254: UH1.U14 206.94,68.5 v2(206.99,68.56)
+PCH_VCCDSW3_3: length 400.7
  TOP w0.102: v2(219.67,54.18) 219.67,53.63 v3(220.25,53.05)
  TOP w0.305: v2(302.03,111.9) 302.07,111.94 JAPS1.3
  TOP w0.508: v2(284.87,104.69) 284.87,105.31 R835.1 ; v2(200.77,51.32) 200.75,51.34 200.75,51.5 200.42,51.82 RH112.1 ; v2(135.14,36.41) 132.49,39.05 132.49,61.07 136.25,64.83 CC19.1 ; RH92.1 201.28,56.5 200.44,56.5 v2(200.21,56.27)
  IN1 w0.508: v2(200.77,51.32) 200.44,51.65 200.44,53.71 200.5,53.77 200.5,55.75 200.21,56.04 v2(200.21,56.27)
  IN2 w0.508: v2(135.14,36.41) 136.71,36.41 137.57,37.27 137.57,43.88 139,45.3 183.42,45.3 185.86,42.86 187.46,42.86 189.9,45.3 196.5,45.3 199.8,48.6 199.8,50.66 200.47,51.32 v2(200.77,51.32) 200.81,51.36 201.18,51.36 201.67,50.86 201.67,49.33 204.05,46.95 205.87,46.95 207.56,48.64 209.32,48.64 209.85,48.11 211.41,48.11 213.41,50.11 214.31,50.11 216.15,51.96 216.91,51.96 218.72,53.76 219.25,53.76 v2(219.67,54.18) 219.88,53.96 228.74,53.96 229.38,53.31 v2(229.41,53.31) ; v2(284.87,104.69) 284.87,104.83 ; 284.87,104.83 284.18,105.51 283.52,105.51 283.35,105.68 282.07,105.68 281.15,106.59 279.74,106.59 279.49,106.84 278.87,106.84 278.61,106.58 277.01,106.58 276.66,106.93 275.4,106.93 274.79,106.32 256.97,106.32 256.57,105.93 251.65,105.93 251.4,105.69 251,105.69 v2(250.86,105.55) ; 284.87,104.83 284.87,105.04 285.21,105.38 286.68,105.38 287.05,105.38 287.07,105.4 287.09,105.4 287.82,106.13 291.64,106.13 292.16,105.61 293.79,105.61 293.93,105.47 302.93,105.47 305.74,108.28 305.74,111.83 305.22,112.34 302.47,112.34 v2(302.03,111.9)
  IN4 w0.508: v2(320.37,162.88) 320.37,161.56 316.3,157.49 307.83,157.49 307.3,156.96 307.3,153.9 308.3,152.9 308.74,152.9 310.35,151.29 310.35,148.65 303.59,141.9 303.59,113.46 v2(302.03,111.9)
  BOTTOM w0.254: UH1.A16 212.73,63.59 212.73,62.89 213.34,62.29 213.98,62.29 214.77,61.51 214.77,60.87 CH44.1
  BOTTOM w0.381: CH44.1 215.23,60.52 215.77,60.52 215.78,60.51 216.01,60.51 216.52,60.01 216.52,59.7 216.12,59.3 216.12,58.43 RH237.2
  BOTTOM w0.508: RH217.2 217.32,55.69 217.32,54.53 218.02,53.84 219.32,53.84 v2(219.67,54.18) ; RH217.2 RH216.2 ; RH217.2 217.09,56.21 217.09,57.45 RH238.2 217.09,57.46 216.23,58.32 RH237.2 ; R566.2 319.44,188.79 320.32,187.91 320.32,187.4 318.77,185.85 318.77,182.31 320.57,180.51 320.57,173.1 318.64,171.17 318.64,164.6 v2(320.37,162.88) ; v2(229.41,53.31) 229.41,53.35 229.64,53.58 234.15,53.58 234.93,54.37 234.93,59.13 238.18,62.38 238.18,65.81 239.71,67.34 241.58,67.34 242.68,68.44 242.68,71.39 246.62,75.32 246.62,79.64 249.17,82.19 249.17,85.03 249.58,85.43 249.58,98.82 250.86,100.1 v2(250.86,105.55) ; v2(200.77,51.32) 199.78,51.32 RH80.1
+PCH_VCCDSW_R: length 2.4
  TOP w0.089: CH40.1 212.3,63.16 v1(213.03,62.43)
  TOP w0.457: CH40.1 212.41,63.31 212.41,64.33 RH232.1
+PCH_VCCSST: length 1.3
  TOP w0.508: CH46.1 205.28,69.63 v2(205.62,69.97)
  BOTTOM w0.254: UH1.AA14 205.62,69.52 v2(205.62,69.97)
+PECI_VREF: length 7.1
  TOP w0.102: R866.1 281.24,104.56 v1(280.86,104.18)
  TOP w0.254: U51.B51 282.65,109.91 282.65,109.91 282.65,109.9 282.49,109.74 282.49,108.23 281.94,107.67 281.94,106.97 282.24,106.67 C740.1
  TOP w0.508: R866.1 281.24,105.5 282,106.26 C740.1
+PWR_SRC: length 62.5
  TOP w0.508: PQ3.3 124.24,6.46 PC6.1 125.01,7.24 PR17.1 124.06,9.22 124.06,15.37 v2(124.58,15.89)
  IN4 w0.508: 173.07,14.53 171.56,16.04 170.85,16.04 169.02,17.87 126.56,17.87 v2(124.58,15.89)
  vias: v2(175.07,171.39) v2(175.61,171.99) v2(175.69,171.37) v2(176.23,172) v2(178.96,146.8) v2(178.98,146.21) v2(179.59,146.74) v2(179.6,146.15) v3(104.12,174.69) v4(103.36,176.54) v4(103.61,171.84) v4(104.12,176.54) v4(104.38,171.84) v4(104.53,177.16) v4(104.88,176.54) v4(105.14,171.84) v4(105.28,177.15) v4(105.65,176.54) v4(105.9,171.84) v4(106.66,177.05) v4(106.66,176.16) v4(106.66,175.4) v4(106.66,174.64) v4(106.66,173.88) v4(106.66,173.11) v4(106.66,172.35) v4(106.66,171.59) v4(107.3,176.67) v4(107.3,175.78) v4(107.3,175.02) v4(107.3,174.26) v4(107.3,173.37) v4(107.3,172.61) v4(107.3,171.84) v4(107.93,177.18) v4(107.93,176.16) v4(107.93,175.4) v4(107.93,174.64) v4(107.93,173.88) v4(108.44,174.26) v4(108.57,176.67) v4(108.57,175.78) v4(108.57,175.02) v4(109.33,176.29) v4(109.33,175.4) v4(142.07,165.19) v4(142.06,164.5) v4(142.73,165.19) v4(142.72,164.5) v4(143.38,164.5) v4(143.39,165.19) v4(144.06,165.2) v4(144.05,164.52) v4(144.61,164.85) v4(145.19,164.49) v4(145.51,165.19) v4(145.86,164.53) v4(174.01,10.64) v4(174.01,10.01) v4(174.01,9.37) v4(174.68,10.63) v4(174.68,9.99) v4(174.68,9.36) v4(175.37,10.67) v4(175.37,10.03) v4(175.37,9.4) v4(176.11,10.67) v4(176.11,10.03) v4(176.11,9.4) v4(198.14,21.83) v4(198.13,21.16) v4(198.9,21.84) v4(198.9,21.21) v4(199.58,21.83) v4(199.58,21.2) v4(200.26,21.82) v4(200.26,21.18) v4(200.99,21.82) v4(200.99,21.18) v4(201.62,21.82) v4(201.62,21.18) v4(202.27,21.79) v4(202.28,21.15) v4(202.9,21.81) v4(202.92,21.15) v4(242.68,29.48) v4(242.78,28.26) v4(242.93,27.57) v4(243.06,30.87) v4(243.06,30.11) v4(243.04,28.84) v4(243.37,29.46) v4(243.44,28.08) v4(243.67,28.85) v4(243.82,30.11) v4(244,29.48) v4(244.08,28.31) v4(244.46,30.11) v4(244.51,28.85) v4(244.78,28.27) v4(244.84,29.48) v4(245.09,30.11) v4(245.17,28.84) v4(291.3,173.65) v4(291.3,172.88) v4(292.18,173.65) v4(292.18,172.88) v4(293.07,173.65) v4(293.07,172.88)
+PWR_SRC_AC: length 29.2
  TOP w0.508: PR877.2 159.66,166.83 160.13,166.36 v2(160.13,166.17)
  IN4 w0.508: v2(160.13,166.17) 160.13,168.18 160.73,168.78 160.73,171.06 159.79,172 159.79,175.36 159.16,175.98 156.68,175.98 154.83,177.83 154.83,182.68 153.86,183.65 v2(149.11,183.65)
  BOTTOM w0.508: PC807.1 159.75,166.54 v2(160.13,166.17)
  vias: v1(148.95,190.39) v2(148.37,183.63) v4(98.71,185.22) v4(99.44,185.23) v4(100.15,185.27) v4(100.78,185.52) v4(100.97,188.29) v4(101.01,187.63) v4(101.02,186.99) v4(101.05,186.33) v4(101.39,185.76) v4(101.7,188.33) v4(101.72,187.68) v4(101.75,186.33) v4(101.79,186.99) v4(127.87,175.02) v4(128.63,175.02) v4(129.4,175.02) v4(130.16,175.02) v4(130.79,175.02) v4(130.79,174.26) v4(130.79,173.49) v4(130.79,172.73) v4(131.55,175.02) v4(131.55,174.26) v4(131.55,173.49) v4(131.55,172.73) v4(147.94,188.99) v4(147.94,188.23) v4(147.94,187.46) v4(147.94,186.7) v4(148.7,188.99) v4(148.7,188.23) v4(148.7,187.46) v4(148.7,186.7) v4(149.46,188.99) v4(149.46,188.23) v4(149.46,187.46) v4(149.46,186.7)
+PWR_SRC_S: length 381.4
  TOP w0.508: RC95.1 143.37,71.01 143.61,70.76 v2(143.63,70.76) ; v2(186.89,108.52) 186.89,108.13 RV67.1 ; v2(222.72,100.44) 222.72,100.29 225.5,97.51 230.84,97.51 231.99,96.37 v1(234.68,96.37) 244.82,96.37 249.16,92.02 251.12,92.02 253.05,90.09 v2(253.07,90.09) ; PQ3.1 125.92,2.91 126.65,2.17 PC7.1
  IN1 w0.508: v2(181.97,98.62) 182.35,98.23 182.35,89.8 185.66,86.5 185.67,86.42 185.67,78.07 185.66,77.99 v2(182.23,74.56)
  IN2 w0.508: v2(143.63,70.76) 143.63,69.82 142.07,68.26 142.07,62.93 144.31,60.69 175.08,60.69 183.99,69.6 183.99,72.8 v2(182.23,74.56)
  IN3 w0.508: v2(123.85,2.27) 117.34,2.27 114.26,5.36 114.26,11.21 115.15,12.1 115.15,28.77 109.32,34.59 109.32,58.46 114.84,63.98 v2(114.84,64.03) ; v2(222.72,100.44) 222.53,100.44 220.95,102.02 220.95,104.88 219.16,106.67 216.24,106.67 215.81,107.1 215.81,107.76 215.05,108.52 202.9,108.52 201.98,107.59 196.63,107.59 196.2,107.16 188.31,107.16 186.89,108.58 v2(186.89,108.52) ; v2(253.07,90.09) 253.12,90.09 254.17,89.04 254.17,69.67 250.63,66.13 250.63,60.53 251.24,59.92 251.24,59.36 250.73,58.85 250.73,57.95 250.17,57.39 250.17,53.69 249.68,53.19 249.68,52.05 250.11,51.62 250.11,50.86 248.88,49.62 248.88,40.86 247.37,39.34 247.37,37.76 247.1,37.49 247.1,36.58 249.72,33.96 249.72,32.8 247.58,30.67 247.58,28.19 243.61,24.22 241.57,24.22 240.93,23.57 233.69,23.57 232.51,24.75 230.34,24.75 v2(229.75,25.34)
  IN4 w0.508: v2(186.89,108.52) 185.78,107.42 185.78,105.4 181.44,101.05 181.44,99.15 v2(181.97,98.62)
  BOTTOM w0.508: v2(229.75,25.34) 229.75,24.66 228.88,23.79 R930.1 ; v2(143.63,70.76) 138.93,70.76 136.43,68.26 118.74,68.26 116.47,65.99 116.01,65.99 114.84,64.82 v2(114.84,64.03)
+RSVD_VCC3P3_1: length 5.8
  BOTTOM w0.254: U31.1 317.52,195.04 v1(317.7,194.87) 317.99,194.58
  BOTTOM w0.508: 317.99,194.58 318.04,194.53 320.84,194.53 321.67,193.69 R553.2
+RTC_CELL: length 286.4
  TOP w0.102: v2(260.73,105.3) v3(260.73,106.04)
  TOP w0.508: R830.1 R870.1 284.7,102.87 283.5,104.08 v2(283.5,104.46) ; v2(208.78,56.99) RH44.1 RH42.1 ; RH5.1 210.08,52.1 v2(209.86,51.88) ; R1084.1 v2(351.48,174.61) ; R1156.1 294.27,106.03 R810.1 294.42,106.88 v2(294.53,106.99) 294.43,107.09 R819.1
  IN1 w0.508: v2(351.48,174.61) 352.05,174.61 352.69,173.98 352.69,171.61 352.07,170.99 352.07,167.82 351.54,167.3 351.54,163.75 346.83,159.04 338.95,159.04 337.93,158.03 333.46,158.03 332.72,157.29 332.72,156.08 331.67,155.03 330.27,155.03 330.06,154.81 327.66,154.81 324.89,152.04 v2(324.89,152.02)
  IN2 w0.508: v2(260.73,105.3) 277.53,105.3 277.58,105.35 279.79,105.35 281.03,104.1 283.14,104.1 v2(283.5,104.46) ; v2(262.31,77.76) 262.29,77.79 261.48,77.79 260.84,77.15 255.2,77.15 254.44,77.91 v2(246.01,77.91)
  IN3 w0.508: v2(298.66,118.47) 300.21,118.47 308.92,127.19 310.25,127.19 317.76,134.7 318.56,134.7 319.44,135.57 319.44,139.48 323.43,143.47 323.43,144.21 324.49,145.28 324.49,150.69 324.89,151.08 v2(324.89,152.02) ; v2(208.78,56.99) 208.78,56.8 211.73,53.85 211.73,53.75 ; v2(209.86,51.88) 209.87,51.88 210.27,52.29 210.89,52.29 211.73,53.12 211.73,53.75 ; v2(246.01,77.91) 246.01,73.84 245.35,73.18 245.35,58.84 239,52.49 237.98,52.49 236.46,50.96 227.74,50.96 226.55,49.77 219.67,49.77 218.91,50.53 218.09,50.53 215.98,52.64 214.08,52.64 212.96,53.76 211.74,53.76 211.73,53.75
  IN4 w0.508: v2(294.53,106.99) 294.53,107.14 295.79,108.39 296.96,108.39 297.75,109.18 297.75,111.26 297.16,111.85 297.16,116.98 v2(298.66,118.47) ; v2(208.78,56.99) 208.79,56.99 211.31,59.51 v2(211.31,59.69)
  BOTTOM w0.254: CH57.1 209.93,56.95 209.93,60.65 209.64,60.94 UH1.A6
  BOTTOM w0.508: v2(262.31,77.76) 261.91,77.76 261.3,78.37 261.3,79.82 260.43,80.68 260.43,81.37 259.77,82.03 259.77,90.56 260.08,90.87 260.08,95.26 259.09,96.25 259.09,96.79 259.55,97.24 259.55,98.79 260.73,99.97 v2(260.73,105.3) ; v2(283.5,104.46) 283.5,104.76 283.88,105.14 284.36,105.14 284.97,105.75 287.33,105.75 288.01,106.43 288.01,107.49 288.86,108.34 292.9,108.34 293.51,107.73 294.17,107.73 294.53,107.37 v2(294.53,106.99) ; CH56.1 CH57.1 ; CH56.1 RH43.1 RH67.2 210.47,57.63 210.47,58.85 v2(211.31,59.69) ; CH56.1 CH55.1 ; v2(324.89,152.02) 325.17,152.3 PD3.1 325.43,154.66 PC3.1
+RTC_CELL_VBAT: length 12.9
  TOP w0.254: v2(290.05,110.96) 289.46,110.96 289.23,110.74 289.23,109.83 289.47,109.6 U51.B64
  TOP w0.508: R830.2 286.63,103.78 C724.1 286.65,104.41 v2(286.28,104.77)
  IN1 w0.508: v2(290.05,110.96) 289.95,110.96 289.42,110.43 289.42,109.22 288.31,108.11 288.31,106.79 286.29,104.77 v2(286.28,104.77)
  BOTTOM w0.127: v2(286.28,104.77) 286.92,104.77 v1(286.93,104.76)
+SA_DIMM1_VREFDQ: length 16.5
  TOP w0.508: RD17.2 RD18.1 122.79,34.94 122.63,35.1 122.63,36.5 ; 122.63,36.5 121.56,36.5 121.1,36.97 RD1.1 ; 122.63,36.5 v1(125.46,36.5) 126.5,36.5 127.39,35.61 127.39,32.77 126.86,32.23 RD19.2
+SA_DIMM_VREFDQ: length 154
  TOP w0.102: v2(127.11,88.4) v1(127.11,87.77)
  TOP w0.406: QD6.1 121.6,29.28 RD27.1
  TOP w0.508: RD26.2 122.03,30.29 v2(121.93,30.19) 121.59,29.84 RD27.1
  IN2 w0.254: 134.54,88.37 135.45,87.46 152.86,87.46 152.88,87.44 166.06,87.44 166.25,87.63 166.25,90.5 166.95,91.2 166.95,93.23 v2(167.7,93.99) 166.86,93.99 166.18,93.31 166.18,91.25 165.26,90.33 165.26,88.65 165.03,88.42 134.59,88.42 134.54,88.37 ; 134.54,88.37 134.46,88.37
  IN2 w0.508: v2(127.11,88.4) 134.43,88.4 134.46,88.37
  IN4 w0.508: v2(127.11,88.4) 125.15,88.4 122.14,85.39 122.14,82.5 119.44,79.79 119.44,67.06 121.56,64.94 121.56,47.09 120.47,46 120.47,39.95 119.72,39.2 119.72,33.93 120.77,32.88 120.77,31.34 v2(121.93,30.19)
  BOTTOM w0.305: v2(167.7,93.99) 167.24,94.45 JCPU1.F16
+SA_DIMM_VREFDQ_Q: length 4.3
  TOP w0.102: v1(125.43,29.63) 125.08,29.28 QD6.6
  TOP w0.381: QD6.6 124.5,29.81 RD26.1
  TOP w0.508: RD26.1 124.02,30.63 123.81,30.85 RD17.1 CD47.1
+SB_DIMM2_VREFDQ: length 5.5
  TOP w0.102: RD15.2 127.16,28.61 v1(128.3,29.76)
  TOP w0.508: RD15.2 RD16.1 RD14.2 127.11,26.76 126.26,26.76 125.51,26.01 RD8.1
+SB_DIMM_VREFDQ: length 168.7
  TOP w0.102: QD6.4 125.2,27.98 v1(125.47,28.24)
  TOP w0.381: QD6.4 124.5,27.07 RD30.1
  TOP w0.508: RD30.1 RD31.2 123.45,27.57 v2(123.69,27.81)
  IN3 w0.254: 167.96,91.42 167.73,91.65 v2(167.73,91.92) 168.22,92.4 172.08,92.4 173.06,91.42 167.96,91.42
  IN3 w0.508: v2(123.69,27.81) 124.43,27.08 124.43,18.61 126.18,16.85 144.67,16.85 146.11,15.42 158.96,15.42 159.6,14.78 162.41,14.78 162.5,14.87 179.24,14.87 182.91,18.54 182.91,25.36 184.78,27.23 184.78,48.86 173.74,59.89 173.74,72.31 176.67,75.23 176.67,88.23 173.76,91.13 173.35,91.13 173.06,91.42
  BOTTOM w0.305: v2(167.73,91.92) 167.26,91.45 JCPU1.F13
+SB_DIMM_VREFDQ_Q: length 26
  TOP w0.381: RD31.1 122.6,26.99 QD6.3
  TOP w0.508: RD31.1 122.32,26.92 121.13,25.73 121.13,23.96 119.72,22.55 119.72,21.26 122.45,18.53 126.78,18.53 127.62,19.37 v1(127.62,21.72) 128.25,22.35 128.25,24.96 128.86,25.56 CD46.1 128.86,26.54 128.6,26.81 RD14.1
+SDC_IN: length 136.3
  TOP w0.254: v4(77.47,187.41) 77.58,187.3 PU700.3
  TOP w0.508: v2(72.55,186.19) 72.18,186.56 PR713.2 ; v2(110.07,158.65) 109.69,158.65 109.27,159.07 PC720.1 109.27,159.6 109.73,160.06 PU703.3 ; PR854.1 152.87,160.23 v2(152.66,160.03) ; PC700.1 106.18,169.15 v1(105.33,170) 104.73,170.6 101.38,170.6 v2(100.64,171.34)
  IN2 w0.508: v2(100.64,171.34) 101.1,170.88 107.6,170.88 109.23,172.51 116.36,172.51 117.25,173.41 121.43,173.41 122.84,174.82 v4(123.3,174.82)
  IN3 w0.508: v4(77.47,187.41) 77.47,188.51 77.11,188.86 74.75,188.86 72.55,186.66 v2(72.55,186.19)
  IN4 w0.508: v2(105.79,161.32) 105.75,161.35 105.75,162.2 105.5,162.45 104,162.45 101.37,165.07 101.37,167.84 100.84,168.37 100.36,168.37 99.93,168.8 99.93,169.38 100.64,170.09 v2(100.64,171.34) 99.6,170.29 87.94,170.29 80.48,177.75 80.48,178.96 79.4,180.03 77.81,180.03 77,179.22 76.25,179.22 72.18,179.22 71.78,179.62 71.78,180.45 72.55,181.23 v2(72.55,186.19)
  BOTTOM w0.508: v2(152.66,160.03) 152.2,160.03 149.18,163.04 131.87,163.04 128.84,166.08 128.84,168.77 128.18,169.43 v4(127.62,169.43) ; v2(105.79,161.32) 105.79,161.01 106.98,159.82 108.16,159.82 109.33,158.65 v2(110.07,158.65)
  vias: v4(123.3,174.18) v4(123.3,173.42) v4(123.31,172.77) v4(124.06,174.82) v4(124.06,174.18) v4(124.06,173.42) v4(124.06,172.78) v4(124.32,170.13) v4(124.29,169.46) v4(126.86,170.13) v4(126.86,169.43) v4(127.62,170.13)
+SIM_PWR: length 121.4
  TOP w0.102: v3(242.95,175.16) 243.02,175.08 C639.1
  TOP w0.508: C639.1 245.72,175.08 C636.1 C616.1 246.82,175.09 v2(247.56,175.83) 247.04,176.34 JSIM1.1
  IN1 w0.508: v2(321.28,209.71) 321.22,209.78 307.84,209.78 305.46,207.4 296.7,207.4 294.97,205.67 294.97,192.95 293.47,191.45 292.44,191.45 291.24,190.26 281.59,190.26 280.23,188.9 278.96,188.9 278.27,189.6 276.92,189.6 276.2,188.87 267.97,188.87 267.37,189.47 262,189.47 261.53,189 249.93,189 248.52,187.6 248.52,177.53 247.48,176.49 247.48,175.91 v2(247.56,175.83)
  BOTTOM w0.508: v2(321.28,209.71) 321.2,209.64 321.2,207.57 322.64,206.13 323.5,206.13 324.93,204.71 328.06,204.71 328.95,203.82 JMINI1.8
+SM_VREF: length 150.1
  TOP w0.254: 140.27,78.65 140.27,80.14 140.73,80.6 v2(140.73,80.92) 140.42,80.92 139.89,80.39 139.51,80.39 139.26,80.15 139.26,79.43 138.82,78.98 138.82,78.47 139.07,78.22 139.84,78.22 140.27,78.65
  TOP w0.508: 138.82,78.47 134.77,78.47 131.34,81.9 v1(124.19,81.9) 123.13,81.9 v2(121.12,83.92) ; v2(165.67,16.18) 165.12,16.72 QD7.3 166.05,17.9 166.05,18.5 165.59,18.96 RD29.2 165.59,19.62 165.9,19.93 166,19.93 166.49,20.42 RD28.1
  IN4 w0.508: v2(121.12,83.92) 121.12,82.38 118.74,80.01 118.74,66.86 120.05,65.55 120.05,47.22 119.81,46.98 119.81,40.31 119.03,39.53 119.03,33.71 119.71,33.03 119.71,19.28 123.77,15.21 126.31,15.21 128.2,17.11 165.13,17.11 165.67,16.57 v2(165.67,16.18)
  BOTTOM w0.381: JCPU1.AM3 141.2,81.39 v2(140.73,80.92)
+SM_VREF_DIMM: length 18.2
  TOP w0.457: v1(171.34,16.2) 171.34,16.64 169.54,18.44 167.71,18.44 167.17,18.99 167.17,20.97 166.87,21.26 166.11,21.26 165.72,21.65 RD13.1
  TOP w0.508: v1(171.34,16.2) 171.34,15.99 170.02,14.67 RD20.2 RD21.1 RD22.2 RD23.1
