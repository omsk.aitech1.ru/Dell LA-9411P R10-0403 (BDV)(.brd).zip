# Allegro board LA-9411P R10-0403.brd (continued)
## Copper pours and planes (outline as drawn) (continued)
1.5VSP_LX on TOP (solid shape): 239.67,109.23 239.67,107.35 239.25,106.93 239.25,102.76 239.12,102.63 237.22,102.63 237.09,102.76 237.09,103.9 236.84,104.15 235.44,104.15 235.31,104.28 235.31,104.79 235.44,104.91 236.2,104.91 237.22,105.93 237.22,106.31 237.85,106.95 237.85,109.14 238.13,109.42 239.48,109.42
1.5VSP_VIN on TOP (solid shape): 233.28,104.91 233.28,103.71 232.74,103.16 232.43,103.16 232.13,102.86 232.13,100.72 232.74,100.11 232.74,99.92 232.66,99.84 232.24,99.84 232.24,99.83 232.2,99.83 232.2,99.33 232.01,99.33 232.01,99.9 231.5,99.9 231.45,99.84 231.44,99.83 231.44,99.33 231.19,99.33 231.19,99.9 229.79,99.9 229.73,99.96 229.73,102.56 230.34,103.18 231.14,103.18 231.24,103.28 231.25,103.28 231.25,104.41 231.38,104.53 232.08,104.53 232.52,104.98 233.22,104.98
1.8VSP_LX on TOP (solid shape): 283.38,141.52 283.38,134.57 283.26,134.44 282.56,134.44 282.49,134.51 282.49,135.39 281.54,136.35 281.54,136.77 281.62,136.99 281.54,137.22 281.54,142.06 281.8,142.32 282.58,142.32
1.8VSP_VIN on TOP (solid shape): 289.03,133.81 289.03,132.98 289.61,132.98 289.61,132.73 289.03,132.73 289.03,132.16 289.61,132.16 289.61,131.97 289.03,131.97 289.03,131.19 288.73,130.89 282.86,130.89 282.55,131.2 282.55,132.22 282.67,132.35 284.21,132.35 284.59,132.73 287.45,132.73 287.64,132.92 287.64,133.87 287.7,133.93 288.91,133.93
1.35V_B+ on TOP (solid shape): 197.72,18.81 199.25,18.81 199.25,19.32 199.63,19.32 199.63,18.81 200.39,18.81 200.39,19.32 200.77,19.32 200.77,18.81 201.53,18.81 201.91,18.43 201.91,12.33 200.26,10.68 200.26,7.76 200.01,7.51 195.86,7.51 195.58,7.78 195.58,8.12 195.56,8.14 195.56,19.19 195.94,19.57 196.96,19.57
1.35V_FB on TOP (solid shape): 212.94,13.1 212.94,13.08 213,12.97 213.09,12.89 213.09,11.7 213.41,11.38 214.55,11.38 214.61,11.32 214.61,9.79 214.55,9.73 212.77,9.73 212.64,9.85 212.64,12.59 212.33,12.9 211.56,12.9 211.51,12.95 211.51,13.12 211.55,13.16 212.88,13.16
+0.9V_LAN on TOP (solid shape): outline of 1038 points within 309.61,187.71 324.21,203.47
+0.9V_LAN on BOTTOM (solid shape): 314.94,192.29 314.94,191.4 315.2,191.15 317.25,191.15 317.61,190.79 317.61,189.62 317.48,189.5 313.67,189.5 313.55,189.62 313.55,191.02 313.29,191.27 313.29,192.29 313.42,192.42 314.82,192.42
+0.9V_LAN on BOTTOM (solid shape): 319.64,196.99 320.02,196.99 320.15,197.12 320.15,197.62 320.28,197.75 320.91,197.75 321.04,197.62 321.04,195.85 320.91,195.72 319.39,195.72 319.13,195.97 319.13,196.86 318.88,197.12 317.86,197.12 317.86,197.75 318.88,197.75
+0.675V_DDR_VTT on TOP (solid shape): 187.93,19.86 187.93,18.4 187.96,18.38 187.96,17.11 187.66,16.81 186.7,16.81 186.36,17.16 186.36,19.9 186.7,20.24 187.55,20.24
+0.675V_DDR_VTT on TOP (solid shape): 186.09,42.37 186.09,42.37 186.09,41.84 185.87,41.62 185.87,40.03 185.17,39.33 184.66,39.33 184.53,39.46 184.53,41.74 184.47,41.81 184.47,42.38 184.6,42.5 185.95,42.5
+0.675V_DDR_VTT on TOP (solid shape): 203.78,13.22 203.82,13.19 203.88,13.16 203.94,13.09 203.94,11.82 203.44,11.82 203.44,11.32 203.94,11.32 203.94,10.81 203.82,10.68 202.42,10.68 202.29,10.81 202.29,12.97 202.55,13.22
+0.675V_DDR_VTT on TOP (solid shape): 187.64,33.04 187.64,28.06 187.63,28.03 187.6,28.01 187.25,27.63 187.6,27.25 187.63,27.23 187.64,27.2 187.64,25.8 187.39,25.55 185.67,25.55 185.55,25.68 185.55,27.8 185.77,28.02 186.16,28.02 186.25,28.12 186.25,29.09 185.55,29.79 185.55,33.04 185.74,33.23 187.45,33.23
+0.675V_DDR_VTT on BOTTOM (solid shape): 187.6,27.11 187.6,25.52 187.14,25.06 185.8,25.06 185.71,25.15 185.71,27.07 185.89,27.25 187.47,27.25
+0.675V_DDR_VTT on BOTTOM (solid shape): 187.11,19.67 187.11,18.65 187.1,18.64 187.1,17.07 186.88,16.85 186.09,16.85 186,16.94 186,17.72 186.01,17.73 186.01,19.7 186.16,19.85 186.93,19.85
+0.675V_DDR_VTT on BOTTOM (solid shape): 186.71,40.78 187.39,40.78 187.65,40.53 187.65,36.25 186.92,35.52 186.92,34.12 187.65,33.4 187.65,30.04 187.41,29.81 186.15,29.81 186.02,29.93 186.02,31.86 185.7,32.18 185.7,36.3 186.02,36.61 186.02,37.71 186.02,37.85 185.7,38.18 185.7,40.04 185.28,40.45 185.28,40.97 185.29,40.97 185.29,41.56 185.36,41.63 185.87,41.63
+0.675V_DDR_VTT on IN3 (solid shape): 188.08,19.85 188.08,19.09 187.87,18.87 186.56,18.87 186.43,19 186.43,19.82 186.6,19.99 187.94,19.99
+0.675V_DDR_VTT on IN3 (solid shape): 203.07,13.02 203.07,12.1 202.8,11.84 201.35,11.84 201.1,12.09 201.1,12.71 201.53,13.14 202.94,13.14
+0.675V_P on TOP (solid shape): 207.26,12.65 207.26,12.55 207.51,12.29 207.97,12.29 208.21,12.53 208.21,12.88 208.49,13.16 209.28,13.16 209.34,13.1 209.34,11.82 209.49,11.67 209.76,11.67 209.91,11.82 209.91,12.74 209.93,12.75 210.13,12.75 210.17,12.71 210.17,10.68 209.91,10.43 207.5,10.43 207.25,10.68 207.25,11.57 206.87,11.95 205.72,11.95 204.77,11 204.26,11 204.2,11.06 204.2,11.51 203.69,11.51 203.69,11.63 204.2,11.63 204.2,12.9 204.31,13.02 205.96,13.02 206.1,13.16 206.75,13.16
+0.675V_P on BOTTOM (solid shape): 207.6,12.18 207.6,11.75 207.54,11.68 206.85,11.68 206.52,12.01 205.41,12.01 205.14,12.28 205.14,12.78 205.37,13 206.78,13
+1.2V_LDO_OZ on TOP (solid shape): 255.38,49.54 255.38,49.01 253.77,47.4 253.61,47.4 253.6,47.38 253.42,47.38 253.4,47.41 253.4,48.39 253.7,48.69 254.17,48.69 254.54,49.06 254.54,49.59 254.62,49.67 255.25,49.67
+1.2V_LDO_OZ on TOP (solid shape): 252.38,40.12 252.38,39.33 252.46,39.26 252.46,39.14 252.65,38.94 252.65,37.44 252.47,37.26 251.46,37.26 251.3,37.42 251.22,37.42 251.14,37.5 251.14,37.93 251.19,37.99 251.19,39.09 250.92,39.36 250.45,39.36 250.4,39.41 250.4,39.94 250.66,40.2 252.31,40.2
+1.2V_LDO_OZ on IN2 (solid shape): 254.46,38.73 254.46,37.97 254.41,37.88 254.31,37.88 253.88,37.78 253.88,37.34 253.91,37.3 253.83,37.22 253.77,37.19 253.07,37.19 252.84,37.27 252.61,37.19 251.39,37.19 251,37.58 251,38.56 251.33,38.89 254.3,38.89
+1.05V_+1.5V_RUN on TOP (solid shape): outline of 185 points within 192.27,76.1 201.47,84.26
+1.5V_CARD on TOP (solid shape): 275.12,34.68 276.46,34.68 276.59,34.56 276.59,32.88 276.52,32.81 274.8,32.81 274.77,32.84 274.62,32.84 273.95,33.52 273.95,35.03 274.01,35.09 274.71,35.09
+1.5V_CARD on TOP (solid shape): 281.16,31.51 282.43,31.51 282.68,31.25 282.68,30.75 283.19,30.24 285.22,30.24 285.35,30.11 285.35,29.48 285.22,29.35 282.94,29.35 282.56,29.73 285.1,29.73 285.1,29.86 284.34,29.86 284.34,29.73 282.56,29.73 281.41,30.87 280.53,30.87 280.4,31 280.4,31.64 280.53,31.76 280.91,31.76
+1.5V_CARD on IN1 (solid shape): 276.64,32.82 276.66,32.79 276.69,32.75 276.72,32.72 276.75,32.68 276.8,32.66 276.83,32.64 277.55,31.91 282.58,31.91 282.75,31.75 282.75,30.47 282.48,30.2 276.04,30.2 274.84,31.41 276.69,31.41 276.69,31.35 276.7,31.3 276.71,31.25 276.74,31.2 276.77,31.16 276.8,31.12 276.85,31.09 276.89,31.06 276.94,31.04 276.99,31.03 277.05,31.02 277.1,31.03 277.15,31.04 277.2,31.06 277.25,31.09 277.29,31.12 277.32,31.16 277.36,31.2 277.38,31.25 277.39,31.3 277.4,31.35 277.4,31.41 277.39,31.46 277.38,31.51 277.36,31.56 277.32,31.6 277.29,31.64 277.25,31.68 277.2,31.7 277.15,31.72 277.1,31.73 277.05,31.74 276.99,31.73 276.94,31.72 276.89,31.7 276.85,31.68 276.8,31.64 276.77,31.6 276.74,31.56 276.71,31.51 276.7,31.46 276.69,31.41 274.84,31.41 274.65,31.6 274.65,33.07 274.81,33.24 276.23,33.24
+1.05V_M on TOP (solid shape): outline of 239 points within 202.04,82.63 205.76,90.56
+1.05V_M on BOTTOM (solid shape): 318.12,189 318.12,187.97 317.86,187.72 316.21,187.72 316.09,187.85 316.09,189.24 316.21,189.37 317.75,189.37
+1.05V_M on BOTTOM (solid shape): 209.53,71.39 209.53,71.26 209.71,71.08 209.9,71.08 209.96,71.01 209.96,70.8 209.91,70.75 209.53,70.75 209.41,70.62 209.41,70.24 209.28,70.12 209.18,70.12 208.87,69.81 208.87,69.08 208.72,68.92 208.72,68.62 208.64,68.54 208.47,68.54 206.51,70.5 206.51,70.65 206.61,70.75 206.76,70.75 206.79,70.73 207.48,70.73 208.19,71.44 208.36,71.43 208.4,71.44 209.08,71.44 209.15,71.51 209.41,71.51
+1.05V_M on BOTTOM (solid shape): outline of 263 points within 205.6,16.42 227.14,34.53
+1.05V_M on VCC: 205.19,33.16 204.43,33.92 202.91,33.92 201.53,35.3 201.53,36.57 200.39,37.71 200.39,65.69 202.04,67.34 202.04,68.11 204.05,70.12 205.07,70.12 205.47,70.52 205.47,71.49 204.02,72.94 204.02,73.47 202.41,75.08 203.42,76.09 204.35,76.09 204.86,75.58 206.72,75.58 211.16,80.02 212.35,80.02 214.36,78.01 214.36,73.4 211.95,70.98 211.95,63.87 208.52,60.44 208.52,56.93 209.53,55.91 209.53,36.19 206.51,33.16
+1.05V_MP on BOTTOM (solid shape): outline of 279 points within 213.72,6.74 227.06,16.85
+1.5V_RUN on TOP (solid shape): 223.88,81.55 223.88,81.29 222.99,80.4 222.87,80.4 222.23,81.04 222.23,81.29 223.12,82.18 223.25,82.18
+1.5V_RUN on TOP (solid shape): 179.69,191.44 179.69,190.78 179.45,190.54 178.34,190.54 177.82,191.06 177.52,191.06 177.4,191.17 177.4,191.68 177.4,191.69 177.53,191.82 179.31,191.82
+1.5V_RUN on TOP (solid shape): 30.09,196.13 30.09,195.67 30.15,195.62 30.54,195.62 30.59,195.67 30.59,196.14 30.63,196.18 30.97,196.18 31.1,196.05 31.1,194.74 31.05,194.69 29.65,194.69 29.54,194.81 29.54,196.09 29.62,196.18 30.04,196.18
+1.05V_RUN on TOP (solid shape): 207.96,73.93 208.29,73.93 208.52,74.16 208.67,74.16 208.82,74 208.82,73.75 208.44,73.37 208.44,73.11 207.63,72.3 207.35,72.3 206.36,71.31 206.1,71.31 205.85,71.56 205.81,71.56 205.79,71.58 205.77,71.56 205.55,71.56 205.16,71.18 205.04,71.18 204.66,71.56 204.66,71.79 207.27,74.41 207.48,74.41
+1.5V_RUN on TOP (solid shape): 234.93,101.42 234.93,100.98 235.5,100.98 235.5,100.79 234.93,100.79 234.93,100.15 235.44,100.15 235.44,99.96 234.93,99.96 234.93,99.33 234.87,99.26 233.46,99.26 233.02,99.71 233.02,99.96 232.87,100.11 232.87,100.16 232.69,100.34 232.69,101.22 232.76,101.29 233.52,101.29 233.52,101.36 233.62,101.36 233.88,101.61 234.74,101.61
+1.5V_RUN on TOP (solid shape): 276.5,36.4 276.5,35.1 276.33,34.94 275.08,34.94 274.7,35.32 274.04,35.32 273.97,35.38 273.97,35.52 274.04,35.59 274.94,35.59 275.31,35.22 275.78,35.22 275.93,35.37 275.93,35.89 275.84,35.98 275.48,35.98 275.14,36.32 274,36.32 273.95,36.37 273.95,36.51 274.02,36.59 276.31,36.59
+1.05V_RUN on TOP (solid shape): outline of 240 points within 199.58,72.52 206.36,78.02
+1.05V_RUN on TOP (solid shape): outline of 980 points within 216.39,23.93 227.64,46.05
+1.5V_RUN on BOTTOM (solid shape): 31.89,196.08 31.89,194.88 31.49,194.49 30.06,194.49 29.89,194.65 29.89,196.02 30.08,196.21 31.75,196.21
+1.5V_RUN on BOTTOM (solid shape): 119.83,188.4 119.83,187.53 119.66,187.36 118.41,187.36 118.18,187.59 118.18,188.47 118.28,188.57 119.02,188.57 119.05,188.59 119.63,188.59
+1.5V_RUN on BOTTOM (solid shape): 208.38,92.63 208.38,92.54 209.87,91.06 209.87,90.77 209.48,90.38 209.38,90.38 207.85,91.91 207.4,91.91 207.07,92.24 207.07,92.42 207.77,93.11 207.9,93.11
+1.05V_RUN on BOTTOM (solid shape): 225.59,25.35 225.59,21.89 225.42,21.73 222.4,21.73 222.26,21.87 222.26,22.39 221.95,22.69 217.53,22.69 217.05,23.18 217.05,25.13 217.76,25.84 225.09,25.84
+1.05V_RUN on BOTTOM (solid shape): 211.36,73.7 211.36,73.51 211.48,73.39 211.68,73.39 211.83,73.24 211.83,73.08 211.69,72.94 211.69,72.58 211.6,72.49 210.68,72.49 210.56,72.38 210.43,72.38 210.35,72.47 210.35,73.62 210.45,73.72 210.87,73.72 210.99,73.85 211.21,73.85
+1.05V_RUN on BOTTOM (solid shape): 208.63,74.14 208.71,74.16 209.18,74.16 209.25,74.08 209.25,73.85 209.18,73.77 208.85,73.77 208.67,73.6 208.67,73.24 208.89,73.02 209.11,73.02 209.62,72.52 209.62,72.49 209.63,72.41 209.65,72.33 209.66,72.3 209.51,72.15 207.6,72.15 206.89,71.43 206.86,71.44 206.63,71.45 206.45,71.31 205.62,71.31 205.04,71.89 205.04,72.12 206.89,73.98 208.21,73.98 208.25,74.01 208.26,74.02 208.34,74.07 208.41,74.16 208.54,74.16
+1.05V_RUN on BOTTOM (solid shape): 204.71,75.63 204.71,75.2 205.52,74.38 206.13,74.38 206.26,74.26 206.26,74 206.09,73.83 206.06,73.84 205.95,73.86 205.85,73.83 205.84,73.82 205.67,73.82 205.14,73.29 205.04,73.29 205.03,73.3 204.88,73.33 204.72,73.3 204.7,73.28 204.53,73.08 204.56,72.81 204.58,72.78 204.45,72.66 204.2,72.66 203.56,73.29 203.56,74.05 203.87,74.36 204.05,74.36 204.17,74.49 204.17,74.74 203.54,75.37 203.44,75.37 203.36,75.45 203.36,75.78 203.41,75.82 203.45,75.87 203.56,75.98 203.56,76.29 203.64,76.36 203.97,76.36
+1.5V_RUN on IN1 (solid shape): outline of 157 points within 238.87,23.15 243.18,39.92
+1.5V_RUN on IN2 (solid shape): 119.52,188.53 120.68,188.53 120.8,188.42 120.8,187.34 120.53,187.07 118.85,187.07 118.72,187.21 118.72,188.37 118.94,188.59 119.45,188.59
+1.5V_RUN on IN2 (solid shape): 234.88,101.87 234.88,99.99 234.25,99.35 231.61,99.35 231.54,99.42 229.89,99.42 226.86,96.38 226.86,90.56 226.72,90.43 226.24,90.38 226.19,89.9 224.38,88.09 224.38,84.09 225.13,83.34 225.13,81.18 224.75,80.8 222.93,80.8 222.33,81.39 222.33,88.54 225.51,91.72 225.51,97.03 228.53,100.05 228.53,101.99 229.15,102.62 234.13,102.62
+1.5V_RUN on IN2 (solid shape): 178.89,191.58 178.89,190.41 178.62,190.14 178.51,190.12 178.44,190.21 177.84,190.47 178.09,189.86 178.19,189.8 178.17,189.69 177.69,189.22 177.39,189.22 177.36,189.19 174.95,189.19 174.48,188.72 167.48,188.72 166.03,190.17 165.74,190.17 165.71,190.21 162.11,190.21 161.68,190.64 161.68,191.07 161.86,191.25 164.32,191.25 164.56,191.48 166.1,191.48 166.52,191.06 166.52,191.05 166.69,190.79 167,190.76 167.01,190.77 167.12,190.77 167.14,190.74 167.46,190.54 167.78,190.74 167.79,190.77 175.88,190.77 177.05,191.93 178.53,191.93
+1.5V_RUN on IN2 (solid shape): outline of 370 points within 240.79,22.06 277.9,36.84
+1.05V_RUN on IN2 (solid shape): outline of 1741 points within 195.05,70.5 206.31,80.28
+1.05V_RUN on IN3 (solid shape): outline of 1299 points within 200.39,71.44 209.2,83.83
+1.5V_RUN on TOP: 254.43,176.8 254.43,177.76 255.85,179.18 256.18,179.18 256.86,178.5 256.86,177.34 255.98,176.45 255.98,174.24 256.23,173.99 258.48,173.99 258.68,173.79 258.68,172.55 258.68,172.55 258.68,172.15 258.54,172.02 257.12,172.02 256.66,172.48 254.81,172.48 254.39,172.9 254.39,176.76
+1.5V_RUN on VCC: 240.75,39 239.63,40.12 239.63,54.85 238.36,56.12 238.36,96.13 235.04,99.45 233.64,99.45 232.77,100.32 232.77,102.9 233.77,103.9 241.77,103.9 257.16,119.29 257.16,172.75 257.52,173.11 258.58,173.11 259.7,171.99 259.7,118.61 241.92,100.83 241.92,83.05 240.9,82.03 240.9,45.75 243.44,43.21 243.44,40.38 242.07,39
+1.05V_RUN on VCC: 223.78,43.83 219.16,43.83 218.55,44.44 218.55,50.28 214.34,54.5 210.53,54.5 210.04,54.98 210.04,56.12 209.02,57.14 209.02,60.23 212.45,63.66 212.45,70.77 214.87,73.19 214.87,78.22 212.56,80.53 210.95,80.53 206.51,76.09 205.07,76.09 204.56,76.59 203.2,76.59 202.05,75.44 200.77,76.72 198.72,76.72 195.94,79.49 195.94,81.95 199.73,85.74 204.94,85.74 206.99,87.79 206.99,94.25 207.88,95.14 212.09,95.14 213.47,93.76 213.47,84.87 216.92,81.42 219.71,81.42 222.61,78.52 222.61,76.62 223.27,75.96 225.56,75.96 225.92,75.6 225.92,71.75 225.03,70.86 225.03,68.23 225.92,67.34 225.92,58.54 225.03,57.65 225.03,53.58 224.14,52.7 224.14,51.6 225.03,50.71 225.03,45.08 ; 1 cut-out
+1.5V_RUN_HDMI on TOP (solid shape): 23.06,206.9 23.06,206.54 24.98,204.62 24.98,203.62 24.9,203.54 24.41,203.54 22.83,205.12 21.7,205.12 21.19,205.63 21.19,206.77 21.38,206.96 23,206.96
+1.5V_RUN_HDMI on TOP (solid shape): 30.92,197.28 30.92,196.41 30.84,196.33 30.48,196.33 30.44,196.29 30.44,195.81 30.4,195.77 30.27,195.77 30.25,195.8 30.25,196.27 30.18,196.33 29.85,196.33 29.8,196.38 29.8,197.33 29.95,197.48 30.72,197.48
+1.5V_RUN_HDMI on IN4 (solid shape): outline of 663 points within 20.66,195.66 31.23,207.51
+1.05V_RUN_VCC on BOTTOM (solid shape): 211.79,90.97 211.79,90.23 211.08,89.52 211.03,89.52 210.33,90.22 210.33,90.78 210.07,91.05 210.07,91.16 210.76,91.86 210.9,91.86
+1.5V_RUNP on TOP (solid shape): 242.81,106.56 242.81,101.24 242.36,100.79 241.09,100.79 240.9,100.6 237.03,100.6 236.77,100.34 236.77,99.52 236.58,99.33 235.12,99.33 235.12,99.77 235.69,99.77 235.69,100.34 235.12,100.34 235.12,100.6 235.69,100.6 235.69,101.17 235.19,101.17 235.19,102.18 235.44,102.44 239.31,102.44 239.63,102.76 239.63,107.01 239.76,107.14 242.24,107.14
+1.05VSP_B+ on TOP (solid shape): 222.87,10.3 223.5,10.3 223.5,10.81 223.76,10.81 223.76,10.3 224.39,10.3 224.39,10.81 230.87,10.81 231,10.68 231,8.14 230.74,7.89 222.74,7.89 222.61,8.01 222.61,10.81 222.87,10.81
+1.8V_MPLL_PVDD on IN2 (solid shape): outline of 176 points within 207.15,141.39 213.64,143.57
+1.8V_RUN_CARD on TOP (solid shape): 259.89,9.94 259.89,7.3 258.87,6.29 248.75,6.29 248.65,6.39 248.65,8.31 249.08,8.74 255.37,8.74 255.88,8.23 258.28,8.23 258.49,8.45 258.49,9.85 258.66,10.02 259.81,10.02
+1.8V_RUN_CARD on TOP (solid shape): 248.71,42.67 248.71,42.54 248.66,42.49 248.01,42.49 247.89,42.37 247.89,41.48 247.44,41.03 246.43,41.03 246.11,40.72 246.11,37.6 246.62,37.1 246.62,34.49 246.61,34.48 246.58,34.33 246.61,34.18 246.62,34.17 246.62,32.46 246.49,32.33 245.6,32.33 245.47,32.46 245.47,36.46 245.16,36.78 245.16,36.81 245.16,37.93 245.17,37.97 245.2,37.99 245.54,38.34 245.2,38.7 245.17,38.71 245.16,38.75 245.16,41.48 245.41,41.73 246.74,41.73 247.76,42.75 248.64,42.75
+1.8V_RUN_CARD on BOTTOM (solid shape): outline of 234 points within 245.46,6.27 249.92,33.16
+1.8V_RUN_GFX on TOP (solid shape): outline of 391 points within 230.93,113.08 241.18,135.61
+1.8V_RUN_GFX on TOP (solid shape): outline of 445 points within 252.14,141.24 289.03,147.61
+1.8V_RUN_GFX on BOTTOM (solid shape): outline of 585 points within 225.62,110.12 232.28,121.23
+1.8V_RUN_GFX on IN1 (solid shape): outline of 1138 points within 222.11,111.26 233.66,123.08
+1.8V_RUN_GFX on IN3 (solid shape): outline of 275 points within 237.56,112.12 254.62,145.81
+1.8V_RUN_GFX on VCC: 228.82,111.14 226.53,113.42 224.88,113.42 224.65,113.66 224.65,121.95 224.88,122.19 228.22,122.19 230.51,119.9 234.02,119.9 234.68,120.56 234.68,126.4 235.17,126.89 238.76,126.89 239.38,126.27 239.38,113.02 237.49,111.14
+1.8V_RUN_GFX_VDDR4 on IN1 (solid shape): outline of 725 points within 226.17,133.74 239,138.32
+1.8V_RUNP on TOP (solid shape): 289.99,141.36 289.99,139.14 290.18,138.95 290.18,138.44 289.99,138.25 286.18,138.25 285.92,138 285.92,136.16 285.73,135.97 284.21,135.97 284.15,136.03 284.15,141.24 284.4,141.49 287.32,141.49 287.32,140.98 287.89,140.98 287.89,141.49 288.08,141.49 288.08,140.98 288.72,140.98 288.72,141.55 289.8,141.55
+1.35V_CPU_VDDQ on TOP (solid shape): outline of 12090 points within 141.32,69.91 171.33,92.91
+1.35V_CPU_VDDQ on BOTTOM (solid shape): outline of 201 points within 143.81,88.76 166.1,92.91
+1.35V_CPU_VDDQ on IN1 (solid shape): outline of 888 points within 144.13,88.39 165.71,93.36
+1.35V_CPU_VDDQ on IN2 (solid shape): outline of 1017 points within 143.08,88.67 165.59,93.1
+1.35V_CPU_VDDQ on IN3 (solid shape): outline of 9539 points within 143.56,69.8 165.46,93.17
+1.35V_MEM on TOP (solid shape): outline of 11671 points within 142.57,16.78 193.26,103.64
+1.35V_MEM on BOTTOM (solid shape): 154.29,33.57 154.36,33.66 154.47,33.64 154.55,33.57 154.64,33.53 154.66,33.53 154.97,33.22 154.97,32.74 154.19,31.96 154.19,31.94 154.14,31.89 154.1,31.86 154.06,31.89 154.04,31.91 154.03,31.95 154.04,31.98 154.29,32.23
+1.35V_MEM on BOTTOM (solid shape): 150.2,25.1 150.29,25.05 150.29,25.03 150.29,24.68 149.37,23.76 149.35,23.75 149.34,23.75 149.19,23.74 149.07,23.66 148.96,23.65 148.9,23.74 148.9,24.12 149.33,24.55 149.57,24.55 150,24.98 150.07,25.02 150.12,25.06
+1.35V_MEM on BOTTOM (solid shape): 153.32,33.62 153.38,33.53 153.38,32.8 152.6,32.03 152.58,32.03 152.47,32 152.37,31.93 152.3,31.89 152.21,31.94 152.21,31.96 152.21,32.81 152.92,33.51 152.94,33.52 152.95,33.52 153.09,33.54 153.21,33.61
+1.35V_MEM on BOTTOM (solid shape): 160.21,20.14 160.23,20.13 160.25,20.12 160.45,20 160.68,20.03 160.77,20.02 160.82,19.94 160.82,19.49 160.67,19.34 160.02,19.34 159.69,19 159.62,18.97 159.57,18.93 159.5,18.89 159.41,18.94 159.41,18.96 159.41,19.51 160.04,20.14
+1.35V_MEM on BOTTOM (solid shape): 148.96,42.88 149,42.87 149.01,42.83 149.01,42.11 149,42.07 148.96,42.06 148.51,42.06 148.28,41.83 148.28,41.19 148.41,41.06 148.43,40.95 148.34,40.89 146.7,40.89 146.66,40.9 146.65,40.94 146.65,41.27 146.66,41.3 146.7,41.32 147.1,41.32 147.32,41.54 147.32,41.73 147.38,41.82 147.49,41.81 147.89,41.76 148.08,42.11 148.08,42.13 148.09,42.15 148.48,42.53 148.48,42.83 148.49,42.87 148.53,42.88
+1.35V_MEM on BOTTOM (solid shape): 159.76,44.03 159.79,44.02 159.81,43.98 159.81,43.61 160.03,43.39 160.09,43.39 160.11,43.39 160.12,43.37 160.32,43.25 160.54,43.27 160.64,43.27 160.68,43.18 160.68,42.49 160.64,42.41 160.54,42.4 160.19,42.36 160.04,42.04 160.04,42.02 160.03,42 159.54,41.51 159.54,40.34 159.41,40.21 159.4,40.21 159.31,40.16 159.24,40.09 159.2,40.06 159.16,40.09 159.14,40.12 159.11,40.14 159.11,40.16 159.36,40.41 159.36,41.64 159.09,41.92 158.92,41.92 158.88,41.93 158.87,41.97 158.87,42.43 158.88,42.47 158.92,42.48 159.1,42.48 159.46,42.85 159.46,43.98 159.48,44.02 159.51,44.03
+1.35V_MEM on BOTTOM (solid shape): 156.97,42.87 157.01,42.85 157.02,42.82 157.02,42.33 157.25,42.11 157.27,42.11 157.31,42.09 157.32,42.06 157.49,41.78 157.81,41.75 157.91,41.74 157.95,41.65 157.95,41.41 158.19,41.17 158.19,40.9 158.18,40.86 158.14,40.85 157.76,40.85 157.49,40.58 157.49,40.16 157.49,40.14 157.4,40.09 157.31,40.14 157.31,40.16 157.31,40.4 157.09,40.62 156.64,40.62 156.61,40.64 156.59,40.67 156.59,40.8 156.61,40.83 156.64,40.85 157.07,40.85 157.23,41.01 157.28,41.08 157.29,41.16 157.29,41.73 157.13,41.89 157.06,41.94 156.98,41.95 156.7,41.95 156.67,41.97 156.65,42.01 156.65,42.82 156.67,42.85 156.7,42.87
+1.35V_MEM on BOTTOM (solid shape): outline of 740 points within 146.27,61.95 188.24,101.1
+1.35V_MEM on BOTTOM (solid shape): outline of 5169 points within 144.38,15.89 162.67,46.11
+1.35V_MEM on GND2: 160.11,18.43 159.35,19.19 144.23,19.19 143.62,19.8 143.62,26.03 142.98,26.66 142.98,47.62 142.6,48 142.6,63.41 143.11,63.92 143.11,68.36 144.64,69.88 144.64,88.55 145,88.91 160.02,88.91 160.51,88.43 160.51,81.4 159.62,80.51 159.62,78.7 160.96,77.36 161.29,77.36 162.92,75.73 162.92,48.17 164.83,46.26 164.83,37.46 164.45,37.07 164.45,27.42 163.69,26.66 163.69,23.15 164.32,22.51 164.32,18.91 163.83,18.43
+1.35V_MEM on VCC: 144.87,30.75 144.25,31.36 144.25,35.68 142.86,37.07 142.86,43.17 142.35,43.68 142.35,57.95 143.75,59.34 143.75,62.65 145.65,64.55 145.65,76.62 147.43,78.39 147.43,88.28 163.94,88.28 163.94,78.98 162.92,77.97 162.92,64.3 164.96,62.26 164.96,43.81 164.32,43.17 164.32,31.74 163.33,30.75
+1.35V_MEM_GFX on TOP (solid shape): 189.97,109.28 192.91,109.28 192.98,109.25 193.01,109.18 193.37,108.84 193.72,109.18 193.75,109.25 193.82,109.28 194.89,109.28 195.79,108.38 195.96,108.38 195.99,108.34 195.99,106.54 195.14,105.68 192.94,105.68 192.93,105.68 190.11,105.68 189.91,105.88 189.91,106.35 189.92,106.36 189.92,107.31 189.72,107.52 189.72,109.13 189.92,109.33
+1.35V_MEM_GFX on BOTTOM (solid shape): 206.82,115.26 206.82,111.57 206.13,110.88 204.68,110.88 204.45,111.11 204.45,116.42 204.55,116.52 205.56,116.52
+1.35V_MEM_GFX on BOTTOM (solid shape): 191.18,110.92 191.18,109.97 191.78,109.37 192.98,109.37 192.98,109.19 193.37,108.81 193.75,109.19 193.75,109.9 193.59,110.05 193.59,110.92 193.67,111 195.23,111 195.46,110.77 195.46,109.92 196.1,109.28 196.1,107.68 195.8,107.39 189.96,107.39 189.48,107.87 189.48,109.4 189.63,109.62 189.53,109.87 189.53,111.01 191.09,111.01
+1.35V_MEM_GFX on IN1 (solid shape): outline of 2783 points within 181.21,107.65 198.48,145.81
+1.35V_MEM_GFX on IN2 (solid shape): outline of 23682 points within 184.01,115.2 233.51,171.83
+1.35V_MEM_GFX on IN3 (solid shape): outline of 19526 points within 182.06,114.31 215.89,167.18
+1.35V_MEM_GFX on VCC: 190.97,107.58 190.33,108.22 183.98,108.22 183.24,108.96 183.24,121.02 181.47,122.8 181.47,155.22 181.58,155.33 183.48,155.33 185.38,157.24 195.29,157.24 196.45,158.4 196.45,166.66 197.32,167.53 237.49,167.53 239.63,165.39 239.63,158.28 235.8,154.44 235.8,140.09 234.27,138.57 227.08,138.57 226.57,138.06 217.3,138.06 216.52,137.28 216.52,128.01 215.9,127.39 215.65,127.39 214,125.74 213.36,125.74 212.33,124.7 212.33,120.26 207.12,115.05 207.12,113.15 206.89,112.92 203.97,112.92 199.14,108.09 195.58,108.09 195.08,107.58
+1.35V_MEN_P on TOP (solid shape): 211.37,12.73 211.37,12.14 212.33,11.19 212.33,9.98 212.26,9.92 211.56,9.92 211.5,9.98 211.5,11.57 211.12,11.95 211.12,12.74 211.15,12.76 211.34,12.76
+1.35V_MEN_P on TOP (solid shape): 210.36,10.17 210.36,8.97 210.29,8.9 209.02,8.9 208.96,8.97 208.96,9.28 209.53,9.28 209.53,9.79 209.02,9.79 209.02,10.17 209.15,10.3 209.97,10.3 209.97,10.3 210.23,10.3
+1.35V_MEN_P on TOP (solid shape): outline of 146 points within 175.12,5.38 188.7,17.03
+1.35V_MEN_P on BOTTOM (solid shape): 190.2,9.69 190.2,5.38 190.15,5.33 189.69,5.33 189.59,5.35 189.49,5.33 177.4,5.33 177.02,5.71 177.02,10.3 177.38,10.66 185.1,10.66 186.03,11.58 188.31,11.58
+1.35V_MEN_P on IN1 (solid shape): 181.72,8.65 181.72,7.63 181.59,7.51 180.32,7.51 180.2,7.63 180.2,8.65 180.32,8.78 181.59,8.78
+1.35V_MEN_P on IN1 (solid shape): 210.42,10.17 210.42,8.27 210.29,8.14 209.28,8.14 209.15,8.27 209.15,10.17 209.28,10.3 210.29,10.3
+3.3V_ALW on TOP (solid shape): 326.82,200.44 327.81,200.44 328.11,200.14 328.11,197.61 327.82,197.32 326.64,197.32 326.46,197.5 326.46,198.65 326.12,198.99 325.59,198.99 325.45,199.13 325.45,200.33 325.58,200.47 326.79,200.47
+3.3V_ALW on TOP (solid shape): 280.69,53.39 280.69,52.7 280.55,52.57 279.89,52.57 279.85,52.53 279.85,52.03 279.83,52.01 279.7,52.01 279.68,52.03 279.68,52.53 279.64,52.57 278.85,52.57 278.62,52.79 278.62,53.4 278.82,53.61 280.48,53.61
+3.3V_ALW on TOP (solid shape): 231,99.14 231.57,99.14 231.57,99.64 231.76,99.64 231.76,99.14 232.39,99.14 232.39,99.64 232.9,99.64 233.47,99.07 234.26,99.07 234.5,98.83 234.5,98.12 234.31,97.93 229.61,97.93 229.41,98.13 229.41,99.25 229.8,99.64 231,99.64
+3.3V_ALW on TOP (solid shape): 293.68,101.13 293.68,100.51 293.63,100.46 293.16,100.46 293.12,100.42 293.12,100 293.15,99.97 293.66,99.97 293.68,99.95 293.68,99.72 293.47,99.5 291.36,99.5 291.24,99.62 291.24,100.18 291.33,100.27 291.87,100.27 292.06,100.46 292.06,100.72 292.51,101.18 293.63,101.18
+3.3V_ALW on TOP (solid shape): 324.17,200.33 324.17,199.8 324.17,199.76 324.19,199.7 324.19,199.26 323.84,198.91 323.84,198.13 324.06,197.91 324.06,196.02 323.94,195.89 323.38,195.89 323.32,195.97 323.23,196.04 323.39,196.51 322.93,196.68 322.93,200.12 323.28,200.47 324.03,200.47
+3.3V_ALW on TOP (solid shape): 139.94,16 139.94,14.81 139.95,14.8 139.95,14.41 139.71,14.17 138.29,14.17 138.25,14.21 138.25,14.64 138.18,14.71 137.55,14.71 137.49,14.64 137.49,14.2 137.45,14.16 137.1,14.16 137.04,14.22 137.04,14.66 136.99,14.71 136.34,14.71 136.29,14.66 136.29,14.21 136.25,14.17 132.98,14.17 132.94,14.21 132.94,14.68 132.9,14.72 132.22,14.72 132.16,14.67 132.16,14.17 132.15,14.16 131.72,14.16 131.71,14.17 131.71,14.67 131.66,14.72 131.03,14.72 130.96,14.64 130.96,14.24 130.89,14.17 130.44,14.17 130.23,14.38 130.23,16.18 130.53,16.47 139.47,16.47
+3.3V_ALW on TOP (solid shape): 251.04,145.96 251.04,145.33 251.03,145.32 251.03,143.91 249.63,142.51 248.5,142.51 248.45,142.56 248.45,143.3 248.55,143.4 248.55,144.01 248.62,144.13 248.64,144.28 248.45,144.69 248.01,144.59 247.94,144.55 247.86,144.58 247.77,144.67 247.24,144.67 247.07,144.5 247.07,144.05 247.04,144.04 246.83,143.71 247.04,143.39 247.07,143.37 247.07,142.58 247.02,142.53 245.61,142.53 245.42,142.71 245.42,146.16 245.96,146.7 250.3,146.7
+3.3V_ALW on TOP (solid shape): outline of 141 points within 282.62,128.49 291.7,134
+3.3V_ALW on TOP (solid shape): outline of 548 points within 282.22,171.77 308.94,190.55
+3.3V_ALW on BOTTOM (solid shape): 287.72,181.93 287.72,181.33 287.53,181.15 286.6,181.15 286.4,180.94 285.47,180.94 285.39,181.03 285.39,181.9 285.63,182.14 287.51,182.14
+3.3V_ALW on BOTTOM (solid shape): 324.6,162.35 324.58,162.32 323.68,162.32 323.33,162.68 323.33,163.59 323.49,163.75 323.49,165.79 323.21,166.07 323.21,167.37 323.94,168.09 324.6,168.09
+3.3V_ALW on BOTTOM (solid shape): 284.27,187.01 284.27,186.3 283.76,185.8 283.76,182.57 284.02,182.31 284.02,181.04 283.97,180.98 282.84,180.98 282.44,181.38 282.44,187.05 282.71,187.32 283.96,187.32
+3.3V_ALW on BOTTOM (solid shape): 301,190.92 301,190.26 300.84,190.1 300.84,188.44 300.71,188.31 299.36,188.31 299.25,188.41 299.25,190.86 299.38,190.99 300.93,190.99
+3.3V_ALW on BOTTOM (solid shape): 305.68,189.45 307.88,189.45 308.19,189.14 308.19,186.9 308.11,186.82 304.65,186.82 304.26,187.22 304.26,189 303.54,189.71 302.66,189.71 302.32,190.05 302.32,190.93 302.38,190.99 304.14,190.99
+3.3V_ALW on BOTTOM (solid shape): outline of 271 points within 166.48,152.97 171.05,165.03
+3.3V_ALW on IN3 (solid shape): outline of 283 points within 281.97,171.6 287.88,186.94
+3.3V_ALW on IN3 (solid shape): outline of 420 points within 43.92,183.51 55.98,193.81
+3.3V_ALW on TOP: 171.38,167.3 168.65,167.3 167.35,165.99 167.35,162.9 167.61,162.64 171.12,162.64 171.54,163.06 171.54,167.14
+3.3V_ALW on VCC: outline of 1322 points within 130.16,13.09 328.15,206.77
+3.3V_ALW2 on TOP (solid shape): 72.63,171.72 74.79,171.72 75.04,171.46 75.04,170.83 75.29,170.57 76.06,170.57 76.18,170.7 76.18,171.59 76.31,171.72 77.33,171.72 77.58,171.46 78.34,171.46 78.47,171.34 78.47,170.32 78.09,169.94 73.64,169.94 73.01,170.57 72.5,170.57 72.12,170.95 72.12,171.72 72.25,171.84 72.5,171.84
+3.3V_ALW2_C2 on TOP (solid shape): 162.81,172.1 162.85,172.08 162.86,172.05 162.86,170.83 164,169.68 164,169.05 163.94,168.99 163.18,168.99 163.11,169.05 163.11,169.93 163.11,169.94 162.67,170.38 162.67,172.05 162.68,172.08 162.72,172.1
+3.3V_ALW_5048 on TOP (solid shape): 279.52,52.41 279.52,51.9 279.57,51.85 279.98,51.85 280.01,51.88 280.01,52.37 280.04,52.41 280.27,52.41 280.44,52.25 280.44,51.26 280.22,51.04 279.51,51.04 279.43,50.96 278.6,50.96 278.47,51.09 278.47,51.42 278.57,51.52 279.14,51.52 279.27,51.65 279.27,52.4 279.29,52.43 279.51,52.43
+3.3V_ALW_PCH on TOP (solid shape): 322.56,164.22 322.56,163.08 322.44,162.95 320.83,162.95 320.53,163.25 320.53,164.22 320.66,164.35 322.44,164.35
+3.3V_ALW_PCH on TOP (solid shape): 327.01,192.93 327.01,190.89 326.88,190.77 326.25,190.77 326.25,191.27 325.74,191.27 325.74,190.77 325.23,190.77 325.1,190.89 325.1,192.93 325.23,193.05 326.88,193.05
+3.3V_ALW_PCH on TOP (solid shape): 327.64,210.58 327.64,209.94 327.13,209.94 327.13,209.44 327.64,209.44 327.64,209.05 327.52,208.93 325.48,208.93 325.36,209.05 325.36,210.45 325.61,210.71 327.52,210.71
+3.3V_ALW_PCH on TOP (solid shape): 309.35,141.87 309.35,141.29 309.34,141.2 309.35,141.1 309.35,139.46 309.1,139.2 308.21,139.2 307.96,139.46 307.96,141.87 308.08,142 309.23,142
+3.3V_ALW_PCH on TOP (solid shape): 301.46,112.03 301.46,111.06 301.73,110.78 302.27,110.78 302.62,111.14 304.02,111.14 304.33,111.44 304.88,111.44 305.04,111.29 305.04,110.38 304.71,110.05 301.38,110.05 300.77,110.65 300.77,112.01 300.81,112.05 301.43,112.05
+3.3V_ALW_PCH on TOP (solid shape): 198.18,60.69 198.18,59.74 197.66,59.22 197.32,59.22 197.18,59.36 197.18,59.85 197.24,60.19 196.99,60.42 196.97,60.43 196.67,60.73 196.66,60.75 196.56,60.95 196.37,61.05 196.35,61.05 196.25,61.15 196.25,61.28 196.79,61.82 197.05,61.82
+3.3V_ALW_PCH on TOP (solid shape): 346.24,189.53 346.72,189.53 346.72,190.09 347.66,190.09 347.85,189.9 347.85,188.87 347.25,188.61 347.85,188.35 347.85,188.34 347.61,188.1 345.85,188.1 345.59,188.37 345.59,189.92 345.77,190.09 346.24,190.09
+3.3V_ALW_PCH on TOP (solid shape): 253.98,138.57 253.98,125.23 254.02,125.2 254.02,125.14 254.11,125.05 254.11,119.65 254.5,119.26 254.51,119.23 254.5,119.19 254.52,118.71 255,118.69 255.04,118.7 255.07,118.69 255.51,118.25 255.51,115.96 255.13,115.58 253.86,115.58 253.09,116.34 253.09,128.54 252.33,129.3 252.33,137.86 251.19,139.01 249.31,139.01 249.19,139.12 249.19,139.77 248.41,140.55 248.41,141.15 248.49,141.24 251.32,141.24
+3.3V_ALW_PCH on TOP (solid shape): 199.87,58.78 199.9,58.68 199.82,58.61 199.76,58.59 199.7,58.54 199.41,58.26 199.41,57.9 199.77,57.9 200.06,58.18 200.1,58.24 200.13,58.31 200.2,58.38 200.3,58.36 201.1,57.56 201.1,57.15 200.83,56.88 200.28,56.88 200.27,56.87 200.15,56.87 199.94,57.07 199.37,57.07 199.06,56.76 198.53,56.76 197.98,57.31 197.98,58.26 198.02,58.35 198.12,58.35 198.61,58.56 198.35,59.02 198.28,59.09 198.3,59.19 198.7,59.59 199.07,59.59
+3.3V_ALW_PCH on TOP (solid shape): 186.8,65.04 186.8,64.93 186.76,64.85 186.68,64.83 186.27,64.5 186.64,64.12 186.71,64.09 186.74,64.02 186.74,63.56 186.74,63.56 186.84,63.3 187.1,63.19 187.12,63.19 187.31,63 187.31,61.86 189,60.17 189,60.14 189.1,59.84 189.38,59.72 189.45,59.72 189.59,59.58 191.63,59.58 192.15,59.05 192.15,59.04 192.25,58.85 192.43,58.76 192.45,58.75 192.55,58.65 192.55,58.19 192.27,57.91 190,57.91 185.45,62.46 185.45,62.61 185.5,62.7 185.61,62.7 185.66,62.67 185.73,62.65 185.79,62.61 185.81,62.54 186.38,62.21 186.22,62.85 186.16,62.89 186.14,62.96 185.92,63.33 185.51,63.23 185.43,63.19 185.36,63.22 185.02,63.56 185.02,65.29 185.28,65.54 186.29,65.54
+3.3V_ALW_PCH on TOP (solid shape): outline of 664 points within 192.51,44.16 216.64,55.77
+3.3V_ALW_PCH on BOTTOM (solid shape): 251.44,141.11 251.44,139.08 252.08,138.44 253.98,138.44 254.11,138.32 254.11,137.93 253.98,137.81 250.55,137.81 250.3,138.06 250.3,141.11 250.55,141.36 251.19,141.36
+3.3V_ALW_PCH on BOTTOM (solid shape): 209.99,70.5 209.99,70.27 209.86,70.14 209.86,69.79 209.2,69.13 209.02,69.13 208.97,69.18 208.97,69.71 209.28,70.01 209.32,70.01 209.51,70.2 209.51,70.55 209.58,70.62 209.86,70.62
+3.3V_ALW_PCH on BOTTOM (solid shape): 186.93,65.8 186.93,65.54 186.42,65.04 186.42,64.78 186.29,64.66 185.95,64.66 185.54,65.07 185.52,65.05 185.4,65.16 185.4,65.54 185.52,65.66 185.54,65.67 185.75,65.77 185.85,65.98 185.86,66 185.91,66.05 186.67,66.05
+3.3V_ALW_PCH on BOTTOM (solid shape): 211.08,71.74 211.5,71.74 211.59,71.65 211.59,71.51 211.51,71.44 211.18,71.44 211.01,71.26 211.01,70.63 210.62,70.25 210.38,70.25 210.29,70.27 210.22,70.28 210.15,70.31 210.12,70.38 210.12,71.08 209.99,71.21 209.73,71.21 209.64,71.3 209.63,71.54 209.76,71.67 210.65,71.67 210.78,71.79 211.03,71.79
+3.3V_ALW_PCH on BOTTOM (solid shape): 47.35,180.1 47.35,178.03 47.34,177.99 47.3,177.98 46.96,177.62 47.3,177.27 47.34,177.25 47.35,177.22 47.35,171.84 47.86,171.34 47.86,170.07 47.74,169.94 45.96,169.94 44.94,170.95 44.94,173.97 44.97,174.03 45.03,174.07 45.36,174.42 45.03,174.78 44.97,174.81 44.94,174.88 44.94,179.46 45.45,179.46 45.45,179.97 44.94,179.97 44.94,180.61 45.07,180.73 46.72,180.73
+3.3V_ALW_PCH on BOTTOM (solid shape): 256.33,116.74 256.33,109.8 255.06,108.53 255.06,98.37 254.49,97.8 254.49,96.41 255,95.9 255,91.45 255,91.33 255.71,90.61 255.71,87.69 255.65,87.59 255.53,87.62 254.92,87.38 255.53,87.13 255.65,87.16 255.71,87.06 255.71,81.75 255.51,81.55 254.62,81.55 254.45,81.71 254.45,83.41 254.49,83.45 254.49,85.61 254.45,85.65 254.45,85.65 253.82,86.29 253.82,90.88 253.73,90.97 253.73,91.71 253.7,91.74 253.69,91.75 253.61,91.87 253.49,91.95 253.48,91.95 253.4,92.04 253.4,95.46 253.35,95.51 253.35,95.64 252.97,96.02 252.97,104.03 253.35,104.41 253.35,104.41 253.4,104.46 253.4,108.42 253.35,108.47 253.35,112.92 254.49,114.06 254.49,114.78 254.66,114.95 254.66,116.79 254.85,116.98 256.09,116.98
+3.3V_ALW_PCH on BOTTOM (solid shape): outline of 256 points within 184.26,77.74 190.23,94.65
+3.3V_ALW_PCH on BOTTOM (solid shape): outline of 277 points within 319.13,163.08 327.64,180.73
+3.3V_ALW_PCH on BOTTOM (solid shape): outline of 296 points within 274.68,105.99 277.99,118.38
+3.3V_ALW_PCH on BOTTOM (solid shape): outline of 333 points within 194.42,49.57 203.82,58.94
+3.3V_ALW_PCH on IN1 (solid shape): 308.97,141.74 308.97,139.71 307.96,138.7 307.96,112.66 305.54,110.25 304.15,110.25 304.02,110.38 304.02,111.26 306.56,113.8 306.56,140.73 307.83,142 308.72,142
+3.3V_ALW_PCH on IN1 (solid shape): 106.52,148.46 106.57,148.42 106.63,148.38 107.4,147.61 107.4,147.4 109.08,145.72 109.08,140.91 111.87,138.12 111.87,123.97 111.87,123.84 114.28,121.42 114.28,116.34 114.92,115.7 114.92,115.68 115.02,115.38 115.32,115.28 115.34,115.28 115.81,114.82 115.81,113.8 115.62,113.61 115.59,113.62 115.15,113.43 115.3,112.98 115.3,112.25 115.26,112.25 114.96,111.9 115.26,111.54 115.3,111.54 115.3,110.75 115.26,110.75 114.97,110.4 115.26,110.05 115.3,110.04 115.3,109.24 115.27,109.23 115.03,108.9 115.27,108.56 115.3,108.55 115.3,103.18 115.3,103.17 115.27,103.05 115.3,102.92 115.3,102.91 115.3,102.41 115.3,102.4 115.33,102.15 115.52,101.98 115.55,101.96 115.55,100.98 115.3,100.72 114.82,100.72 113.14,102.41 113.14,114.69 112.53,115.3 112.5,115.36 112.5,121.3 110.85,122.95 110.85,137.68 108.06,140.47 108.06,145.17 105.52,147.71 105.52,148.6 105.77,148.86 106.12,148.86
+3.3V_ALW_PCH on IN1 (solid shape): outline of 274 points within 212.45,81.8 226.55,86.12
+3.3V_ALW_PCH on IN1 (solid shape): outline of 371 points within 324.59,191.53 328.15,210.07
+3.3V_ALW_PCH on IN1 (solid shape): outline of 492 points within 191.88,52.59 199.88,60.21
+3.3V_ALW_PCH on IN2 (solid shape): 48.12,171.21 48.12,170.19 47.86,169.94 46.97,169.94 46.72,170.19 46.72,171.34 46.85,171.46 47.86,171.46
+3.3V_ALW_PCH on IN2 (solid shape): 106.41,148.98 106.41,147.59 106.28,147.46 105.52,147.46 105.27,147.71 105.27,148.98 105.39,149.11 106.28,149.11
+3.3V_ALW_PCH on IN2 (solid shape): 273.77,118.45 274.53,118.45 274.84,118.76 276.38,118.76 276.44,118.75 276.49,118.76 276.72,118.76 276.97,118.5 276.97,117.34 276.64,117 271.63,117 269.75,118.88 269.73,118.88 269.6,119.01 268.59,119.01 267.7,118.12 265.79,118.12 263.89,116.22 261.98,116.22 261.74,116.32 261.49,116.23 261.48,116.22 260.97,115.71 254.74,115.71 254.49,115.96 254.49,117.36 255,117.87 262.23,117.87 262.24,117.83 262.63,117.54 262.94,117.91 262.94,117.94 265.16,120.15 272.07,120.15
+3.3V_ALW_PCH on IN2 (solid shape): outline of 111 points within 114.79,76.72 185.15,102.12
+3.3V_ALW_PCH on IN2 (solid shape): 188.56,78.63 188.8,78.51 189.05,78.6 189.08,78.61 189.12,78.59 189.34,78.37 189.34,77.74 189.09,77.48 187.82,77.48 187.31,76.97 187.31,76.59 187.21,76.34 187.31,76.09 187.31,75.79 187.16,75.5 187.31,75.21 187.31,74.56 188.7,73.16 188.7,70.24 187.18,68.72 187.18,67.19 187.01,66.89 187.18,66.59 187.18,64.91 187.01,64.74 186.94,64.71 186.87,64.74 186.49,64.81 186.27,64.5 186.24,64.43 186.17,64.4 185.93,64.4 185.4,64.93 185.4,65.56 185.43,65.63 185.5,65.66 185.86,66.02 185.5,66.38 185.43,66.41 185.4,66.48 185.4,69.1 187.31,71.01 187.31,72.15 186.29,73.16 186.29,77.48 186.44,77.63 186.46,77.64 186.67,77.74 186.77,77.95 186.77,77.97 187.43,78.63
+3.3V_ALW_PCH on IN2 (solid shape): 249.16,85.1 249.16,83.45 249.79,82.82 260.08,82.82 260.33,82.57 262.07,82.57 262.16,82.5 262.13,82.39 262.01,82.15 262.09,81.89 262.11,81.83 262.09,81.76 262.36,81.18 262.64,81.76 262.62,81.83 262.64,81.89 262.72,82.15 262.6,82.39 262.57,82.5 262.66,82.57 268.75,82.57 268.79,82.54 269.41,81.91 269.41,81.1 269.1,80.79 269.08,80.79 268.83,80.74 268.69,80.53 268.68,80.49 265.69,80.49 265.41,80.63 265.13,80.49 257.64,80.49 257.29,80.84 257.21,80.84 257.2,80.85 257.03,80.89 256.87,80.85 256.85,80.84 255.85,80.84 255.24,81.45 248.5,81.45 248.01,81.93 248.01,83.2 246.36,84.85 241.25,84.85 241.07,84.9 240.88,84.85 226.04,84.85 225.41,85.48 225.41,85.86 225.66,86.12 229.96,86.12 230.18,85.9 242.89,85.9 243.74,86.75 247.51,86.75
+3.3V_ALW_PCH on IN3 (solid shape): 327.77,192.54 327.77,184.49 327.74,184.42 327.66,184.39 327.29,184.04 327.66,183.68 327.74,183.65 327.77,183.58 327.77,180.23 327.64,180.1 325.99,180.1 325.86,180.23 325.86,183.4 326.12,183.65 326.12,183.86 326.12,183.86 326.12,187.08 326.63,187.59 326.63,187.79 326.63,187.79 326.63,188.15 326.63,188.23 325.61,189.24 325.61,192.67 325.99,193.05 327.26,193.05
+3.3V_ALW_PCH on IN3 (solid shape): outline of 689 points within 182.86,84.98 226.8,94.88
+3.3V_ALW_PCH on IN3 (solid shape): outline of 673 points within 275.95,102.88 305.54,111.52
+3.3V_ALW_PCH on TOP: 206.85,65.57 207.08,65.34 207.08,65.33 207.17,65.19 207.31,65.1 207.32,65.1 207.39,65.03 207.48,64.76 207.74,64.67 208.87,64.67 209.83,63.72 209.83,62.5 210.23,62.09 210.23,61.86 209.89,61.52 209.8,61.52 208.81,62.51 208.52,62.51 208.15,62.88 207.17,62.88 206.97,62.68 206.94,62.7 206.56,62.72 206.39,62.39 206.36,62.31 206.29,62.28 205.93,62.28 204.66,63.55 204.66,64.15 204.69,64.17 204.71,64.2 204.79,64.24 204.87,64.21 205.24,64.12 205.48,64.41 205.51,64.48 205.57,64.5 205.84,64.64 205.91,64.94 205.94,65.03 206.03,65.06 206.35,65.14 206.46,65.45 206.48,65.53 206.56,65.57
+3.3V_ALW_VTR on TOP (solid shape): 296.19,100.86 296.19,99.92 295.83,99.57 293.89,99.57 293.84,99.62 293.84,100.1 293.81,100.13 293.3,100.13 293.28,100.15 293.28,100.28 293.3,100.3 293.78,100.3 293.84,100.36 293.84,101 293.98,101.14 295.91,101.14
+3.3V_ALW_VTR on IN2 (solid shape): 294.85,111.61 294.85,110.36 294.62,110.13 294.23,110.13 294.12,110.24 294.13,110.27 294.09,110.63 293.8,110.84 293.78,110.85 293.7,110.93 293.75,110.97 293.76,110.98 293.85,111.01 293.93,111.07 294,111.1 294.07,111.08 294.66,111.34 294.07,111.61 294,111.58 293.93,111.61 293.38,111.61 293.4,111.06 293.43,110.95 293.33,110.88 291.96,110.88 291.59,110.52 291.24,110.52 291.18,110.58 291.19,110.61 291.2,110.86 291.04,111.06 291.04,111.24 291.09,111.33 291.19,111.33 291.6,111.37 291.7,111.76 291.71,111.86 291.79,111.9 294.56,111.9
+3.3V_CARD on TOP (solid shape): 270.92,34.92 270.92,33.06 270.85,32.98 269.93,32.98 269.71,33.21 269.71,34.73 270.07,35.1 270.75,35.1
+3.3V_CARD on TOP (solid shape): 283.83,33.67 285.22,33.67 285.35,33.54 285.35,33.03 285.22,32.91 282.68,32.91 282.56,33.03 281.54,33.03 281.41,33.16 285.1,33.16 285.1,33.41 284.34,33.41 284.34,33.16 281.41,33.16 281.41,33.92 281.29,34.05 280.53,34.05 280.4,34.18 280.4,34.81 280.53,34.94 282.56,34.94
+3.3V_CARD on TOP (solid shape): 268.68,37.19 268.68,36.13 268.71,36.09 270.76,36.09 270.84,36.02 270.84,35.89 270.76,35.81 269.83,35.81 269.08,35.06 268.77,35.06 268.75,35.08 268.09,35.08 268,35.17 268,35.94 267.9,36.04 267.5,36.04 267.37,36.17 267.37,37.17 267.5,37.3 268.56,37.3
+3.3V_CARD on BOTTOM (solid shape): outline of 325 points within 269.78,29.78 282.65,34.9
+3.3V_CARD on IN1 (solid shape): outline of 205 points within 267.14,32.22 270.94,37.91
+3.3V_LAN on TOP (solid shape): outline of 130 points within 306.94,190.39 322.05,194.83
+3.3V_LAN on BOTTOM (solid shape): 300.62,199.53 300.62,196.9 300.39,196.66 300.39,194.27 300.22,194.11 300.22,194.07 299.98,193.56 300.54,193.46 300.58,193.47 300.61,193.46 300.75,193.37 300.91,193.34 300.99,193.32 301.02,193.24 301.02,192.37 300.92,192.27 299.24,192.27 299,192.51 299,194.14 299.23,194.37 299.23,196.17 297.43,197.97 297.43,199.66 297.62,199.85 300.31,199.85
+3.3V_LAN on IN4: 299.95,199.72 302.85,199.72 303.36,199.21 303.36,197.24 306.01,194.59 306.01,193.53 307.91,191.62 307.91,190.45 307.79,190.33 305.72,190.33 304.32,191.72 304.32,194.14 299.82,198.64 299.82,199.59
+3.3V_LAN_OUT on TOP (solid shape): 317.61,196.1 317.61,195.57 317.52,195.48 316.44,195.48 316.35,195.38 316.35,194.33 316.21,194.2 315.58,194.2 315.32,194.45 315.32,196.1 315.45,196.23 317.48,196.23
+3.3V_LAN_OUT on BOTTOM (solid shape): 316.47,196.35 316.47,194.32 316.34,194.2 315.96,194.2 315.83,194.32 315.83,196.48 316.34,196.48
+3.3V_M on TOP (solid shape): 274.73,126.69 274.73,124.28 271.43,120.97 271.41,120.97 271.08,120.67 271.29,120.29 271.32,120.27 271.32,114.28 270.09,113.04 263,113.04 261.68,114.36 261.68,115.56 261.69,115.59 261.73,115.61 262.09,115.96 261.73,116.32 261.69,116.33 261.68,116.37 261.68,118.25 262.19,118.76 263.51,118.76 264.14,118.12 264.14,115.84 264.78,115.2 268.6,115.2 269.56,116.16 269.56,121.63 272.51,124.58 272.51,126.36 273.16,127.01 274.42,127.01
+3.3V_M on BOTTOM (solid shape): 200.15,42.62 201.98,42.62 202.09,42.51 202.09,42.01 201.96,41.88 201.14,41.88 201.01,42.01 200.62,42.01 200.61,42.02 200.01,42.02 199.88,41.88 199.14,41.88 198.86,42.16 198.86,42.47 198.96,42.56 199.19,42.56 199.2,42.57 199.44,42.57 199.61,42.74 200.03,42.74
+3.3V_M on BOTTOM (solid shape): outline of 97 points within 302.12,192.26 305.06,198.26
+3.3V_M on IN2 (solid shape): 274.86,126.58 274.86,126.17 274.53,125.84 272.98,125.84 272.88,125.95 272.88,126.52 273.16,126.8 274.65,126.8
+3.3V_M on IN2 (solid shape): 285.1,128.14 285.1,127.6 284.74,127.24 283.09,127.24 282.88,127.46 282.88,127.91 283.02,128.05 283.94,128.05 284.01,127.99 284.32,127.99 284.62,128.28 284.96,128.28
+3.3V_M on IN3 (solid shape): 263.04,118.57 263.04,116.85 262.85,116.66 262.35,116.66 262.14,116.88 262.14,118.64 262.3,118.8 262.81,118.8
+3.3V_M on IN3 (solid shape): 285.16,128.73 285.16,127.7 284.76,127.29 284.16,127.29 284.01,127.44 284.01,128.59 284.36,128.94 284.95,128.94
+3.3V_M on IN3 (solid shape): 304.83,196.95 305.62,196.95 305.93,196.65 305.93,196.13 305.77,195.97 304.58,195.97 304.25,196.3 304.25,197.04 304.35,197.14 304.64,197.14
+3.3V_M on IN3 (solid shape): 200.12,42.46 200.12,41.5 199.79,41.17 199.41,41.17 198.8,41.78 198.8,42.39 198.98,42.57 199.27,42.57 199.4,42.7 199.88,42.7
+3.3V_PCIE_FLASH on TOP (solid shape): 308,176.26 308,175.72 307.82,175.54 307.82,175.18 307.64,175.01 306.14,175.01 306.04,175.11 306.04,176.2 306.13,176.29 307.97,176.29
+3.3V_PCIE_FLASH on BOTTOM (solid shape): 306.99,177.55 306.99,175.64 307.6,175.04 307.6,174.87 307.6,174.87 307.6,173.71 307.46,173.57 306.08,173.57 305.96,173.68 305.96,175.27 306.36,175.67 306.36,177.61 306.42,177.67 306.87,177.67
+3.3V_PCIE_FLASH on BOTTOM (solid shape): 313.75,185.65 313.75,183.07 314.31,182.51 316.59,182.51 317.92,181.19 317.99,180.14 319.04,180.06 319.64,179.46 319.64,175.37 319.61,175.35 319.37,175.02 319.61,174.68 319.64,174.67 319.64,174.13 319.26,173.75 317.61,173.75 317.58,173.78 317.58,178.23 315.32,180.48 312.66,180.48 312.35,180.78 312.35,185.64 312.56,185.84 313.56,185.84
+3.3V_PCIE_FLASH on BOTTOM (solid shape): outline of 102 points within 285.39,175.62 294.95,179.75
+3.3V_PCIE_WWAN on TOP (solid shape): 345.68,207.66 345.68,207.31 346.27,206.72 346.27,205.93 346.16,205.82 345.73,205.82 345.72,205.81 345.51,205.81 345.19,205.5 343.92,205.5 343.14,205.5 343.01,205.63 343.01,207.66 343.14,207.78 345.55,207.78
+3.3V_PCIE_WWAN on TOP (solid shape): 336.41,207.53 336.41,202.32 335.82,201.74 325.53,201.74 325.48,201.79 325.48,202.49 325.81,202.82 325.81,204.05 325.97,204.2 327.03,204.2 327.34,204.51 327.34,207.3 327.82,207.78 336.15,207.78
+3.3V_PCIE_WWAN on TOP (solid shape): 321.15,129.85 321.15,129.68 320.91,129.44 320.91,127.65 320.57,127.3 320.57,126.9 320.51,126.83 318.16,126.83 318.11,126.88 318.11,127.67 318.29,127.85 319.18,127.85 319.77,128.43 319.77,129.78 319.9,129.92 321.09,129.92
+3.3V_PCIE_WWAN on BOTTOM (solid shape): outline of 580 points within 326.17,197.51 353.64,212.23
+3.3V_PCIE_WWAN on IN4 (solid shape): outline of 730 points within 317.01,126.7 328.72,139.18
+3.3V_RP1 on TOP (solid shape): outline of 231 points within 327.9,208.67 344.03,216.55
+3.3V_RP1 on BOTTOM (solid shape): 339.96,217.06 340.09,216.93 341.1,216.93 341.61,217.44 343.01,217.44 343.14,217.31 343.14,216.67 343.26,216.55 344.03,216.55 344.15,216.67 344.15,216.8 344.28,216.93 345.17,216.93 345.32,216.96 345.45,217.06 345.68,217.06 345.8,216.93 345.8,215.96 345.73,215.88 345.67,215.79 345.67,215.78 345.3,215.4 344.15,215.4 344.03,215.28 342.37,215.28 342.25,215.4 342.25,216.04 342.12,216.17 340.34,216.17 339.71,216.8 339.71,217.69 339.96,217.69
+3.3V_RP1 on IN1 (solid shape): outline of 152 points within 331.96,213.75 341.87,225.18
+3.3V_RP2 on TOP (solid shape): 334.97,193.09 336.14,193.09 336.15,193.08 336.15,191.91 335.9,191.66 334.49,191.66 332.62,193.52 332.62,194.18 332.76,194.32 333.74,194.32
+3.3V_RP2 on TOP (solid shape): 326.88,190.39 326.88,183.91 326.63,183.65 324.34,183.65 324.21,183.78 324.21,185.31 324.34,185.43 325.48,185.43 325.86,185.81 325.86,189.37 325.61,189.62 325.36,189.62 325.23,189.75 325.23,190.39 325.36,190.51 326.75,190.51
+3.3V_RP2 on BOTTOM (solid shape): 324.09,187.34 324.09,185.81 323.96,185.69 323.2,185.69 322.94,185.94 322.94,187.34 323.07,187.46 323.96,187.46
+3.3V_RP2 on IN3 (solid shape): outline of 377 points within 322.56,183.65 336.99,195.97
+3.3V_RP3 on IN3 (solid shape): outline of 860 points within 334.59,184.23 348.3,197.38
+3.3V_RP3 on TOP: 339.47,188.62 335.31,188.62 335.05,188.89 335.05,189.5 335.25,189.7 336.62,189.7 336.85,189.93 336.85,193.08 337.32,193.55 337.32,198.79 337.97,199.45 345.81,199.45 346.39,198.87 346.39,194.88 347.86,193.41 347.86,190.5 347.61,190.25 344.31,190.25 344.05,190.5 344.05,192.82 344.38,193.15 344.38,197.19 344.04,197.54 340.11,197.54 339.58,197 339.58,188.73
+3.3V_RP4 on BOTTOM (solid shape): 36.81,182.96 36.81,181.94 37.74,181.01 40.45,181.01 40.7,181.27 40.7,182.19 40.85,182.35 42.24,182.35 42.53,182.64 44.56,182.64 44.69,182.51 44.69,179.08 44.56,178.96 42.22,178.96 41.77,179.41 39.04,179.41 38.95,179.5 38.95,179.87 38.46,180.35 37.89,180.35 36.5,181.75 36.5,182.96 36.56,183.02 36.75,183.02
+3.3V_RP4 on IN2 (solid shape): outline of 200 points within 28.86,177.61 42.17,182.59
+3.3V_RP4 on IN3 (solid shape): outline of 191 points within 30.34,180.15 42.53,191.07
+3.3V_RUN on TOP (solid shape): 117.46,49.16 117.46,46.88 117.39,46.81 115.36,46.81 115.24,46.94 115.24,47.64 115.81,47.64 115.81,48.15 115.3,48.15 115.3,49.1 115.43,49.22 117.39,49.22
+3.3V_RUN on TOP (solid shape): 327.64,213.12 327.64,212.23 327.13,212.23 327.13,211.72 327.64,211.72 327.64,211.34 327.52,211.21 326.5,211.21 326.25,211.47 326.25,212.86 326.63,213.25 327.52,213.25
+3.3V_RUN on TOP (solid shape): 297.09,123.48 297.09,122.17 296.93,122.02 296.19,122.02 296.03,122.17 296.03,123.52 296.25,123.52 296.25,123.02 296.31,122.96 296.74,122.96 296.77,122.99 296.77,123.53 297.04,123.53
+3.3V_RUN on TOP (solid shape): 269.76,36.89 269.76,36.8 269.97,36.59 270.77,36.59 270.86,36.5 270.86,36.35 270.84,36.32 270.05,36.32 269.96,36.23 268.94,36.23 268.82,36.35 268.82,37.04 269.01,37.22 269.43,37.22
