# Allegro board LA-9411P R10-0403.brd (continued)
## Placement (name value [footprint] x y rotation side) (continued)
RH226  -  [R_0402]  193.44 65.81 225 top
RH227  -  [R_0402]  195.4 67.05 45 top
RH228  -  [R_0402]  191.55 67.7 225 bottom
RH229  -  [R_0402]  191.81 60.79 315 bottom
RH230  -  [R_0402]  192.18 67.07 225 bottom
RH231  -  [R_0402]  194.2 61.73 225 bottom
RH232  -  [R_0402]  212.3 64.45 135 top
RH233  -  [R0603_0OHM]  193.61 77.48 225 top
RH234  -  [R_0402]  207 69.84 135 top
RH235  -  [R_0603]  194.46 76.62 225 top
RH236  -  [R_0603]  206.19 82.16 135 top
RH237  -  [R_0603]  217.22 59.31 225 bottom
RH238  -  [R0603_0OHM]  218.08 58.44 225 bottom
RH239  -  [R_0402]  216.16 79.28 225 top
RH240  -  [R_0603]  216.38 85.61 0 top
RH241  -  [R0603_0OHM]  211.17 90.07 315 bottom
RH242  -  [R0805_0OHM]  219.72 60.85 45 top
RH243  -  [R_0805]  218.5 62.07 45 top
RH244  -  [R0805_0OHM]  215.72 80.24 135 top
RH245  -  [R0805_0OHM]  224.93 60.48 315 top
RH246  -  [R0603_0OHM]  209.7 92.18 315 bottom
RH247  -  [R0603_0OHM]  217.78 87.25 180 top
RH248  -  [R_0402]  188.82 70.52 133.7 top
RH254  -  [R_0402]  213.03 53.92 135 bottom
RH255  -  [R_0402]  219.34 81.18 225 top
RH256  -  [R_0402]  220.11 80.42 225 top
RH257  -  [R_0402]  215.14 57.14 135 top
RH258  -  [R_0402]  185.52 64.51 315 bottom
RH328  -  [R_0402]  213.54 55.83 45 top
RH362  -  [R_0402]  262.95 138.32 180 bottom
RPH1  -  [RP_0804_8P4R]  200.77 58.38 225 bottom
RPH2  -  [RP_0804_8P4R]  325.07 165.41 180 bottom
RPH3  -  [RP_0804_8P4R]  204.2 62.9 45 top
RPH4  -  [RP_0804_8P4R]  213.82 66.66 315 top
RPH5  -  [RP_0804_8P4R]  198.42 83.78 135 top
RPH6  -  [RP_0804_8P4R]  206.48 48.57 315 top
RPH7  -  [RP_0804_8P4R]  201.62 41.77 90 top
RPH8  -  [RP_0804_8P4R]  200.55 59.03 225 top
RPH9  -  [RP_0804_8P4R]  198.53 61.23 225 top
RV1  -  [R_0402]  194.59 162.94 0 top
RV2  -  [R0402_0OHM]  233.22 133.12 90 top
RV3  -  [R_0402]  216.98 157.11 180 top
RV4  -  [R_0402]  216.06 160.16 0 top
RV5  -  [R_0402]  212.45 152.74 270 top
RV6  -  [R_0402]  211.44 151.83 90 top
RV7  -  [R_0402]  216.06 164.22 0 top
RV8  -  [R_0402]  216.98 161.18 180 top
RV9  -  [R_0402]  195.44 170.12 90 top
RV10  -  [R_0402]  198.48 171.03 270 top
RV11  -  [R_0402]  207.37 152.74 270 top
RV12  -  [R_0402]  204.33 151.83 90 top
RV13  -  [R_0402]  226.93 170.12 90 bottom
RV14  -  [R_0402]  225.92 171.03 270 bottom
RV15  -  [R_0402]  216.01 170.12 90 bottom
RV16  -  [R_0402]  218.04 171.03 270 bottom
RV17  -  [R_0402]  232.27 152.74 270 top
RV18  -  [R0402_0OHM]  227.44 115.51 90 top
RV19  -  [R_0402]  229.22 151.83 90 top
RV20  -  [R_0402]  216.98 153.05 180 top
RV21  -  [R_0402]  216.06 156.1 0 top
RV22  -  [R_0402]  235.06 150.2 270 bottom
RV23  -  [R_0402]  234.04 149.29 90 bottom
RV24  -  [R_0402]  228.71 170.12 90 top
RV25  -  [R_0402]  227.06 135.18 0 top
RV27  -  [R_0402]  225.66 171.03 270 top
RV28  -  [R_0402]  214.27 125.01 0 top
RV29  -  [R_0402]  242.48 131.2 0 bottom
RV31  -  [R_0402]  216.25 139.37 0 top
RV32  -  [R_0402]  227.12 138.47 0 top
RV33  -  [R_0402]  246.95 134.76 180 bottom
RV34  -  [R_0402]  214.63 136.81 90 top
RV35  -  [R_0402]  230.36 136.52 180 top
RV36  -  [R_0402]  217.01 126.76 180 top
RV37  -  [R0402_0OHM]  243.65 138.82 180 bottom
RV38  -  [R0402_0OHM]  243.65 142.89 180 bottom
RV39  -  [R0402_0OHM]  243.65 141.87 180 bottom
RV40  -  [R0402_0OHM]  246.95 135.78 180 bottom
RV41  -  [R_0402]  226.53 124.92 0 top
RV42  -  [R_0402]  239.68 125.36 0 bottom
RV43  -  [R_0402]  239.68 132.73 0 bottom
RV44  -  [R_0402]  233.28 114.64 270 bottom
RV45  -  [R_0402]  233.1 138.5 0 top
RV46  -  [R_0402]  229.64 140.28 90 top
RV47  -  [R_0402]  242.98 119.01 0 top
RV48  -  [R_0402]  240.6 131.71 180 bottom
RV49  -  [R_0402]  227.31 122.08 270 top
RV52  -  [R_0402]  243.65 140.86 180 bottom
RV53  -  [R_0402]  242.98 122.06 0 top
RV54  -  [R_0402]  228.2 114.64 270 bottom
RV55  -  [R_0402]  246.03 119.01 0 top
RV56  -  [R_0402]  246.03 118 0 top
RV57  -  [R_0402]  243.19 114.49 90 top
RV58  -  [R_0402]  246.03 112.15 0 top
RV59  -  [R_0402]  246.03 116.98 0 top
RV60  -  [R_0402]  246.95 113.17 180 top
RV61  -  [R_0402]  249.74 118 180 top
RV62  -  [R_0402]  230.53 126.98 0 top
RV63  -  [R_0402]  230.27 125.54 180 top
RV64  -  [R_0402]  246.95 136.79 180 bottom
RV65  -  [R_0402]  195.5 159.89 180 top
RV66  -  [R_0402]  246.03 139.84 0 bottom
RV67  -  [R_0402]  186.55 107.78 270 top
RV68  -  [R_0402]  246.95 138.82 180 bottom
RV69  -  [R_0402]  224.9 119.21 270 top
RV70  -  [R_0402]  229.22 114.64 270 bottom
RV71  -  [R_0402]  230.23 114.64 270 bottom
RV72  -  [R_0402]  227.19 114.64 270 bottom
RV73  -  [R_0402]  225.87 114.69 180 bottom
RV74  -  [R_0402]  235.62 122.82 0 top
RV75  -  [R_0402]  235.62 121.81 0 top
RV76  -  [R0402_0OHM]  243.98 137.78 180 bottom
RV77  -  [R_0402]  242.98 118 0 top
RV78  -  [R_0402]  242.07 132.24 0 top
RV79  -  [R_0402]  229.16 130.83 90 top
RV80  -  [R_0402]  186.55 104.33 90 top
RV81  -  [R_0402]  177.96 109.77 90 top
RV82  -  [R_0402]  183.19 108.46 0 top
RV84  -  [R_0402]  231 114.64 270 top
RV85  -  [R0402_0OHM]  187.56 104.33 90 top
RV86  -  [R_0402]  240.6 129.68 180 bottom
RV87  -  [R_0402]  240.6 128.66 180 bottom
RV88  -  [R_0402]  231 131.66 270 top
RV95  -  [R_0402]  240.6 124.35 180 bottom
RV96  -  [R_0402]  223.72 125.04 0 top
RV97  -  [R_0402]  240.6 130.7 180 bottom
RV100  -  [R_0402]  240.7 122.86 270 bottom
RV102  -  [R_0402]  243.65 139.84 180 bottom
RV103  -  [R_0402]  243.65 136.79 180 bottom
RV104  -  [R_0402]  243.9 116.98 180 top
RV107  -  [R_0402]  200.01 110.68 90 bottom
RV108  -  [R_0402]  188.83 110.68 90 bottom
RV109  -  [R_0402]  182.79 126.63 0 bottom
RV110  -  [R_0402]  192.9 111.59 270 bottom
RV111  -  [R_0402]  232.01 113.73 90 top
RV113  -  [R_0402]  231.25 134.1 180 top
RV117  -  [R_0402]  182.79 150 0 bottom
RV118  -  [R_0402]  186.57 148.93 270 top
RV119  -  [R_0402]  182.79 138.82 0 top
RV120  -  [R_0402]  183.7 137.81 180 top
RV125  -  [R_0402]  240.65 121.04 180 bottom
RV128  -  [R_0402]  183.7 125.62 180 bottom
RV129  -  [R_0402]  204.82 115.11 180 bottom
RV131  -  [R_0402]  203.91 118.16 0 bottom
RV139  -  [R_0402]  189.85 110.68 90 bottom
RV140  -  [R_0402]  204.02 124.35 180 top
RV141  -  [R_0402]  240.6 127.65 180 bottom
RV145  -  [R_0402]  215.62 135.43 180 top
RV146  -  [R_0402]  215.58 136.31 90 top
RV147  -  [R_0402]  215.06 131.2 270 top
RV148  -  [R_0402]  214.31 132.06 90 top
RV152  -  [R_0402]  220.11 139.31 180 top
RV153  -  [R_0402]  223.19 139.19 0 top
RV154  -  [R_0402]  224.95 137.3 0 top
RV155  -  [R_0402]  222.04 139.23 180 top
RV162  -  [R_0402]  214.69 152.54 180 bottom
RV163  -  [R_0402]  208.39 151.83 90 top
RV169  -  [R_0402]  228.2 151.83 90 bottom
RV171  -  [R_0402]  229.22 151.83 90 bottom
RV177  -  [R_0402]  206.21 171.03 270 top
RV178  -  [R_0402]  227.15 139.37 0 top
RV179  -  [R_0402]  225.06 139.09 90 top
RV180  -  [R_0402]  229.04 139.4 270 top
RV181  -  [R_0402]  203.11 121.3 0 top
RV182  -  [R_0402]  185.53 107.78 270 top
RV183  -  [R_0402]  197.98 110.68 90 bottom
RV184  -  [R_0402]  198.99 111.59 270 bottom
RV185  -  [R_0402]  182.79 126.63 0 top
RV186  -  [R_0402]  183.7 127.65 180 top
RV187  -  [R_0402]  193.91 111.59 270 bottom
RV188  -  [R_0402]  194.93 111.59 270 bottom
RV189  -  [R_0402]  199.55 150.51 0 bottom
RV190  -  [R_0402]  198.43 150.51 180 bottom
RV191  -  [R_0402]  203.87 143.36 180 top
RV192  -  [R_0402]  202.95 142.34 0 top
RV193  -  [R_0402]  182.79 148.98 0 bottom
RV194  -  [R_0402]  183.7 147.97 180 bottom
RV195  -  [R_0402]  203.93 137.78 180 bottom
RV196  -  [R_0402]  203.02 136.77 0 bottom
RV197  -  [R_0402]  182.79 145.94 0 top
RV198  -  [R_0402]  183.7 146.95 180 top
RV203  -  [R_0402]  182.79 139.84 0 bottom
RV205  -  [R_0402]  183.7 140.86 180 bottom
RV206  -  [R_0402]  207.37 170.12 90 bottom
RV208  -  [R_0402]  208.39 170.12 90 bottom
RV209  -  [R_0402]  229.73 170.12 90 top
RV210  -  [R_0402]  230.74 170.12 90 top
RV237  -  [R_0402]  236.03 124.85 180 top
RV238  -  [R_0402]  235.11 125.87 0 top
RV239  -  [R_0402]  236.03 128.92 180 top
RV240  -  [R_0402]  235.11 127.9 0 top
RV241  -  [R_0402]  225.92 115.51 90 top
RV242  -  [R_0402]  224.9 115.51 90 top
RV243  -  [R_0402]  236.13 117.74 0 top
RV244  -  [R_0402]  237.04 116.47 180 top
RV296  -  [R_0402]  223.72 123.19 90 top
RV298  -  [R_0402]  222.73 124.94 180 top
SW1  -  [SW_SKRBAAE010_4P]  338.46 208.51 270 top
T2  -  [TPC12]  150.22 88.66 0 top
T3  -  [TPC12]  146.29 88.66 90 top
T4  -  [TPC12]  158.35 104.41 90 top
T5  -  [TPC12]  133.08 84.33 180 bottom
T6  -  [TPC12]  148.19 88.66 0 top
T7  -  [TPC12]  173.73 101.75 0 top
T8  -  [TPC12]  170.15 118.81 180 bottom
T9  -  [TPC12]  171.81 120.15 180 bottom
T10  -  [TPC12]  152.89 104.41 90 top
T11  -  [TPC12]  132.25 82.68 180 bottom
T12  -  [TPC12]  173.91 100.1 0 top
T13  -  [TPC12]  171.97 102.69 0 top
T14  -  [TPC12]  176.44 99.09 0 top
T15  -  [TPC12]  154.29 104.53 90 top
T16  -  [TPC12]  137.78 120.66 90 top
T17  -  [TPC12]  136.38 119.52 90 top
T18  -  [TPC12]  165.98 119.23 180 bottom
T19  -  [TPC12]  132.19 119.14 90 top
T20  -  [TPC12]  168.21 119.56 180 bottom
T21  -  [TPC12]  132.55 101.94 0 top
T22  -  [TPC12]  133.97 101.1 0 top
T23  -  [TPC12]  142.6 101.74 0 top
T24  -  [TPC12]  142.6 100.09 0 top
T25  -  [TPC12]  167.22 88.63 0 top
T26  -  [TPC12]  163.11 120.29 90 top
T27  -  [TPC12]  132.7 70.24 0 top
T28  -  [TPC12]  161.22 119.56 90 top
T29  -  [TPC12]  163.18 88.66 0 top
T30  -  [TPC12]  174.01 95.53 0 top
T31  -  [TPC12]  156.19 88.66 0 top
T32  -  [TPC12]  159.24 88.66 0 top
T33  -  [TPC12]  171.69 74.43 0 top
T34  -  [TPC12]  133.03 80.67 180 bottom
T35  -  [TPC12]  174.68 98.63 0 top
T36  -  [TPC12]  175.87 97.12 0 top
T37  -  [TPC12]  129.14 105.82 0 top
T38  -  [TPC12]  130.97 105.82 0 top
T39  -  [TPC12]  163.18 103.39 0 top
T40  -  [TPC12]  161.91 104.41 0 top
T41  -  [TPC12]  156.95 104.41 0 top
T42  -  [TPC12]  155.56 104.41 0 top
T43  -  [TPC12]  160.26 104.41 0 top
T44  -  [TPC12]  142.48 104.41 0 top
T45  -  [TPC12]  144 104.41 0 top
T46  -  [TPC12]  175.9 95.01 0 top
T47  -  [TPC12]  131.59 100.96 0 top
T48  -  [TPC12]  160.26 118.07 0 top
T49  -  [TPC12]  142.73 95.01 0 top
T50  -  [TPC12]  164.19 104.28 0 top
T51  -  [TPC12]  142.73 92.09 0 top
T52  -  [TPC12]  132.06 116.73 180 bottom
T53  -  [TPC12]  132.89 118.81 180 bottom
T54  -  [TPC12]  130.67 119.14 0 top
T55  -  [TPC12]  143.24 103.26 90 top
T56  -  [TPC12]  137.78 119.27 0 top
T57  -  [TPC12]  197.09 71.39 315 top
T58  -  [TPC12]  195.84 71.68 315 top
T59  -  [TPC12]  217.81 64.95 135 bottom
T60  -  [TPC12]  206.35 92.48 135 bottom
T61  -  [TPC12]  205.62 91.19 135 bottom
T62  -  [TPC12]  206.81 90.59 135 bottom
T63  -  [TPC12]  206.26 89.37 135 bottom
T64  -  [TPC12]  209.63 82.78 315 top
T65  -  [TPC12]  200.08 72.86 315 top
T66  -  [TPC12]  207.68 91.6 135 bottom
T67  -  [TPC12]  201.61 72.82 315 top
T68  -  [TPC12]  204.07 65.54 315 top
T69  -  [TPC12]  205.09 66.46 315 top
T70  -  [TPC12]  209.16 57.78 315 top
T71  -  [TPC12]  202.67 68.47 315 top
T72  -  [TPC12]  130.69 101.94 0 top
T73  -  [TPC12]  206.36 53.73 135 bottom
T74  -  [TPC12]  192.64 69.99 135 bottom
T75  -  [TPC12]  205.61 68.31 315 top
T76  -  [TPC12]  212.83 78.5 315 top
T77  -  [TPC12]  212.96 76.97 315 top
T78  -  [TPC12]  204.92 89.1 135 bottom
T79  -  [TPC12]  203.62 89.44 135 bottom
T80  -  [TPC12]  204.83 87.3 135 bottom
T81  -  [TPC12]  205.93 88.06 135 bottom
T82  -  [TPC12]  214.36 72.97 315 top
T83  -  [TPC12]  214.87 71.51 315 top
T84  -  [TPC12]  201.15 84.7 135 bottom
T85  -  [TPC12]  203.82 79.77 45 top
T86  -  [TPC12]  195.37 69.63 315 top
T87  -  [TPC12]  216.09 66.9 0 top
T88  -  [TPC12]  133.74 103.87 0 top
T91  -  [TPC12]  239.5 145.05 180 bottom
T92  -  [TPC12]  244.71 146.19 180 bottom
T93  -  [TPC12]  243.31 146.06 180 bottom
T94  -  [TPC12]  240.9 145.05 180 bottom
T95  -  [TPC12]  242.55 144.92 180 bottom
T96  -  [TPC12]  243.95 144.92 180 bottom
T97  -  [TPC12]  240.9 143.52 180 bottom
T98  -  [TPC12]  239.5 143.52 180 bottom
T99  -  [TPC12]  235.06 142.13 0 top
T100  -  [TPC12]  240.27 142.38 180 bottom
T101  -  [TPC12]  239.5 141.24 180 bottom
T102  -  [TPC12]  235.19 140.09 0 top
T103  -  [TPC12]  239.5 139.84 180 bottom
T104  -  [TPC12]  240.9 141.24 180 bottom
T105  -  [TPC12]  233.79 140.6 0 top
T106  -  [TPC12]  241.66 138.7 180 bottom
T107  -  [TPC12]  240.83 139.84 180 bottom
T108  -  [TPC12]  239.38 136.54 180 bottom
T109  -  [TPC12]  240.65 146.44 180 bottom
T110  -  [TPC12]  239.38 146.82 180 bottom
T111  -  [TPC12]  241.92 146.19 180 bottom
T112  -  [TPC12]  241.66 137.3 180 bottom
T113  -  [TPC12]  240.7 136.41 180 bottom
T114  -  [TPC12]  240.39 138.57 180 bottom
T115  -  [TPC12]  241.66 142.38 180 bottom
T118  -  [TPC12]  231.38 136.54 0 top
T119  -  [TPC12]  229.09 137.45 0 top
T120  -  [TPC12]  232.65 136.54 0 top
T121  -  [TPC12]  271.64 42.43 0 top
T122  -  [TPC12]  275.51 56.08 0 top
T123  -  [TPC12]  229.22 133.24 0 top
T124  -  [TPC12]  234.81 135.01 0 top
T125  -  [TPC12]  232.27 134.12 0 top
T126  -  [TPC12]  228.46 122.06 0 top
T127  -  [TPC12]  233.54 135.39 0 top
T128  -  [TPC12]  231.38 135.14 0 top
T129  -  [TPC12]  233.92 136.79 0 top
T130  -  [TPC12]  278.3 50.24 0 top
T136  -  [TPC12]  257.86 50.24 0 top
T137  -  [TPC12]  279.46 47.8 0 top
T138  -  [TPC12]  228.46 120.54 0 top
T139  -  [TPC12]  227.19 123.58 0 top
T141  -  [TPC12]  263.44 42.56 0 top
T142  -  [TPC12]  315.65 203.29 180 bottom
T143  -  [TPC12]  317.11 203.47 180 bottom
T144  -  [TPC12]  266.62 43.64 0 top
T146  -  [TPC12]  261.21 49.92 0 top
T147  -  [TPC12]  269.26 59.8 0 top
T148  -  [TPC12]  275.51 45.73 0 top
T156  -  [TAIMA_IH-115-F_24P]  297.42 209.58 0 top
U1  -  [AH180-WG-7_SC59-3]  6.95 217.12 90 top
U2  -  [SLG55584AVTR_TDFN8_2X2]  323.22 218.57 270 bottom
U6  -  [PI3V713-AZLEX_TQFN32_6X3]  182.26 171.52 0 top
U7  -  [ASM1467_QFN20_4X4]  321.61 128.72 0 top
U8  -  [RT9818A-44GU3_SC70-3]  217.26 50.41 135 bottom
U9  -  [TC7SH08FU_SSOP5]  213.59 49.97 225 bottom
U15  -  [TC7SH08FU_SSOP5]  312.42 204.42 180 bottom
U19  -  [PS8401ATQFN40GTR-A3_TQFN40_5X5]  28.76 199.76 90 top
U20  -  [PI3C3125LEX_TSSOP14]  192.54 171.16 90 bottom
U21  -  [TC7SET04FU_SSOP5]  202.64 175.85 270 bottom
U23  -  [PI3C3125LEX_TSSOP14]  187.41 174.81 270 bottom
U24  -  [TC7SET04FU_SSOP5]  177.26 171.85 90 bottom
U26  -  [CAT24C64WI-GT3_SO8]  167.37 144.62 0 top
U27  -  [RTD2136S-CG_QFN48_6X6]  172.65 140.26 270 top
U31  -  [WGI217LM-QPN9-A2_QFN48_6X6]  317.52 196.05 180 bottom
U32  -  [PI3L720ZHEX_TQFN42_9X3P5]  298.62 200.34 0 top
U38  -  [OZ777FJ2LN_QFN48_6X6]  253.52 47.89 180 top
U39  -  [AT97SC3204-X2A14-AB_TSSOP28]  300.75 137.15 180 top
U41  -  [TPS2231MRGPR-2_QFN20_4X4]  270.42 36.95 270 top
U46  -  [ECE5048-LZY_DQFN132_11X11]  273.64 48.89 90 top
U48  -  [G547I2P81U_MSOP8]  352.81 222.98 270 bottom
U49  -  [G547I2P81U_MSOP8]  29.6 192.88 270 bottom
U50  -  [TC7SH08FU_SSOP5]  277.49 123.14 180 top
U51  -  [MEC5075-LZY_DQFN132_11X11]  292.92 110.16 90 top
U52  -  [W25Q64FVSSIQ_SO8]  190.99 30.04 0 top
U53  -  [W25Q32FVSSIQ_SO8]  197.34 30.04 0 top
U54  -  [TC7SH08FU_SSOP5]  181.58 150.57 0 top
U55  -  [TC7SH08FU_SSOP5]  171.93 154.89 0 top
U58  -  [TC7SH08FU_SSOP5]  318.18 211.33 90 bottom
U74  -  [ALC3226-CG_QFN48_7X7]  337.68 174.09 270 top
U88  -  [LNG3DMTR_LGA16_3X3]  117.98 12.03 0 bottom
U89  -  [AP2330W-7_SC59-3]  21.38 209.18 270 top
U90  -  [PS8710BTQFN24GTR-A0_TQFN24_4X4]  327.32 188.63 90 bottom
U91  -  [G547I2P81U_MSOP8]  350.4 216.6 180 top
U92  -  [PS8710BTQFN24GTR-A0_TQFN24_4X4]  339.81 217.24 180 bottom
U93  -  [G547I2P81U_MSOP8]  349.83 198.92 180 top
U94  -  [PS8710BTQFN24GTR-A0_TQFN24_4X4]  36.67 182.57 180 bottom
U95  -  [PS8710BTQFN24GTR-A0_TQFN24_4X4]  339.5 189.64 90 bottom
U100  -  [TPS22966DPUR_SON14_2X3]  283.52 181.36 0 bottom
U101  -  [TPS22966DPUR_SON14_2X3]  323.6 200.08 0 top
U102  -  [TPS22966DPUR_SON14_2X3]  302.86 190.61 180 bottom
U103  -  [TPS22966DPUR_SON14_2X3]  248.96 142.9 180 top
U104  -  [TPS22966DPUR_SON14_2X3]  171.17 166.57 270 top
U105  -  [TPS22966DPUR_SON14_2X3]  222.82 36.39 90 bottom
UC1  -  [74AHC1G09GW_TSSOP5]  138.65 63 0 top
UC2  -  [SN74LVC1G07DCKR_SC70-5]  125.22 100.84 90 bottom
UC3  -  [74AHC1G09GW_TSSOP5]  188.92 64.81 45 bottom
UH1  -  [DH82LPMS-QCG1-B0_FCBGA_695P]  207.88 59.3 45 bottom
UH2  -  [TC7SH08FU_SSOP5]  208.91 55.17 315 bottom
UH3  -  [TC7SH08FU_SSOP5]  186.84 67.56 225 top
UV1  -  [MARS-PRO_FCBGA_962P]  208.65 145.6 270 bottom
UV3  -  [K4G20325FC-HC05_FBGA_170P]  187.05 134.09 90 top
UV4  -  [K4G20325FC-HC05_FBGA_170P]  187.05 125.5 270 bottom
UV5  -  [K4G20325FC-HC05_FBGA_170P]  199.85 125.5 270 top
UV6  -  [K4G20325FC-HC05_FBGA_170P]  199.85 134.09 90 bottom
UV7  -  [K4G20325FC-HC05_FBGA_170P]  212.71 166.5 270 top
UV8  -  [K4G20325FC-HC05_FBGA_170P]  199.91 166.5 270 bottom
UV9  -  [K4G20325FC-HC05_FBGA_170P]  233.71 166.5 270 top
UV10  -  [K4G20325FC-HC05_FBGA_170P]  220.91 166.5 270 bottom
UV14  -  [74AHC1G09GW_TSSOP5]  244.85 133.63 270 bottom
Y3  -  [Y_X3G025000DI1H-H_4P]  312.36 188.52 180 bottom
Y6  -  [Y_Q13FC1350000_2P]  291.85 102.76 0 top
YH1  -  [Y_Q13FC1350000_2P]  206.8 54.18 135 top
YH2  -  [Y_Q22FA2380049900_4P]  215.43 90.35 45 bottom
YV1  -  [Y_7V27000011_4P]  236.88 110.07 180 bottom

## Library data of the parts
C1-C3 C290 C365 C369 C393 C394 C400 C401 C403 C410 C412 C416 C417 C420-C422 C424 C445 C448 C450 C452 C455 C456 C465 C486-C488 C580 C581 C628-C631 C725 C726 C802 C986 C987 C989 C1513-C1522 C1524 C1526 C1528-C1539 C1541-C1544 C1546-C1551 C1553-C1564 CD45-CD48 CH9 CH76-CH80 CV116-CV119 CV358 PC2 PC5 PC15 PC17 PC548 PC665-PC668 PC671 PC674 PC675 PC679 PC701 PC704 PC705 PC728 PC730 PC733 PC818 PC948 PC949 PC967-PC969 PCV172 PCV174 PCV175 = C_0402
C7 = C_0805: room: THERMAL
C8 C9 C16 C18 C284 = C_0402: room: THERMAL
C25-C30 = C_0402: room: CRT
C31 C32 C46 C340 C342 C344 C346-C355 CE5 CE7 CE13-CE18 = C_0402: room: HDMI
C40 C41 C43 C49 C297 C298 = C_0402: room: LVDS
C44 C45 C550-C553 CE3 = C_0402: room: TPM
C47 = C_0805: room: HDMI
C51-C53 = C_0402: room: USH
C100 C101 C103-C105 C107 C108 C110-C112 C114 C116-C118 = C_0402: room: EDP
C106 C109 C113 C115 = C_0603: room: EDP
C195 C196 C446 C447 C449 C451 C454 C579 C967 C970 C984 CC137 CV226 CV227 PC1 PC3 PC4 PC16 PC120 PC308 PC309 PC670 PC676 PC680 PC700 PC702 PC703 PC720 PC966 PCV183 = C_0603
C246 C247 C296 = C_0603: room: LVDS
C283 C285-C287 C720-C722 C724 C733-C737 C739-C744 C747 C757 C759 C774-C777 C780 C781 = C_0402: room: KBC
C288 C289 = C_0402: room: RSMRST
C299 C301 C1206 C1207 = C_0402: room: CAM
C300 = C_0805: room: CAM
C356 C357 C360 C366-C368 = C_0402: room: AUX MUX
C383-C386 C388 C395 C396 C399 C402 = C_0402: room: HDD
C387 = C_0603: room: HDD
C397 C398 C404-C409 = C_0402: room: ODD
C414 C415 C668 C723 = C_0402: room: ESATA
C423 = C_0805: room: +5VMOD SOURCE
C458-C461 C463 C466-C471 C476-C478 = C_0402: room: LAN
C462 C464 C475 = C_0603: room: LAN
C472-C474 = C_0402: room: LAN SW
C479-C481 C483 C484 = C_0603: room: LOM
C482 C1167 = C_0402: room: LOM
C485 = C_1808: room: LOM
C559-C561 C564 C566 C572 C577 C578 C1502 C1504 C1507 = C_0603: room: OZ777
C562 C567-C571 C573-C576 C800 C801 C1501 C1503 C1505 C1506 C1508-C1511 CE759 = C_0402: room: OZ777
C595 C596 C598 C603-C607 = C_0402: room: WLAN
C608 = C_0603: room: WLAN
C610-C612 C614 = C_0402: room: WWAN
C613 = C_0805: room: WWAN
C615 C1176 = C_D2: room: WWAN
C616 C636 = C_0402: room: SIM
C617 C618 C621-C625 = C_0402: room: DMC
C626 = C_0603: room: DMC
C633-C635 C637 C640 C642 C645-C649 CE10-CE12 = C_0402: room: EXPRESS
C638 C641 C643 = C_0603: room: EXPRESS
C639 = C_0603: room: SIM
C651 = C_D2: room: USB
C654 C675 C715 = C_0402: room: USB
C667 = C_APXK6R3ARA221MF451: room: ESATA
C676 = C_0805: room: USB
C677 C678 C717 = C_0402: room: MDC
C679-C701 C704 CE8 CE9 = C_0402: room: DOCK
C702 C703 = C_0603: room: DOCK
C705 C714 = C_0603: room: SIO
C706-C710 C712 C713 C716 = C_0402: room: SIO
C718 = C_0603: room: MDC
C719 = C_0805: room: ESATA
C746 C1216 CE1 CE2 = C_0402: room: FLASH ROM
C749-C752 C755 = C_0402: room: TOUCH.PAD
C756 C758 = C_0402: room: KB
C760 C762 = C_0603: room: +3.3V_LAN SOURCE
C761 = C_0805: room: +5V_RUN_SOURCE
C765 = C_0603: room: +3.3V_SUS SOURCE
C771 C783 CV41-CV48 CV56 CV59 CV62 CV64 CV73 CV74 CV98 CV113 CV173 CV201 CV206 CV212 CV216 CV217 CV221 CV224 CV238 CV274 CV275 = C_0603: room: GPU
C772 = C_0603: room: +1.05VRUN_SOURCE
C773 = C_0402: room: +1.05VRUN_SOURCE
C778 = C_0402: room: LED
C779 C782 = C_0603: room: KBC
C952 C962 C965 C1214 = C_0603: room: CODEC
C953 C957 C959 C961 C968 C972-C978 C994 C1105-C1107 = C_0402: room: CODEC
C954-C956 C958 C960 C963 C969 = C_0805: room: CODEC
C998 C1001 = C_0402: room: IO
C1004 = C_0402: room: LED_B
C1177 C1178 = C_0805: room: LAN
C1211-C1213 C1215 = C_0402: room: AJACK
C1247 C1512 C1525 C1527 C1540 C1545 C1552 CC47 CC48 PC660-PC664 PC669 PC672 PC673 PC731 PC732 PC734-PC740 PC917-PC919 = C_0805
C1523 = C_APXK6R3ARA221MF451
CC1-CC16 CC19 CC21-CC23 PC945 = C_0402: room: CPU
CC17 CC18 = C_0402: room: XDP1
CC24-CC33 CC36-CC46 PC900-PC904 PC909-PC914 PC920-PC926 PC935-PC943 = C_0805: room: CPU
CC34 CC35 = C_D2: room: CPU
CC135 = C_0603: room: +1.35V_CPU_VDDQ SOURCE
CC136 = C_0402: room: +1.35V_CPU_VDDQ SOURCE
CD1-CD6 CD15-CD28 CD37-CD44 = C_0402: room: MEMORY
CD7-CD13 CD29-CD35 = C_0603: room: MEMORY
CD14 CD36 = C_APXK2R5ARA331MF451: room: MEMORY
CE6 = C_0805: room: DOCK
CH2 = C_0402: room: XDP2
CH4-CH8 CH10-CH19 CH22-CH25 CH27 CH29 CH30 CH34-CH37 CH39 CH40 CH42-CH51 CH53-CH62 CH64-CH75 = C_0402: room: PCH
CH20 CH21 CH26 CH31-CH33 CH38 CH41 CH52 CH63 = C_0603: room: PCH
CH28 = C_0805: room: PCH
CLIP1 = EMI-110X138: room: LED
CMOS1 ME1 = SHORTPADS: User Part Number: PART#; room: PCH
CV1-CV40 CV49-CV55 CV57 CV58 CV60 CV61 CV63 CV65-CV72 CV81 CV82 CV87 CV92-CV95 CV114 CV115 CV129-CV131 CV133-CV135 CV137-CV159 CV162 CV163 CV168 CV170 CV176-CV182 CV185 CV188 CV189 CV191 CV192 CV198-CV200 CV202-CV204 CV207-CV211 CV213-CV215 CV218-CV220 CV222 CV223 CV225 CV237 CV278-CV281 CV283-CV288 CV290-CV299 CV301-CV313 CV315 CV316 CV318-CV320 CV322-CV333 CV340-CV343 CV349-CV357 = C_0402: room: GPU
D1 = RB751V40_SC76-2: room: THERMAL
D2 = RB751VM-40TE-17_SOD323-2: room: HDMI
D8 D23 D37 D89 D90 = L30ESDL5V0C3-2_SOT23-3
D11 D12 = RB751VM-40TE-17_SOD323-2
D31 = RB751V40_SC76-2: room: WLAN
D32 = RB751V40_SC76-2: room: DOCK
D33 = L30ESD24VC3-2_SOT23-3: room: DOCK
D35 D36 D65 D73 = RB751V40_SC76-2
D59 D62 = RB751V40_SC76-2: room: LED
D64 D66 D68 D69 = RB751V40_SC76-2: room: LVDS
D71 = RB751V40_SC76-2: room: GPU
D72 = L30ESDL5V0C3-2_SOT23-3: room: USB
D74 = L30ESDL5V0C3-2_SOT23-3: room: ESATA
D78 = IP4292CZ10-TBR_XSON10_2P5X1: room: USB
D79 = IP4292CZ10-TBR_XSON10_2P5X1: room: ESATA
D81 D82 = L03ESDL5V0CC3-2_SOT23-3: room: AJACK
D83 = L03ESDL5V0CC3-2_SOT23-3
D88 D91 = IP4292CZ10-TBR_XSON10_2P5X1
FD1-FD4 = FIDUCIAL_C40M80: room: LED
H1 H3-H13 = H_2P8: room: LED
H2 = H_6P2: room: LED
H14 H15 H20 = H_2P3: room: LED
H16-H19 H23-H25 = H_3P5: room: LED
H21 = H_2P5X8P0: room: LED
H22 = H_4P8: room: LED
H26 H27 = H_2P8
H28 H29 = H_3P8
H30 = H_2P3
JAPS1 = TYCO_1-2041070-6_16P: room: ETY-ROOM
JBTB1 = E-T_1001K-F30C-02L_30P-T: room: IO
JCAM1 = PS_HPW10003-08MR2_8P: room: CAM
JCPU1 = LOTES_AZIF0012-P002B_947P-T: room: CPU
JDEG2 = TYCO_1-2041070-0_10P: room: KBC
JDIMM1 = TYCO_2-2013290-1_204P: room: MEMORY
JDIMM2 = TYCO_2-2013311-1_204P: room: MEMORY
JDOCK1 = JAE_WD2F144WB1R300_144P: room: DOCK
JEXP1 = E-T_1001K-F30C-02L_30P-T: room: EXPRESS
JFAN1 = ACES_50273-0040N-001_4P: room: THERMAL
JHDMI1 = CONCR_099AKAC19NBLCNF_19P-T: room: HDMI
JHP1 = SINGA_2SJ3080-001111F_6P-T: room: AJACK
JKB1 = ACES_51524-01001-003_10P: room: KB
JLED2 = PS_HPF05052-061000R_6P: room: LED_B
JLOM1 = TE_2041528-1_13P-T: room: LOM
JLVDS1 = ACES_59003-04006-001_40P: room: LVDS
JMDC1 = ACES_50124-0127N-001_12P: room: MDC
JMINI1-JMINI3 = BELLW_80003-7041_52P: room: WLAN
JRTC1 = ACES_50273-0020N-001_2P: room: ETY-ROOM
JSATA1 = SANTA_196003-1_22P: room: HDD
JSATA2 = TYCO_2-2129116-3_31P-T: room: ODD
JSD1 = T-SOL_156-1000302606_18P-T: room: OZ777
JSF1 = PS_HPF10052-04M000R_4P: room: ETY-ROOM
JSIM1 = T-SOL_159-1000302602_10P-T: room: SIM
JSPI1 = TYCO_2-2041070-0_20P-T: room: FLASH ROM
JSPK1 = ACES_50279-0040N-001_4P: room: CODEC
JTAG1 = SHORTPADS: room: KBC
JTP1 = PS_HPF05052-081000R_8P: room: TOUCH.PAD
JUSB1 = SANTA_373130-1_9P: room: USB
JUSB2-JUSB4 = SANTA_373130-1_9P
JUSH1 = TYCO_2-2041070-0_20P-T: room: USH
JXDP1 = SAMTE_BSH-030-01-L-D-A_60P: room: XDP1
JXDP2 = SAMTE_BSH-030-01-L-D-A_60P: room: XDP2
L1-L4 = MURAT_DLW21SN900HQ2L_0805_4P: room: HDMI
L10 = MURAT_DLW21SN121SQ2L_4P: room: CAM
L29 = TAIYO_CBC2012T4R7M_2P: room: LAN
L45 L47 = MURAT_BLM18BD601SN1D_2P: room: OZ777
L51 = MURAT_DLW21SN900SQ2L_0805_4P: room: USB
L77 = MURAT_BLM21PG600SN1D_L0805_2P: room: CODEC
L90 = MURAT_DLW21SN900SQ2L_0805_4P: room: ESATA
L95 L96 = MURAT_DLW21SN900HQ2L_0805_4P: room: USB
L97 L98 = MURAT_DLW21SN900HQ2L_0805_4P: room: ESATA
L99 = MURAT_DLW21SN900HQ2L_0805_4P: room: DOCK
L107 L110 = MURAT_DLW21SN900SQ2L_0805_4P
L108 L109 L111 L112 LE2 LE4 LE5 = MURAT_DLW21SN900HQ2L_0805_4P
L113-L116 = CHILI_PBY160808T-300Y-N_2P
LE3 = MURAT_BLM18BB221SN1D_2P: room: CODEC
LED1 = LED_LTW-193ZDS5_2P: room: LED
LH1 = MURAT_BLM18PG181SN1D_L0603_2P: room: PCH
LV16-LV21 LV30 RV1 RV3-RV17 RV19-RV25 RV27-RV29 RV31-RV36 RV41-RV49 RV52 RV53 RV55-RV69 RV77 RV79 RV80 RV84 RV86-RV88 RV95-RV97 RV100 RV102-RV104 RV107-RV111 RV113 RV117-RV120 RV125 RV128 RV129 RV131 RV139-RV141 RV145-RV148 RV152-RV155 RV162 RV163 RV169 RV171 RV177-RV198 RV203 RV205 RV206 RV208-RV210 RV237-RV244 RV296 RV298 = R_0402: room: GPU
MBATT1 = OCTEK_BTJ-06LDFB_6P: room: ETY-ROOM
PBATT1 = OCTEK_BTJ-09WKFB_9P: room: P_DCIN
PC6 PC7 PC511 = C_0603: room: VSB
PC8 PC13 = C_0805: room: P_DCIN
PC9-PC12 PC14 = C_0603: room: P_DCIN
PC101 PC102 = C_MP6VL220MC6: room: 3V5V
PC103 PC105 PC106 PC108 PC402 PC406 PC407 PC729 PC927-PC934 PC944 PC946 PC947 PC950 = C_0402: room: ETY-ROOM
PC104 PC107 PC109 PC110 PC503 PC505 PC506 PC512-PC514 PC533-PC535 PC603 PC604 PC621 PC622 PC807 = C_0805: room: CPU_CORE
PC111 PC112 PC114 PC116-PC119 PC501 PC522 PC542 PC626 = C_0603: room: ETY-ROOM
PC201 = C_MP2VU390MC5R7: room: VGA_CORE
PC202 PC203 PC207 PC208 = C_0805: room: 1.5V/0.75V
PC204 PC205 PC209 PC211 PC214 PC215 = C_0402: room: 1.5V/0.75V
PC206 PC210 PC212 PC213 = C_0603: room: 1.5V/0.75V
PC216 PC628 PC629 PC970 PC971 = C_D2
PC301 = C_MP2VU390MC5R7: room: ETY-ROOM
PC302 PC303 PC307 = C_0402: room: 1.05V
PC304 PC305 = C_0805: room: 1.05V
PC306 = C_0603: room: 1.05V
PC400 PC403 PC404 = C_0805: room: ETY-ROOM
PC401 PC405 = C_0402: room: P_1P8V
PC500 PC504 PC507 PC515-PC517 PC519-PC521 PC523 PC528 PC536 PC537 PC539-PC541 PC544-PC547 PC600 PC602 PC609 PC611-PC616 PC620 PC624 PC625 PC627 PC630 PC632 PC678 PC801 PC802 PC808 PC810 PC812 = C_0402: room: CPU_CORE
PC502 PC508 PC509 PC518 PC524 PC529 PC538 PC543 PC601 PC605 PC607 PC608 PC610 PC617-PC619 PC623 PC631 PC800 PC813 PC815 = C_0603: room: CPU_CORE
PC510 PC525-PC527 = C_0402: room: DDR_VTT
PC530-PC532 = C_EEEFK1E101YP: room: CPU_CORE
PC606 PC677 = C_D2: room: ETY-ROOM
PC706 PC709 PC717 = C_0603: room: CHARGER
PC707 PC711-PC714 PC718 PC719 = C_0805: room: CHARGER
PC708 PC710 PC716 PC721-PC727 = C_0402: room: CHARGER
PC715 = C_0603: room: ADP3209
PC803 PC811 PC816 = C_0603: room: P_SELECTOR
PC804-PC806 PC809 PC814 PC817 = C_0402: room: P_SELECTOR
PC905-PC908 PC915 = C_D1: room: ETY-ROOM
PC916 = C_D1
PC951-PC962 = C_0402: room: 3P3V_5V
PC963-PC965 = C_0603: room: 3P3V_5V
PD1 = IP4223CZ6_SO6: room: SWITCH
PD2 = TVNST52302AB0_SOT523-3: room: SWITCH
PD3 = BAS40-05W_SC70-3: room: ETY-ROOM
PD4 = TVNST52302AB0_SOT523-3
PD7 PD818-PD821 = SDMK0340L-7-F_SOD323-2
PD700 = ES2AA-13-F_SMA2: room: ETY-ROOM
PD701 = RB717F_SOT323-3: room: ETY-ROOM
PD702 = BAT54HT1G_SOD323-2: room: ETY-ROOM
PD800 PD801 = PDS5100H-13_POWERDI5-3: room: P_SELECTOR
PD802 PD807 = SDMK0340L-7-F_SOD323-2: room: P_SELECTOR
PD803-PD805 PD809 PD811 PD812 = SDMK0340L-7-F_SOD323-2: room: ETY-ROOM
PD806 PD808 = PDS5100H-13_POWERDI5-3: room: ETY-ROOM
PD814 PD816 PD817 = RB717F_SOT323-3
PH500 PH600 PH601 PR100-PR102 PR104-PR106 PR119 PR204 PR400 PR402-PR405 PR523 PR530 PR539 PR607 PR615 PR706 PR707 PR713 PR722 PR732-PR734 PR738 PR739 PR741 PR743 PR816-PR818 PR822-PR824 PR826-PR830 PR840 PR842 PR848 PR851 PR852 PR856 PR858 PR873 = R_0402: room: ETY-ROOM
PH501 PR500 PR503 PR504 PR507 PR509 PR521 PR525 PR527-PR529 PR531-PR533 PR535 PR537 PR542 PR551 PR555-PR557 PR601-PR606 PR608-PR613 PR616 PR619 PR623 PR624 PR626 PR627 PR631-PR634 PR637-PR640 PR642 PR644-PR648 PR654-PR656 PR658 PR659 = R_0402: room: CPU_CORE
PJP1 PJP300-PJP302 PJP400 PJP401 = JUMP_43X79: room: DDR_VTT_0.75V
PJP2 = JUMP_43X39: room: HDMI
PJP3 = JUMP_43X79: room: +5VMOD SOURCE
PJP4-PJP6 PJP104 PJP200 PJP203 PJP204 PJP500 = JUMP_43X118
PJP7 PJP609-PJP612 = JUMP_43X79
PJP53 PJP64 = JUMP_43X39: room: HDD
PJP60 = JUMP_43X79: room: CODEC
PJP61 = JUMP_43X39: room: TPM
PJP62 = JUMP_43X39: room: CODEC
PJP63 = JUMP_43X39: room: SIO
PJP65 = JUMP_43X39: room: KBC
PJP66 PJP68-PJP74 PJP80 PJP81 PJP201 PJP202 = JUMP_43X39
PJP67 = JUMP_43X39: room: EDP
PJP100-PJP103 = JUMP_43X118: room: 3V/5V
PJP600 PJP601 PJP603 PJP604 = JUMP_43X118: room: ETY-ROOM
PJP602 = JUMP_43X39: room: CPU_CORE
PJP700 = JUMP_43X118: room: CHARGER
PJP701 = JUMP_43X39: room: CHARGER
PJPDC1 = JESS_UCNR2451M005-0_5P: room: ETY-ROOM
PL1-PL3 = TAIYO_FBMJ4516HS720NT_2P
PL4 = MURAT_BLM18BD102SN1D_L0603_2P
PL5 = KC_FBMA-L11-453215800LMA90T_2P
PL101 = TOKO_FDSD0630-H-2R2M-P3_2P: room: ETY-ROOM
PL102 = CYNTE_PCMC063T-2R2MN_2P: room: VDDCI
PL103 PL701 = MAGLA_MMD-05CZ-1R0M-M7L_2P: room: ETY-ROOM
PL201 = TOKO_FDUE1040D-H-1R0M-P3_2P: room: 1.5V/0.75V
PL301 = TOKO_FDSD0630-H-1R0M-P3_2P: room: 1.05V
PL401 PL604 = TAIYO_NRS4018T1R0NDGJ_2P
PL501-PL503 = TOKO_FDUE0640J-H_4P: room: CPU_CORE
PL504 = KC_FBMA-L11-453215800LMA90T_2P: room: CPU_CORE
PL600 PL601 = TOKO_FDUE0640J-H_4P: room: P_GPU_CORE
PL603 = TOKO_FDSD0420-H-1R0M-P3T_2P
PL700 = TOKO_FDVE1040-H-2R2M-P3_2P: room: ETY-ROOM
PQ1 = FDV301N-G_SOT23-3: room: P_DCIN
PQ2 = MMST3904-7-F_SOT323-3: room: P_DCIN
PQ3 = TP0610K-T1-E3_SOT23-3: room: VSB
PQ4 = FDS6679AZ-G_SO8: room: P_DCIN
PQ5 = SSM3K7002FU_SC70-3: room: VSB
PQ6 = IMD2AT-108_SC74-6: room: ETY-ROOM
PQ7 PQ828 = DMG2301U-7_SOT23-3
PQ101 PQ102 PQ301 = SIS412DN-T1-GE3_POWERPAK8-5: room: ETY-ROOM
PQ103 PQ104 PQ303 = SIS472DN-T1_POWERPAK1212-8-5: room: ETY-ROOM
PQ201 = SIR472DP-T1-GE3_POWERPAK8-5: room: 1.5V/0.75V
PQ203 = SIRA06DP-T1-GE_POWERPAKSO-8-5: room: 1.5V/0.75V
PQ501 PQ502 PQ505 PQ506 PQ509 PQ510 PQ600 PQ601 PQ604 PQ605 PQ704 PQ705 = SIR472DP-T1-GE3_POWERPAK8-5: room: ETY-ROOM
PQ503 PQ504 PQ507 PQ508 PQ511 PQ512 = SIRA06DP-T1-GE_POWERPAKSO-8-5: room: CPU_CORE
PQ602 PQ603 PQ606 PQ607 = SIRA06DP-T1-GE_POWERPAKSO-8-5: room: ETY-ROOM
PQ610 PQ710 = DMN65D8LW-7_SOT323-3
PQ700 = SI4835DDY-T1-GE3_SO8: room: CHARGER
PQ701 PQ702 = NTR4502PT1G_SOT23-3: room: ETY-ROOM
PQ703 = SI3993CDV-T1-GE3_TSOP6: room: ETY-ROOM
PQ706 = SIRA14DP-T1GE3_POWERPAK-SO8-5: room: ETY-ROOM
PQ707 = DMN66D0LDW-7_SOT363-6: room: ETY-ROOM
PQ709 = DMN65D8LW-7_SOT323-3: room: ETY-ROOM
PQ711 = SIRA14DP-T1GE3_POWERPAK-SO8-5
PQ800 = SI4835DDY-T1-GE3_SO8: room: P_SELECTOR
PQ801 PQ814 = NTR4502PT1G_SOT23-3: room: P_SELECTOR
PQ802 PQ805-PQ807 PQ812 PQ813 = DMN66D0LDW-7_SOT363-6: room: P_SELECTOR
PQ803 = SI4835BDY-T1-E3_SO8: room: P_SELECTOR
PQ804 = FDS6679AZ_SO8: room: P_SELECTOR
PQ808 = 2N7002DW-T-R7_SOT363-6: room: P_SELECTOR
PQ809 = SI4835DDY-T1-GE3_SO8: room: ETY-ROOM
PQ810 PQ811 PQ815 = FDS6679AZ-G_SO8: room: P_SELECTOR
PQ816 = AO3402_SOT23-3: room: P_SELECTOR
PQ817 PQ818 = DMN65D8LW-7_SOT323-3: room: P_SELECTOR
PQ819 PQ821 PQ824 Q325 Q327 QD6 = DMN66D0LDW-7_SOT363-6
PQ820 PQ822 PQ823 = NTR4502PT1G_SOT23-3
PQ825 PQ827 PQ829 PQ830 = RHU002N06_SOT323-3
PQ826 = FDS6679AZ-G_SO8
PQ910 = 2N7002DW-T-R7_SOT363-6
PR1 PR10-PR16 PR18 = R_0402: room: P_DCIN
PR2-PR4 = R_0402: room: PBATT
PR5-PR9 PR20 PR21 PR23-PR25 PR111 PR300 PR512 PR515 PR516 PR518 PR519 PR543-PR547 PR549 PR558 PR620 PR651 PR652 PR679 PR682-PR685 PR687 PR689-PR693 PR697 PR727 PR729 PR736 PR744 PR746-PR749 PR800-PR808 PR814 PR834 PR836 PR837 PR839 PR863-PR865 PR867 PR869 PR874-PR876 PR878-PR881 PR883-PR885 PR889 PR891 PR894 PR896 PR897 R14 R16-R21 R39 R52 R55 R112-R114 R198 R199 R209 R210 R415 R416 R493 R516-R518 R550 R554 R558 R560 R563-R567 R657 R694 R695 R724 R727-R729 R739 R748 R749 R806 R831 R1084 R1139 R1156 R1620 R1624 R1635 R1636 R1670 R1684-R1689 R3673-R3752 R3754 R3755 R3757-R3780 RC9 RC12 RC13 RC68 RC69 RC100 RC103 RC104 RC108-RC110 RD14-RD22 RD24 RD27 RD28 RD30 RH92 RH120 RH122 RH197 RH216 RH217 RH248 RH254 RH258 RV54 RV70-RV75 RV78 RV81 RV82 = R_0402
PR17 PR19 = R_0402: room: VSB
PR22 PR686 PR835 = R_0805
PR26 PR210 PR308 PR511 PR548 PR650 PR681 PR688 PR696 PR710 PR745 PR811 PR812 PR832 PR833 PR838 PR866 PR868 PR882 PR886-PR888 PR890 PR892 PR893 PR895 R2 R4-R6 R10-R13 R15 R22-R29 R31-R37 R40 R45-R50 R53 R109 R115 R559 R747 R839 R840 R1669 R3753 R3756 RC14 RD13 RD23 RD25 RD26 RD29 RD31 RE3 RE4 RE25-RE30 RH196 RV85 = R0402_0OHM
PR103 PR110 PR406 PR501 PR520 PR522 PR524 PR526 PR600 PR617 PR618 PR621 PR625 PR628 PR629 PR641 PR643 PR700 PR702 PR709 PR717 PR724 PR737 PR820 PR825 PR843 PR847 PR857 PR859 PR862 = R0402_0OHM: room: ETY-ROOM
PR107 PR108 PR502 PR510 PR534 PR536 PR538 PR550 PR552 PR553 PR614 PR649 = R_0603: room: CPU_CORE
PR109 PR112 PR742 = R_1206: room: ETY-ROOM
PR118 = R0402_0OHM: room: 3_5V
PR200 PR203 = R_0603: room: 1.5V/0.75V
PR201 PR205-PR207 = R_0402: room: 1.5V/0.75V
PR202 = R_1206: room: 1.5V/0.75V
PR208 = R0402_0OHM: room: 1.5V/0.75V
PR209 = R_0402: room: 1P5V
PR301 = R_0603: room: 1.05V
PR302 PR303 PR305-PR307 = R_0402: room: 1.05V
PR304 = R_1206: room: 1.05V
PR401 = R_0805: room: P_1P8V
PR505 PR506 PR508 PR540 PR635 PR636 PR657 = R0402_0OHM: room: CPU_CORE
PR513 PR680 = R_1206
PR514 PR809 RC99 RC106 RH240 = R_0603
PR541 PR554 PR622 PR653 = R_1206: room: CPU_CORE
PR701 PR716 = R_1206_4P-D: room: ETY-ROOM
PR703 PR714 PR720 PR723 PR725 PR726 PR728 PR730 PR731 PR735 PR740 = R_0402: room: CHARGER
PR704 PR705 PR718 PR719 = R0402_0OHM: room: CHARGER
PR708 = R_0805: room: CPU_CORE
PR715 PR821 = R_0603: room: ETY-ROOM
PR721 = R_1206: room: CHARGER
PR810 PR813 PR815 PR819 PR841 PR844-PR846 PR849 PR853 PR861 PR870 PR871 = R_0402: room: P_SELECTOR
PR831 PR877 R3881-R3883 = R0805_0OHM
PR850 PR855 PR860 PR872 = R0402_0OHM: room: P_SELECTOR
PR854 = R0805_0OHM: room: ETY-ROOM
PU1 = 74LVC1G3157GW_SC-88-6: room: P_DCIN
PU100 = TPS51225CRUKR_QFN20_3X3: room: ETY-ROOM
PU200 = RT8207MZQW_WQFN20_3X3: room: 1.5V/0.75V
PU300 = TPS51212DSCR_SON10_3X3: room: 1.05V
PU400 = SY8033BDBC_DFN10_3X3: room: ETY-ROOM
PU500 = ISL95812HRZ-T_QFN32_4X4
PU501 = ISL6208BCRZ-T_QFN8_2X2: room: ETY-ROOM
PU600 = ISL62883CHRTZ-T_TQFN40_5X5: room: ETY-ROOM
PU602 = SY8036DBC_DFN10_3X3
PU603 = SY8033BDBC_DFN10_3X3
PU700 = BQ24738RGRR_QFN20_3P5X3P5: room: ETY-ROOM
PU701 = AS393MTR-G1_SO8: room: ETY-ROOM
PU702 = LM358DR2G_SOIC8
PU703 = INA199A2DCKR_SC70-6
PU704 PU809 U54 U55 = TC7SH08FU_SSOP5
PU800 = CD3301RHHR_QFN36_6X6: room: P_SELECTOR
PU801 PU802 PU804 PU806 PU807 UH2 UH3 = TC7SH08FU_SSOP5: room: PCH
PU803 = 74AHC1G32GW_SOT353-5: room: PCH
PU805 = TC7SH08FU_SSOP5: room: ETY-ROOM
PU808 = CD3302RUYR_QFN28_4X4: room: PCH
Q1-Q3 = MMBT3904WT1G_SC70-3: room: THERMAL
Q4 = PMST3904_SOT323-3: room: THERMAL
Q5 Q6 Q85 Q88 Q324 QC5 QD7 QD9 QV5 QV6 = L2N7002WT1G_SC-70-3
Q21 = FDC654P-G_SSOT-6: room: LVDS
Q22 = L2N7002WT1G_SC-70-3: room: LVDS
Q23 = DMG2301U-7_SOT23-3: room: CAM
Q29 = DMN66D0LDW-7_SOT363-6: room: HDD
Q44 = L2N7002WT1G_SC-70-3: room: MDC
Q45 Q47 = L2N7002WT1G_SC-70-3: room: KBC
Q48 Q59 = L2N7002WT1G_SC-70-3: room: ETY-ROOM
Q52 = DMN66D0LDW-7_SOT363-6: room: +3.3V_RUN_SOURCE
Q63 = SI4164DY-T1-GE3_SO8: room: +1.05VRUN_SOURCE
Q70-Q72 = L2N7002WT1G_SC-70-3: room: DISCHARGE
Q74 Q83 Q84 = DMN66D0LDW-7_SOT363-6: room: LED
Q75 Q79-Q82 Q86 = PDTA114EU_SC70-3: room: LED
Q76 = L2N7002WT1G_SC-70-3: room: ODD
Q77 Q78 Q89 = L2N7002WT1G_SC-70-3: room: WWAN
Q100 = L2N7002WT1G_SC-70-3: room: LED
Q106 = DMN66D0LDW-7_SOT363-6: room: CODEC
Q123 = DMN66D0LDW-7_SOT363-6: room: ODD
Q124 = DMN66D0LDW-7_SOT363-6: room: WLAN
Q326 = L2N7002WT1G_SC-70-3: room: LAN
QC1 = L2N7002WT1G_SC-70-3: room: CPU
QC3 = L2N7002WT1G_SC-70-3: room: EDP
QC4 = DMN66D0LDW-7_SOT363-6: room: +1.35V_CPU_VDDQ SOURCE
QC6 = AO4304L_SO8: room: +1.35V_CPU_VDDQ SOURCE
QH2 = BSS138W-7-F_SOT323-3: room: PCH
QH3 = L2N7002WT1G_SC-70-3: room: PCH
QH4 = DMN66D0LDW-7_SOT363-6: room: PCH
QV1 = SI4164DY-T1-GE3_SO8: room: GPU
QV2 QV11 = L2N7002WT1G_SC-70-3: room: GPU
QV3 = MMBT3904WT1G_SC70-3: room: GPU
QV4 = MMBT3906WT1G_SC70-3: room: GPU
QV7 = PMST3904_SOT323-3: room: GPU
QV8 = PMST3904_SOT323-3
R3 R760-R763 R767-R769 R771 R772 R774-R778 R780 R782 R786 R789-R791 R793-R796 R798 R800 R803-R805 R807 R878 R1154 R1583 = R_0402: room: SIO
R7-R9 R895 R899 R901 R936 R3664-R3669 RE1 RE2 RH180 RH186 = R_0402: room: FLASH ROM
R30 R38 R51 R407 = R_0402: room: THERMAL
R54 R56-R58 R1163 R1164 RC105 RE32 RH246 RH247 = R0603_0OHM
R61 = R_0402: room: CRT
R62-R65 R68-R82 R84-R88 = R_0402: room: HDMI
R67 = R0402_0OHM: room: HDMI
R100-R103 R105-R108 R110 R111 RC74 RC75 = R_0402: room: EDP
R104 = R0402_0OHM: room: EDP
R152 R551 R552 R555 R1144 R1187 = R0402_0OHM: room: LAN
R153 R736 R740 R816 R1603-R1606 R1614 = R_0402: room: USB
R154 = R0603_0OHM: room: LAN
R159 R160 R422 R423 R1137 R1138 = R_0402: room: LVDS
R169 R1076 R1077 R1079-R1082 R1086 R1096 R1097 R1099 R1119 R1120 R1141 R1142 R1145 R1146 R1642 R1654 R1668 R1680-R1683 = R_0402: room: CODEC
R392 R418 R420 R424 R759 R799 R810-R812 R814 R817-R820 R822 R825 R827-R829 R835-R838 R841 R843 R845-R852 R854-R856 R864 R869-R872 R874-R876 R879-R882 R884 R885 R887-R889 R892 R920 R952 R1069 R1118 R1125 R1169 R1171 R1179 R1197 = R_0402: room: KBC
R427 R428 = R_0402: room: CAM
R491 R492 R1062 R1066 R1530 R1539 = R_0402: room: AUX MUX
R501-R503 R506 R508 = R_0402: room: HDD
R509 R512 = R_0402: room: +5VMOD SOURCE
R510 R513-R515 R1183 = R_0402: room: ODD
R545 R546 R549 R553 R556 R557 R561 R562 = R_0402: room: LAN
R548 = R_0805: room: LAN
R571-R574 R1166 R1167 R1653 = R_0402: room: LOM
R585 R589 R1640 = R_0402: room: USH
R676 R677 R826 R894 R1700-R1702 = R_0402: room: OZ777
R693 R705 R706 R716 R718 R720 R725 R737 R1633 = R_0402: room: WLAN
R703 R707 R1631 = R0402_0OHM: room: WLAN
R704 = R0402_0OHM: room: WWAN
R717 = R0402_0OHM: room: EXPRESS
R719 R726 = R_0402: room: WWAN
R731 R732 R734 = R_0402: room: EXPRESS
R733 = R_0402: room: WPAN
R735 R909 = R_0402: room: +3.3V_RUN_SOURCE
R738 R802 = R0402_0OHM: room: SIO
R744 = R0402_0OHM: room: +3.3V_RUN_SOURCE
R751-R754 RH362 = R_0402: room: MDC
R755-R758 RE7-RE24 = R_0402: room: DOCK
R830 R834 R853 R866 R1068 R1070 R1180 = R0402_0OHM: room: KBC
R902 R903 = R_0402: room: TOUCH.PAD
R925 R926 = R_0402: room: DISCHARGE
R927 = R_0603: room: DISCHARGE
R930 R931 R1611 = R_0402: room: +1.05VRUN_SOURCE
R932 R934 R937 R938 R940 R949 R951 R953-R955 R957 R958 R988 R989 R3671 R3672 = R_0402: room: LED
R1088 R1100 R1676 R1677 R1679 = R_0402: room: AJACK
R1150 R1151 R1609 R1610 R1612 R1613 = R_0402: room: ESATA
R1161 = R0603_0OHM: room: TOUCH.PAD
R1162 = R_0603: room: TOUCH.PAD
R1607 = R0402_0OHM: room: +3.3V_SUS SOURCE
R1608 = R_0402: room: +3.3V_SUS SOURCE
R1615 = R_0402: room: +3.3VM SOURCE
R1616 = R0402_0OHM: room: +3.3VM SOURCE
R1622 R1623 R1629 R1630 = R_0402: room: RSMRST
R1626 = R0402_0OHM: room: USB
R1655 = R0402_0OHM: room: RSMRST
R1667 RE5 = R_0402: room: TPM
R1672 R1673 = R0402_0OHM: room: DOCK
RC1 RC4-RC7 RC15 RC16 RC27-RC30 RC32 RC34 RC36 RC37 RC52-RC64 RC67 RC73 RC76-RC83 RC85 RC87-RC91 RC94 = R_0402: room: CPU
RC2 RC3 RC10 RC31 RC33 RC35 RC42 RC44 RC46 RC48 RC66 RC92 RC93 = R0402_0OHM: room: CPU
RC8 RC11 RC20-RC26 RH1 RH2 = R_0402: room: XDP1
RC84 RC95-RC98 RC143 = R_0402: room: +1.35V_CPU_VDDQ SOURCE
RC86 = R_0603: room: CPU
RD1 RD4 RD6-RD8 RD11 RD12 = R0402_0OHM: room: MEMORY
RD2 RD3 RD5 RD9 RD10 = R_0402: room: MEMORY
RH3 RH4 RH6-RH14 RH16 RH17 RH19 RH20 RH22 RH24-RH28 RH30-RH32 = R_0402: room: XDP2
RH5 RH18 RH34-RH37 RH39-RH45 RH47 RH48 RH50 RH52 RH54-RH65 RH67 RH70 RH73 RH75 RH76 RH78-RH81 RH85 RH87-RH91 RH93-RH95 RH97 RH99 RH100 RH112 RH115-RH119 RH125 RH128 RH133 RH136 RH138 RH141 RH143 RH146 RH153 RH155 RH157-RH162 RH164-RH176 RH187 RH192-RH194 RH198-RH208 RH211-RH213 RH215 RH222-RH232 RH234 RH239 RH256 RH257 RH328 = R_0402: room: PCH
RH38 RH51 RH53 RH66 RH96 RH98 RH101-RH111 RH113 RH114 RH152 RH163 RH188-RH191 RH195 = R0402_0OHM: room: PCH
RH46 RH235-RH237 = R_0603: room: PCH
RH177-RH179 RH181-RH185 = R0402_0OHM: room: FLASH ROM
RH233 RH238 RH241 = R0603_0OHM: room: PCH
RH242 RH244 RH245 = R0805_0OHM: room: PCH
RH243 = R_0805: room: PCH
RH255 = R_0402: room: DP_SW
RPH1-RPH9 = RP_0804_8P4R
RV2 RV18 RV37-RV40 RV76 = R0402_0OHM: room: GPU
SW1 = SW_SKRBAAE010_4P: room: SWITCH
T2-T20 T22-T36 T39-T46 T48-T56 = TPC12: room: CPU
T21 T37 T38 T47 T72 T87 T88 T109-T111 T136-T139 T141 T144 T146-T148 = TPC12
T57-T71 T73-T86 = TPC12: room: PCH
T91-T108 T112-T115 T118-T120 T123-T129 = TPC12: room: GPU
T121 T122 T130 = TPC12: room: SIO
T142 T143 = TPC12: room: LAN
T156 = TAIMA_IH-115-F_24P: room: LOM
U1 = AH180-WG-7_SC59-3
U2 = SLG55584AVTR_TDFN8_2X2: room: USB
U6 = PI3V713-AZLEX_TQFN32_6X3: room: CRT
U7 = ASM1467_QFN20_4X4
U8 = RT9818A-44GU3_SC70-3: room: RSMRST
U9 = TC7SH08FU_SSOP5: room: RSMRST
U15 = TC7SH08FU_SSOP5: room: LAN
U19 = PS8401ATQFN40GTR-A3_TQFN40_5X5: room: HDMI
U20 U23 = PI3C3125LEX_TSSOP14: room: AUX MUX
U21 U24 = TC7SET04FU_SSOP5
U26 = CAT24C64WI-GT3_SO8: room: EDP
U27 = RTD2136S-CG_QFN48_6X6: room: EDP
U31 = WGI217LM-QPN9-A2_QFN48_6X6: room: LAN
U32 = PI3L720ZHEX_TQFN42_9X3P5: room: LAN SW
U38 = OZ777FJ2LN_QFN48_6X6: room: OZ777
U39 = AT97SC3204-X2A14-AB_TSSOP28: room: TPM
U41 = TPS2231MRGPR-2_QFN20_4X4: room: EXPRESS
U46 = ECE5048-LZY_DQFN132_11X11: room: SIO
U48 = G547I2P81U_MSOP8: room: USB
U49 = G547I2P81U_MSOP8: room: ESATA
U50 = TC7SH08FU_SSOP5: room: KBC
U51 = MEC5075-LZY_DQFN132_11X11: room: KBC
U52 = W25Q64FVSSIQ_SO8: room: FLASH ROM
U53 = W25Q32FVSSIQ_SO8: room: FLASH ROM
U58 = TC7SH08FU_SSOP5: room: LED
U74 = ALC3226-CG_QFN48_7X7: room: CODEC
U88 = LNG3DMTR_LGA16_3X3: room: HDD
U89 = AP2330W-7_SC59-3: room: HDMI
U90 U92 U94 U95 = PS8710BTQFN24GTR-A0_TQFN24_4X4
U91 U93 = G547I2P81U_MSOP8
U100-U105 = TPS22966DPUR_SON14_2X3
UC1 = 74AHC1G09GW_TSSOP5: room: CPU
UC2 = SN74LVC1G07DCKR_SC70-5: room: CPU
UC3 = 74AHC1G09GW_TSSOP5: room: PCH
UH1 = DH82LPMS-QCG1-B0_FCBGA_695P: room: PCH
UV1 = MARS-PRO_FCBGA_962P: room: GPU
UV3-UV10 = K4G20325FC-HC05_FBGA_170P: room: GPU
UV14 = 74AHC1G09GW_TSSOP5: room: GPU
Y3 = Y_X3G025000DI1H-H_4P: room: LAN
Y6 = Y_Q13FC1350000_2P: room: KBC
YH1 = Y_Q13FC1350000_2P: room: PCH
YH2 = Y_Q22FA2380049900_4P: room: PCH
YV1 = Y_7V27000011_4P: room: GPU

## Footprints (pads in the part's own frame, mm; a bottom-side part is the same pattern mirrored in y, then rotated)
2N7002DW-T-R7_SOT363-6
  oval 0.381x1.397 smd: 1(0,0) 2(0.65,0) 3(1.3,0) 4(1.3,1.725) 5(0.65,1.725) 6(0,1.725)
74AHC1G09GW_TSSOP5
  oval 0.381x1.346 smd: 1(0,0) 2(0.65,0) 3(1.3,0) 4(1.3,1.79) 5(0,1.79)
74AHC1G32GW_SOT353-5
  oval 0.406x1.092 smd: 1(0,0) 2(0.65,0) 3(1.3,0) 4(1.3,1.8) 5(0,1.8)
74LVC1G3157GW_SC-88-6
  oval 0.381x0.813 smd: 1(0,0) 2(0.65,0) 3(1.3,0) 4(1.3,1.8) 5(0.65,1.8) 6(0,1.8)
ACES_50124-0127N-001_12P
  round 0.787 hole 0.787 unplated: (-6,-1.2) (2,-1.2)
  oval 0.508x1.499 smd: 1(0,0) 2(0,-5.8) 3(-0.8,0) 4(-0.8,-5.8) 5(-1.6,0) 6(-1.6,-5.8) 7(-2.4,0) 8(-2.4,-5.8) 9(-3.2,0) 10(-3.2,-5.8) 11(-4,0) 12(-4,-5.8)
  custom 0.375x0.375 smd: 13(-6.1,0) 16(2.1,0)
  rect 1.803x2.007 smd: 14(-6.1,-2.9) 17(2.1,-2.9)
  rect 1.803x1.499 smd: 15(-6.1,-5.8) 18(2.1,-5.8)
ACES_50273-0020N-001_2P
  oval 0.787x1.6 smd: 1(0,0) 2(1.25,0)
  rect 2.108x2.997 smd: 3(-2.55,-2.9) 4(3.8,-2.9)
ACES_50273-0040N-001_4P
  oval 0.787x1.6 smd: 1(0,0) 2(1.25,0) 3(2.5,0) 4(3.75,0)
  rect 2.108x2.997 smd: 5(-2.55,-2.9) 6(6.3,-2.9)
ACES_50279-0040N-001_4P
  oval 0.787x1.905 smd: 1(0,0) 2(1.25,0) 3(2.5,0) 4(3.75,0)
  rect 1.295x3.353 smd: 5(6.6,-4.925) 6(-2.85,-4.925)
ACES_51524-01001-003_10P
  oval 0.61x1.295 smd: 1(0,0) 2(1,0) 3(2,0) 4(3,0) 5(4,0) 6(5,0) 7(6,0) 8(7,0) 9(8,0) 10(9,0)
  rect 2.489x2.21 smd: 11(-3,-3.05) 12(12,-3.05)
ACES_59003-04006-001_40P
  round 0.889 hole 0.889 unplated: (-20.25,2.125) (0.75,2.125)
  oval 0.254x1.143 smd: 1(0,0) 2(-0.5,0) 3(-1,0) 4(-1.5,0) 5(-2,0) 6(-2.5,0) 7(-3,0) 8(-3.5,0) 9(-4,0) 10(-4.5,0) 11(-5,0) 12(-5.5,0) 13(-6,0) 14(-6.5,0) 15(-7,0) 16(-7.5,0) 17(-8,0) 18(-8.5,0) 19(-9,0) 20(-9.5,0) 21(-10,0) 22(-10.5,0) 23(-11,0) 24(-11.5,0) 25(-12,0) 26(-12.5,0) 27(-13,0) 28(-13.5,0) 29(-14,0) 30(-14.5,0) 31(-15,0) 32(-15.5,0) 33(-16,0) 34(-16.5,0) 35(-17,0) 36(-17.5,0) 37(-18,0) 38(-18.5,0) 39(-19,0) 40(-19.5,0)
  rect 1.499x2.997 smd: 41(-22,2.125) 42(2.5,2.125)
  rect 2.794x1.499 smd: 43(-15.45,4.175) 44(-4.05,4.175)
AH180-WG-7_SC59-3
  oval 0.686x1.143 smd: 1(0,0) 2(-0.95,-2.225) 3(0.95,-2.225)
ALC3226-CG_QFN48_7X7
  oval 0.254x0.889 smd: 1(0,0) 2(0.5,0) 3(1,0) 4(1.5,0) 5(2,0) 6(2.5,0) 7(3,0) 8(3.5,0) 9(4,0) 10(4.5,0) 11(5,0) 12(5.5,0) 25(5.5,7.1) 26(5,7.1) 27(4.5,7.1) 28(4,7.1) 29(3.5,7.1) 30(3,7.1) 31(2.5,7.1) 32(2,7.1) 33(1.5,7.1) 34(1,7.1) 35(0.5,7.1) 36(0,7.1)
  oval 0.889x0.254 smd: 13(6.3,0.8) 14(6.3,1.3) 15(6.3,1.8) 16(6.3,2.3) 17(6.3,2.8) 18(6.3,3.3) 19(6.3,3.8) 20(6.3,4.3) 21(6.3,4.8) 22(6.3,5.3) 23(6.3,5.8) 24(6.3,6.3) 37(-0.8,6.3) 38(-0.8,5.8) 39(-0.8,5.3) 40(-0.8,4.8) 41(-0.8,4.3) 42(-0.8,3.8) 43(-0.8,3.3) 44(-0.8,2.8) 45(-0.8,2.3) 46(-0.8,1.8) 47(-0.8,1.3) 48(-0.8,0.8)
  rect 5.512x5.512 smd: 49(2.75,3.55)
AO3402_SOT23-3
  oval 1.016x1.524 smd: 1(0,0) 2(0.965,2.083) 3(-0.965,2.083)
AO4304L_SO8
  oval 0.635x1.854 smd: 1(0,0) 2(1.27,0) 3(2.54,0) 4(3.81,0) 5(3.81,5.165) 6(2.54,5.165) 7(1.27,5.165) 8(0,5.165)
AP2330W-7_SC59-3
  oval 0.787x0.991 smd: 1(0,0) 2(-0.95,-2.4) 3(0.95,-2.4)
AS393MTR-G1_SO8
  oval 0.635x1.651 smd: 1(0,0) 2(1.27,0) 3(2.54,0) 4(3.81,0) 5(3.81,5.375) 6(2.54,5.375) 7(1.27,5.375) 8(0,5.375)
ASM1467_QFN20_4X4
  oval 0.254x0.991 smd: 1(0,0) 2(0.5,0) 3(1,0) 4(1.5,0) 5(2,0) 11(2,4) 12(1.5,4) 13(1,4) 14(0.5,4) 15(0,4)
  oval 0.991x0.254 smd: 6(3,1) 7(3,1.5) 8(3,2) 9(3,2.5) 10(3,3) 16(-1,3) 17(-1,2.5) 18(-1,2) 19(-1,1.5) 20(-1,1)
  rect 2.108x2.108 smd: 21(1,2)
AT97SC3204-X2A14-AB_TSSOP28
  oval 0.381x1.626 smd: 1(0,0) 2(0.65,0) 3(1.3,0) 4(1.95,0) 5(2.6,0) 6(3.25,0) 7(3.9,0) 8(4.55,0) 9(5.2,0) 10(5.85,0) 11(6.5,0) 12(7.15,0) 13(7.8,0) 14(8.45,0) 15(8.45,5.8) 16(7.8,5.8) 17(7.15,5.8) 18(6.5,5.8) 19(5.85,5.8) 20(5.2,5.8) 21(4.55,5.8) 22(3.9,5.8) 23(3.25,5.8) 24(2.6,5.8) 25(1.95,5.8) 26(1.3,5.8) 27(0.65,5.8) 28(0,5.8)
BAS40-05W_SC70-3
  oval 0.508x0.559 smd: 1(0,0) 2(-0.65,-1.85) 3(0.65,-1.85)
BAT54HT1G_SOD323-2
  rect 0.635x0.838 smd: 1(0,0) 2(2.22,0)
BELLW_80003-7041_52P
  round 1.6 hole 1.6 unplated: (-0.7,4.1)
  round 1.092 hole 1.092 unplated: (24.3,4.1)
  oval 0.61x2.007 smd: 1(0,0) 2(0.4,8.2) 3(0.8,0) 4(1.2,8.2) 5(1.6,0) 6(2,8.2) 7(2.4,0) 8(2.8,8.2) 9(3.2,0) 10(3.6,8.2) 11(4,0) 12(4.4,8.2) 13(4.8,0) 14(5.2,8.2) 15(5.6,0) 16(6,8.2) 17(9.6,0) 18(10,8.2) 19(10.4,0) 20(10.8,8.2) 21(11.2,0) 22(11.6,8.2) 23(12,0) 24(12.4,8.2) 25(12.8,0) 26(13.2,8.2) 27(13.6,0) 28(14,8.2) 29(14.4,0) 30(14.8,8.2) 31(15.2,0) 32(15.6,8.2) 33(16,0) 34(16.4,8.2) 35(16.8,0) 36(17.2,8.2) 37(17.6,0) 38(18,8.2) 39(18.4,0) 40(18.8,8.2) 41(19.2,0) 42(19.6,8.2) 43(20,0) 44(20.4,8.2) 45(20.8,0) 46(21.2,8.2) 47(21.6,0) 48(22,8.2) 49(22.4,0) 50(22.8,8.2) 51(23.2,0) 52(23.6,8.2)
  rect 2.311x3.2 smd: 53(-2.85,0.6) 54(26.45,0.6)
BQ24738RGRR_QFN20_3P5X3P5
  oval 0.254x1.041 smd: 1(0,0) 2(0.5,0) 3(1,0) 4(1.5,0) 5(2,0) 11(2,3.45) 12(1.5,3.45) 13(1,3.45) 14(0.5,3.45) 15(0,3.45)
  oval 1.041x0.254 smd: 6(2.725,0.725) 7(2.725,1.225) 8(2.725,1.725) 9(2.725,2.225) 10(2.725,2.725) 16(-0.725,2.725) 17(-0.725,2.225) 18(-0.725,1.725) 19(-0.725,1.225) 20(-0.725,0.725)
  rect 2.057x2.057 smd: 21(1,1.725)
BSS138W-7-F_SOT323-3
  oval 0.711x0.889 smd: 1(0,0) 2(-0.65,-1.9) 3(0.65,-1.9)
C_0402
  rect 0.508x0.559 smd: 1(0,0) 2(0.914,0)
C_0603
  rect 0.635x0.889 smd: 1(0,0) 2(1.397,0)
C_0805
  rect 0.813x1.397 smd: 1(0,0) 2(1.702,0)
C_1808
  rect 1.041x2.311 smd: 1(0,0) 2(4.35,0)
C_APXK2R5ARA331MF451
  oval 3.15x1.6 smd: 1(0,0) 2(-5.05,0)
C_APXK6R3ARA221MF451
  oval 3.15x1.6 smd: 1(0,0) 2(5.05,0)
C_D1
  rect 1.803x2.794 smd: 1(0,0) 2(6.5,0)
C_D2
  rect 2.388x2.794 smd: 1(0,0) 2(6.4,0)
C_EEEFK1E101YP
  oval 3.2x1.6 smd: 1(0,0) 2(5,0)
C_MP2VU390MC5R7
  oval 3.505x1.6 smd: 1(0,0) 2(-5.6,0)
C_MP6VL220MC6
  oval 3.505x1.6 smd: 1(0,0) 2(5.6,0)
CAT24C64WI-GT3_SO8
  oval 0.635x1.854 smd: 1(0,0) 2(1.27,0) 3(2.54,0) 4(3.81,0) 5(3.81,5.165) 6(2.54,5.165) 7(1.27,5.165) 8(0,5.165)
CD3301RHHR_QFN36_6X6
  oval 0.254x1.194 smd: 1(0,0) 2(0.5,0) 3(1,0) 4(1.5,0) 5(2,0) 6(2.5,0) 7(3,0) 8(3.5,0) 9(4,0) 19(4,5.8) 20(3.5,5.8) 21(3,5.8) 22(2.5,5.8) 23(2,5.8) 24(1.5,5.8) 25(1,5.8) 26(0.5,5.8) 27(0,5.8)
  oval 1.194x0.254 smd: 10(4.9,0.9) 11(4.9,1.4) 12(4.9,1.9) 13(4.9,2.4) 14(4.9,2.9) 15(4.9,3.4) 16(4.9,3.9) 17(4.9,4.4) 18(4.9,4.9) 28(-0.9,4.9) 29(-0.9,4.4) 30(-0.9,3.9) 31(-0.9,3.4) 32(-0.9,2.9) 33(-0.9,2.4) 34(-0.9,1.9) 35(-0.9,1.4) 36(-0.9,0.9)
  rect 4.089x4.089 smd: 37(2,2.9)
CD3302RUYR_QFN28_4X4
  oval 0.203x1.041 smd: 1(0,0) 2(0.4,0) 3(0.8,0) 4(1.2,0) 5(1.6,0) 6(2,0) 7(2.4,0) 15(2.4,3.95) 16(2,3.95) 17(1.6,3.95) 18(1.2,3.95) 19(0.8,3.95) 20(0.4,3.95) 21(0,3.95)
  oval 1.041x0.203 smd: 8(3.175,0.775) 9(3.175,1.175) 10(3.175,1.575) 11(3.175,1.975) 12(3.175,2.375) 13(3.175,2.775) 14(3.175,3.175) 22(-0.775,3.175) 23(-0.775,2.775) 24(-0.775,2.375) 25(-0.775,1.975) 26(-0.775,1.575) 27(-0.775,1.175) 28(-0.775,0.775)
  rect 2.591x2.591 smd: 29(1.2,1.975)
CHILI_PBY160808T-300Y-N_2P
  rect 0.559x1.041 smd: 1(0,0) 2(1.3,0)
CONCR_099AKAC19NBLCNF_19P-T
  round 0.813 hole 0.559: 1(0,0) 2(0.5,1.55) 3(1,0) 4(1.5,1.55) 5(2,0) 6(2.5,1.55) 7(3,0) 8(3.5,1.55) 9(4,0) 10(4.5,1.55) 11(5,0) 12(5.5,1.55) 13(6,0) 14(6.5,1.55) 15(7,0) 16(7.5,1.55) 17(8,0) 18(8.5,1.55) 19(9,0)
  oval 1.499x2.21 hole 0.889x1.6: 20(-4.65,-6.5) 21(13.65,-7.75) 22(-2.75,1.7) 23(11.75,1.7)
