# Allegro board LA-9411P R10-0403.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
DDR_B_D8: length 78.3
  IN1 w0.089: v2(136.73,89.92) 136.27,89.92 136,89.65
  IN1 w0.102: v2(128.95,23.17) 128.72,22.95 127.66,22.95 127.43,23.18 127.43,38.22 126.32,39.33 126.32,73.01 125.36,73.98 125.36,79.01 136,89.65
  BOTTOM w0.089: v2(136.73,89.92) 137.2,90.39 JCPU1.AT12
  BOTTOM w0.102: v2(128.95,23.17) 128.46,23.67 128.46,24.88 128.9,25.32 JDIMM2.21
DDR_B_D9: length 79.9
  IN1 w0.089: 136,89.22 136.3,89.52 137.33,89.52 v2(137.73,89.92)
  IN1 w0.102: 136,89.22 125.66,78.88 125.66,75.2 127.64,73.22 127.64,49.3 127.55,49.21 126.73,49.21 126.63,49.11 126.63,48.81 126.73,48.7 127.54,48.7 127.64,48.6 127.64,48.3 127.54,48.2 126.73,48.2 126.63,48.09 126.63,47.79 126.73,47.69 127.34,47.69 127.47,47.56 127.47,47.31 127.34,47.18 126.73,47.18 126.63,47.08 126.63,46.7 126.76,46.57 127.05,46.57 127.17,46.44 127.17,46.19 127.05,46.06 126.76,46.06 126.63,45.94 126.63,39.45 127.76,38.32 127.76,27.02 128.95,25.83 v2(128.95,24.7)
  BOTTOM w0.089: v2(137.73,89.92) 138.2,90.39 JCPU1.AR12
  BOTTOM w0.102: JDIMM2.23 129.5,25.25 v2(128.95,24.7)
DDR_B_D10: length 83.8
  IN1 w0.089: 136.11,84.37 136.26,84.52 136.9,84.52 137.13,84.75 137.13,85.15 137.51,85.52 137.9,85.52 138.13,85.75 138.13,86.06 138.58,86.51 138.95,86.51 139.14,86.7 139.14,87.05 139.61,87.52 139.9,87.52 140.13,87.75 140.13,89.52 v2(139.73,89.92)
  IN1 w0.102: 136.11,84.37 134.03,82.29 134.03,71.82 131.23,69.02 131.23,62.98 131.36,62.85 131.89,62.85 132.01,62.73 132.01,62.22 131.91,62.12 131.21,62.12 131.11,62.01 131.11,61.71 131.21,61.61 131.91,61.61 132.01,61.51 132.01,61.2 131.91,61.1 131.21,61.1 131.11,61 131.11,60.69 131.21,60.59 131.91,60.59 132.01,60.49 132.01,60.19 131.91,60.08 131.21,60.08 131.11,59.98 131.11,59.68 131.21,59.58 131.91,59.58 132.01,59.47 132.01,59.17 131.91,59.07 131.21,59.07 131.11,58.97 131.11,58.66 131.21,58.56 131.91,58.56 132.01,58.46 132.01,58.15 131.91,58.05 131.21,58.05 131.11,57.95 131.11,57.65 131.21,57.54 131.91,57.54 132.01,57.44 132.01,57.14 131.91,57.04 131.21,57.04 131.11,56.93 131.11,56.63 131.21,56.53 131.91,56.53 132.01,56.43 132.01,46.24 130.3,44.53 130.3,40.11 131.73,38.68 131.73,25.22 v2(132.25,24.7)
  BOTTOM w0.089: JCPU1.AN12 140.2,90.39 v2(139.73,89.92)
  BOTTOM w0.102: v2(132.25,24.7) 132.5,24.95 JDIMM2.33
DDR_B_D11: length 85.2
  IN1 w0.089: v2(140.73,88.92) 140.33,88.52 140.33,86.95 139.9,86.52 139.77,86.52 139.27,86.02 139.27,85.86 138.93,85.52 138.76,85.52 138.13,84.9 138.13,84.75 137.71,84.33 136.53,84.33 136.32,84.13 136.32,83.79 136.11,83.58
  IN1 w0.102: 136.11,83.58 134.93,82.4 134.93,82.4 134.59,82.4 134.35,82.16 134.35,81.94 134.59,81.7 134.83,81.7 134.96,81.57 134.96,81.17 134.83,81.04 134.46,81.04 134.34,80.91 134.34,71.7 132.32,69.68 132.32,68.9 132.22,68.8 131.64,68.8 131.54,68.69 131.54,68.39 131.64,68.29 132.22,68.29 132.32,68.19 132.32,67.88 132.22,67.78 131.64,67.78 131.54,67.68 131.54,67.37 131.64,67.27 132.22,67.27 132.32,67.17 132.32,66.86 132.22,66.76 131.64,66.76 131.54,66.66 131.54,66.36 131.64,66.26 132.22,66.26 132.32,66.15 132.32,65.85 132.22,65.75 131.64,65.75 131.54,65.65 131.54,65.34 131.64,65.24 132.22,65.24 132.32,65.14 132.32,64.83 132.22,64.73 131.64,64.73 131.54,64.63 131.54,64.32 131.64,64.22 132.16,64.22 132.29,64.1 132.29,63.84 132.16,63.72 131.64,63.72 131.54,63.61 131.54,63.31 131.64,63.21 132.22,63.21 132.32,63.11 132.32,46.11 130.7,44.5 130.7,40.41 132.04,39.08 132.04,25.39 132.16,25.26 132.6,25.26 132.72,25.13 132.72,23.29 132.61,23.17 v2(132.25,23.17)
  BOTTOM w0.089: v2(140.73,88.92) 141.2,89.39 JCPU1.AM11
  BOTTOM w0.102: v2(132.25,23.17) 133.1,24.02 JDIMM2.35
DDR_B_D12: length 78.6
  IN1 w0.102: v2(128.95,20.13) 129.47,20.64 129.47,21.43 129.83,21.79 129.83,25.91 128.39,27.34 128.39,31.77 128.5,31.87 128.99,31.87 129.12,32 129.12,32.25 128.99,32.38 128.5,32.38 128.39,32.48 128.39,38.59 127.31,39.67 127.31,44.81 128.25,45.75 128.25,68.65 132.19,72.59 132.19,84.2 136.13,88.14 136.13,88.32 v2(136.73,88.92)
  BOTTOM w0.089: JCPU1.AT11 137.2,89.39 v2(136.73,88.92)
  BOTTOM w0.102: v2(128.95,20.13) 129.46,19.62 129.46,19.24 129.2,18.98 JDIMM2.22
DDR_B_D13: length 81
  IN1 w0.089: 136.11,88.86 136.58,89.33 137.24,89.33 137.65,88.92 v2(137.73,88.92)
  IN1 w0.102: 136.11,88.86 135.77,88.52 135.77,88.21 131.16,83.6 131.16,82.79 130.54,82.17 130.16,82.17 125.97,77.98 125.97,75.32 127.95,73.34 127.95,45.87 126.93,44.86 126.93,39.62 128.09,38.46 128.09,27.22 129.52,25.78 129.52,22.23 v2(128.95,21.65)
  BOTTOM w0.089: v2(137.73,88.92) 138.2,89.39 JCPU1.AR11
  BOTTOM w0.102: JDIMM2.24 129.8,20.4 129.4,20.8 129.4,21.2 v2(128.95,21.65)
DDR_B_D14: length 85.4
  IN1 w0.089: v2(140.73,89.92) 140.29,90.36 139.49,90.36 139.32,90.18 139.32,88.79 138.85,88.32 138.57,88.32 138.33,88.09 138.33,87.83 138.02,87.52 137.46,87.52 137.13,87.19 137.13,86.57 136.88,86.32 136.5,86.32 136.32,86.15 136.32,85.75 136.11,85.53
  IN1 w0.102: v2(132.25,20.13) 131.98,20.13 131.55,20.55 131.55,21.91 131.49,21.98 131.49,24.59 131.12,24.96 131.12,26.46 130.37,27.21 130.37,39.1 129.27,40.21 129.27,45.02 131.4,47.15 131.4,49.93 131.3,50.03 130.67,50.03 130.54,50.16 130.54,50.41 130.67,50.54 131.3,50.54 131.4,50.64 131.4,50.95 131.3,51.05 130.6,51.05 130.5,51.15 130.5,51.45 130.6,51.56 131.3,51.56 131.4,51.66 131.4,52.16 131.3,52.27 130.6,52.27 130.5,52.37 130.5,69.16 133.42,72.08 133.42,82.85 136.11,85.53
  BOTTOM w0.089: v2(140.73,89.92) 141.2,90.39 JCPU1.AM12
  BOTTOM w0.102: JDIMM2.34 132.8,19.58 v2(132.25,20.13)
DDR_B_D15: length 83.4
  IN1 w0.089: v2(139.73,88.92) 139.33,88.52 139.33,88.12 139.13,87.92 139.13,87.75 138.9,87.52 138.73,87.52 138.13,86.92 138.13,86.75 137.9,86.52 137.73,86.52 137.13,85.92 137.13,85.75 136.9,85.52 136.56,85.52 136.11,85.07
  IN1 w0.102: 136.11,85.07 133.73,82.69 133.73,71.95 130.81,69.03 130.81,56.31 130.93,56.18 131.52,56.18 131.64,56.06 131.64,55.57 131.52,55.45 130.91,55.45 130.81,55.35 130.81,55.04 130.91,54.94 131.61,54.94 131.71,54.84 131.71,54.53 131.61,54.43 130.91,54.43 130.81,54.33 130.81,54.03 130.91,53.92 131.61,53.92 131.71,53.82 131.71,53.52 131.61,53.42 130.91,53.42 130.81,53.31 130.81,53.01 130.91,52.91 131.61,52.91 131.71,52.81 131.71,46.96 129.78,45.03 129.78,40.17 130.7,39.24 130.7,27.35 131.43,26.62 131.43,25.09 131.83,24.68 131.83,22.07 v2(132.25,21.65)
  BOTTOM w0.089: JCPU1.AN11 140.2,89.39 v2(139.73,88.92)
  BOTTOM w0.102: JDIMM2.36 133.4,20.5 v2(132.25,21.65)
DDR_B_D16: length 71.2
  IN1 w0.089: v2(137.73,82.92) 137.13,82.32 137.13,81.65 136.9,81.41 136.59,81.41 136.3,81.13 136.3,80.12 136,79.82
  IN1 w0.102: 136,79.82 135.76,79.58 135.76,70.8 134.77,69.81 134.77,68.82 134.67,68.72 133.94,68.72 133.82,68.59 133.82,68.34 133.94,68.21 134.48,68.21 134.6,68.08 134.6,67.83 134.48,67.7 133.84,67.7 133.74,67.6 133.74,67.3 133.84,67.19 134.67,67.19 134.77,67.09 134.77,66.79 134.67,66.69 133.84,66.69 133.74,66.58 133.74,66.28 133.84,66.18 134.67,66.18 134.77,66.08 134.77,65.77 134.64,65.65 133.94,65.65 133.82,65.52 133.82,65.19 133.94,65.06 134.64,65.06 134.77,64.93 134.77,46.55 132.76,44.55 132.76,41.02 132.89,40.89 133.36,40.89 133.49,40.77 133.49,26.71 134.21,25.99 134.21,24.59 134.4,24.4 134.68,24.4 134.79,24.51 v2(134.79,24.7)
  BOTTOM w0.089: v2(137.73,82.92) 138.2,83.39 JCPU1.AR5
  BOTTOM w0.102: JDIMM2.39 134.3,25.19 v2(134.79,24.7)
DDR_B_D17: length 71.3
  IN1 w0.089: 136,80.31 136,80.84 136.11,80.96 136.11,81.93 136.67,82.48 137.03,82.48 137.33,82.78 137.33,83.51 v2(137.73,83.92)
  IN1 w0.102: v2(134.79,23.17) 133.89,24.07 133.89,25.84 133.18,26.55 133.18,39.79 132.43,40.54 132.43,44.65 134.46,46.68 134.46,62.33 134.36,62.43 134.12,62.43 133.99,62.56 133.99,62.81 134.12,62.94 134.36,62.94 134.46,63.04 134.46,63.35 134.36,63.45 133.84,63.45 133.71,63.58 133.71,63.83 133.84,63.96 134.36,63.96 134.46,64.06 134.46,64.57 134.34,64.69 133.56,64.69 133.43,64.82 133.43,69.21 135.45,71.23 135.45,79.76 136,80.31
  BOTTOM w0.089: v2(137.73,83.92) 138.2,84.39 JCPU1.AR6
  BOTTOM w0.102: JDIMM2.41 134.9,25.18 135.25,24.83 135.25,23.64 v2(134.79,23.17)
DDR_B_D18: length 72.9
  IN1 w0.089: v2(140.73,82.92) 140.73,82.53 140.32,82.12 140.32,81.67 139.98,81.33 139.52,81.33 139.32,81.14 139.32,78.51 139.15,78.33
  IN1 w0.102: v2(137.66,24.7) 137.66,26.38 137.13,26.91 137.13,30.94 137.03,31.05 136.6,31.05 136.47,31.17 136.47,31.43 136.6,31.55 137.03,31.55 137.13,31.66 137.13,31.96 137.03,32.06 136.52,32.06 136.39,32.19 136.39,32.44 136.52,32.57 137.03,32.57 137.13,32.67 137.13,41.35 137.4,41.62 137.4,44.4 137.9,44.91 137.9,57.58 137.8,57.68 137.05,57.68 136.95,57.78 136.95,58.09 137.05,58.19 137.8,58.19 137.9,58.29 137.9,58.6 137.8,58.7 137.05,58.7 136.95,58.8 136.95,59.11 137.05,59.21 137.8,59.21 137.9,59.31 137.9,59.82 137.78,59.94 137.26,59.94 137.13,60.07 137.13,69.01 137.9,69.78 137.9,73.53 138.01,73.63 138.53,73.63 138.63,73.74 138.63,74.04 138.53,74.14 138.01,74.14 137.9,74.24 137.9,74.55 138.01,74.65 138.53,74.65 138.63,74.75 138.63,75.06 138.53,75.16 138.01,75.16 137.9,75.26 137.9,75.56 138.01,75.67 138.53,75.67 138.63,75.77 138.63,76.07 138.53,76.17 138.01,76.17 137.9,76.28 137.9,76.63 138.03,76.76 138.5,76.76 138.63,76.89 138.63,77.82 139.15,78.33
  BOTTOM w0.089: v2(140.73,82.92) 141.2,83.39 JCPU1.AM5
  BOTTOM w0.102: v2(137.66,24.7) 137.9,24.94 JDIMM2.51
DDR_B_D19: length 73.5
  IN1 w0.089: 138.91,78.53 139.13,78.75 139.13,81.21 139.44,81.52 139.9,81.52 140.13,81.75 140.13,82.89 140.73,83.49 v2(140.73,83.92)
  IN1 w0.102: v2(137.66,23.17) 137.23,23.61 137.23,26.11 135.99,27.35 135.99,43.88 137.6,45.49 137.6,53.97 137.5,54.08 136.93,54.08 136.8,54.2 136.8,54.46 136.93,54.58 137.5,54.58 137.6,54.69 137.6,54.99 137.5,55.09 136.75,55.09 136.65,55.19 136.65,55.5 136.75,55.6 137.5,55.6 137.6,55.7 137.6,56.01 137.5,56.11 136.75,56.11 136.65,56.21 136.65,56.51 136.75,56.62 137.5,56.62 137.6,56.72 137.6,57.23 137.47,57.35 136.77,57.35 136.65,57.48 136.65,68.95 137.6,69.91 137.6,77.22 138.91,78.53
  BOTTOM w0.089: JCPU1.AM6 141.2,84.39 v2(140.73,83.92)
  BOTTOM w0.102: JDIMM2.53 138.5,24.01 v2(137.66,23.17)
DDR_B_D20: length 70
  IN1 w0.089: v2(136.73,82.92) 136.64,82.92 136.11,82.39
  IN1 w0.102: v2(134.79,21.65) 134.5,21.36 134.35,21.36 134.22,21.49 134.22,21.84 133.9,22.16 133.69,22.16 133.56,22.29 133.56,25.64 132.88,26.32 132.88,39.63 132.1,40.4 132.1,44.75 133.13,45.78 133.13,69.34 135.15,71.36 135.15,80.05 135.78,80.69 135.78,82.07 136.11,82.39
  BOTTOM w0.089: v2(136.73,82.92) 137.2,83.39 JCPU1.AT5
  BOTTOM w0.102: v2(134.79,21.65) 134.31,21.17 134.31,19.25 134.6,18.96 JDIMM2.40
DDR_B_D21: length 70.2
  IN1 w0.089: v2(136.73,83.92) 136.73,83.49 136.11,82.86
  IN1 w0.102: v2(134.79,20.13) 133.23,21.69 133.23,25.5 132.55,26.19 132.55,39.49 131.77,40.26 131.77,44.85 132.82,45.9 132.82,69.47 134.84,71.49 134.84,80.18 135.47,80.81 135.47,82.22 136.11,82.86
  BOTTOM w0.089: v2(136.73,83.92) 137.2,84.39 JCPU1.AT6
  BOTTOM w0.102: JDIMM2.42 135.2,19.72 v2(134.79,20.13)
DDR_B_D22: length 72.4
  IN1 w0.089: 137.3,77.36 137.3,77.64 138.33,78.68 138.33,81.15 138.52,81.33 138.98,81.33 139.32,81.67 139.32,82.16 139.73,82.57 v2(139.73,82.92)
  IN1 w0.102: 137.3,77.36 137.3,70.03 136.34,69.08 136.34,53.87 136.47,53.75 137.17,53.75 137.3,53.62 137.3,53.29 137.17,53.16 136.61,53.16 136.48,53.03 136.48,52.69 136.61,52.57 137.17,52.57 137.3,52.44 137.3,45.62 135.66,43.98 135.66,32.62 135.56,32.51 135.12,32.51 135.02,32.41 135.02,32.11 135.12,32.01 135.56,32.01 135.66,31.9 135.66,27.21 136.9,25.97 136.9,22.41 v2(137.66,21.65)
  BOTTOM w0.089: v2(139.73,82.92) 140.2,83.39 JCPU1.AN5
  BOTTOM w0.102: v2(137.66,21.65) 137.22,21.21 137.22,19.2 137.6,18.82 JDIMM2.50
DDR_B_D23: length 73.4
  IN1 w0.089: 137.94,78.56 138.13,78.75 138.13,81.21 138.44,81.52 138.9,81.52 139.13,81.75 139.13,82.59 139.32,82.77 139.32,83.85 139.39,83.92 v2(139.73,83.92) ; 136.99,77.36 136.99,77.61 137.29,77.92
  IN1 w0.102: 137.94,78.56 137.29,77.92 ; v2(137.66,20.13) 137.45,20.13 136.57,21.01 136.57,25.5 134.72,27.35 134.72,38.48 135.11,38.87 135.11,44.75 136.86,46.51 136.86,50.7 136.76,50.8 136.12,50.8 136.04,50.89 136.04,51.39 136.14,51.49 136.81,51.49 136.91,51.6 136.91,51.9 136.81,52 136.14,52 136.04,52.1 136.04,69.21 136.99,70.16 136.99,77.36
  BOTTOM w0.089: v2(139.73,83.92) 140.2,84.39 JCPU1.AN6
  BOTTOM w0.102: v2(137.66,20.13) 138.2,19.59 JDIMM2.52
DDR_B_D24: length 70
  IN1 w0.089: 140.65,77.36 140.65,77.58 141.33,78.27 141.33,80.09 141.77,80.52 141.9,80.52 142.13,80.75 142.13,80.89 142.7,81.46 142.89,81.46 143.36,81.92 v2(143.73,81.92)
  IN1 w0.102: 140.65,77.36 140.65,76.09 140.54,75.98 140.46,75.98 140.33,75.86 140.33,75.6 140.46,75.48 140.54,75.48 140.65,75.38 140.65,75.07 140.54,74.97 140.19,74.97 140.06,74.84 140.06,74.59 140.19,74.46 140.54,74.46 140.65,74.36 140.65,74.05 140.54,73.95 140.15,73.95 140.05,73.85 140.05,73.55 140.15,73.44 140.54,73.44 140.65,73.34 140.65,73.04 140.54,72.94 140.15,72.94 140.05,72.84 140.05,71.96 139.33,71.24 139.33,60.55 139.39,60.48 139.39,40.91 139.29,40.81 139.04,40.81 138.92,40.69 138.92,40.33 139.05,40.21 139.26,40.21 139.39,40.08 139.39,37.32 138.55,36.49 138.55,32.51 138.66,32.41 139,32.41 139.1,32.31 139.1,32 139,31.9 138.66,31.9 138.55,31.8 138.55,31.49 138.66,31.39 139,31.39 139.1,31.29 139.1,30.98 139,30.88 138.66,30.88 138.55,30.78 138.55,30.48 138.66,30.37 139,30.37 139.1,30.27 139.1,29.97 139,29.87 138.66,29.87 138.55,29.77 138.55,27.5 139.1,26.96 139.1,26.39 139.72,25.77 139.72,24.45 v2(140.2,23.97)
  BOTTOM w0.089: JCPU1.AJ4 144.2,82.39 v2(143.73,81.92)
  BOTTOM w0.102: v2(140.2,23.97) 139.7,24.47 JDIMM2.57
DDR_B_D25: length 69.9
  IN1 w0.089: v2(142.73,81.92) 142.26,81.92 141.86,81.52 141.59,81.52 141.13,81.07 141.13,78.79 139.75,77.4 139.75,77.36
  IN1 w0.102: v2(140.2,22.45) 140.2,22.24 140.07,22.11 139.81,22.11 139.42,22.5 139.42,25.65 138.79,26.27 138.79,26.83 138.25,27.38 138.25,38.31 138.35,38.42 138.68,38.42 138.78,38.52 138.78,38.82 138.68,38.92 138.35,38.92 138.25,39.03 138.25,39.33 138.35,39.43 138.68,39.43 138.78,39.53 138.78,39.84 138.68,39.94 138.35,39.94 138.25,40.04 138.25,40.6 138.51,40.87 138.51,43.87 138.64,44 138.9,44 139.02,44.13 139.02,71.37 139.75,72.09 139.75,77.36
  BOTTOM w0.089: JCPU1.AK4 143.2,82.39 v2(142.73,81.92)
  BOTTOM w0.102: JDIMM2.59 140.3,25.27 140.62,24.94 140.62,22.87 v2(140.2,22.45)
DDR_B_D26: length 67.2
  IN1 w0.089: 143.95,77.36 143.95,78.7 v2(143.73,78.92)
  IN1 w0.102: v2(142.87,23.97) 142.46,24.38 142.46,26.26 141.59,27.13 141.59,27.93 141.69,28.04 141.82,28.04 141.94,28.16 141.94,28.42 141.82,28.54 141.69,28.54 141.59,28.65 141.59,29.55 141.71,29.68 141.87,29.68 141.99,29.81 141.99,30.16 141.87,30.29 141.71,30.29 141.59,30.42 141.59,30.78 141.71,30.91 141.85,30.91 141.98,31.04 141.98,31.29 141.85,31.42 141.71,31.42 141.59,31.55 141.59,31.9 141.71,32.03 141.89,32.03 142.02,32.16 142.02,32.51 141.89,32.64 141.71,32.64 141.59,32.77 141.59,35.75 141.71,35.88 142.16,35.88 142.29,36 142.29,36.28 142.16,36.41 141.71,36.41 141.59,36.54 141.59,36.89 141.71,37.02 142.16,37.02 142.29,37.15 142.29,37.43 142.16,37.55 141.71,37.55 141.59,37.68 141.59,38.11 141.71,38.24 142.16,38.24 142.29,38.37 142.29,38.7 142.16,38.82 141.71,38.82 141.59,38.95 141.59,39.22 141.71,39.34 142.16,39.34 142.29,39.47 142.29,39.73 142.16,39.85 141.71,39.85 141.59,39.98 141.59,40.25 141.71,40.37 142.16,40.37 142.29,40.5 142.29,40.77 142.16,40.89 141.71,40.89 141.59,41.02 141.59,60.22 141.99,60.63 141.99,63.78 142.49,64.27 142.49,68.72 143.22,69.45 143.22,70.93 143.95,71.67 143.95,77.36
  BOTTOM w0.089: JCPU1.AJ1 144.2,79.39 v2(143.73,78.92)
  BOTTOM w0.102: JDIMM2.67 142.7,25.25 142.41,24.97 142.41,24.42 v2(142.87,23.97)
DDR_B_D27: length 68.6
  IN1 w0.089: 143.65,78.28 143.36,78.57 143.35,78.57 143.35,79.11 143.73,79.49 v2(143.73,79.92)
  IN1 w0.102: 143.65,78.28 143.65,76.06 143.55,75.96 143.22,75.96 143.12,75.86 143.12,75.55 143.22,75.45 143.55,75.45 143.65,75.35 143.65,75.04 143.55,74.94 143.22,74.94 143.12,74.84 143.12,74.54 143.22,74.43 143.55,74.43 143.65,74.33 143.65,74.03 143.55,73.93 143.22,73.93 143.12,73.82 143.12,73.52 143.22,73.42 143.55,73.42 143.65,73.32 143.65,73.01 143.55,72.91 143.22,72.91 143.12,72.81 143.12,72.5 143.22,72.4 143.55,72.4 143.65,72.3 143.65,71.91 143.52,71.78 143.04,71.78 142.92,71.65 142.92,70.68 142.79,70.55 142.48,70.55 142.35,70.42 142.35,70.18 142.48,70.05 142.79,70.05 142.92,69.93 142.92,69.66 142.79,69.53 142.31,69.53 142.18,69.41 142.18,64.4 141.69,63.91 141.69,60.76 141.28,60.35 141.28,27.01 142.16,26.13 142.16,24.21 142.45,23.91 142.45,22.86 v2(142.87,22.45)
  BOTTOM w0.089: v2(143.73,79.92) 144.2,80.39 JCPU1.AJ2
  BOTTOM w0.102: v2(142.87,22.45) 143.3,22.88 JDIMM2.69
DDR_B_D28: length 65.9
  IN1 w0.089: 139.44,77.36 139.44,77.63 140.03,78.22 140.04,78.22 v2(140.73,78.92)
  IN1 w0.102: v2(140.2,20.92) 139.11,22.01 139.11,25.52 138.49,26.14 138.49,26.7 137.94,27.25 137.94,40.79 138.21,41.06 138.21,44.07 138.72,44.57 138.72,60.19 137.94,60.96 137.94,62.51 138.04,62.61 138.22,62.61 138.35,62.74 138.35,62.99 138.22,63.12 138.04,63.12 137.94,63.22 137.94,63.53 138.04,63.63 138.21,63.63 138.34,63.76 138.34,64.01 138.21,64.14 138.04,64.14 137.94,64.24 137.94,68.67 138.72,69.44 138.72,71.49 139.44,72.22 139.44,77.36
  BOTTOM w0.089: JCPU1.AM1 141.2,79.39 v2(140.73,78.92)
  BOTTOM w0.102: JDIMM2.56 139.4,20.12 v2(140.2,20.92)
DDR_B_D29: length 64.4
  IN1 w0.089: 139.14,77.36 139.14,77.66 139.73,78.26 139.73,78.92 v2(139.73,78.92)
  IN1 w0.102: v2(140.2,19.4) 138.81,20.79 138.81,25.39 138.19,26.01 138.19,26.58 137.64,27.12 137.64,41.03 137.9,41.3 137.9,44.19 138.41,44.7 138.41,60.06 137.64,60.83 137.64,68.8 138.41,69.57 138.41,71.62 139.14,72.34 139.14,77.36
  BOTTOM w0.089: JCPU1.AN1 139.73,78.98 v2(139.73,78.92)
  BOTTOM w0.102: JDIMM2.58 140,19.2 v2(140.2,19.4)
DDR_B_D30: length 68.1
  IN1 w0.089: v2(142.73,79.92) 143.14,79.51 143.14,78.56 142.81,78.23 142.81,77.36
  IN1 w0.102: 142.81,77.36 142.81,72.04 142.38,71.61 142.38,70.94 142.25,70.81 141.5,70.81 141.37,70.69 141.37,68.87 141.5,68.74 141.7,68.74 141.83,68.62 141.83,68.24 141.71,68.12 141.47,68.12 141.37,68.02 141.37,67.64 141.5,67.51 141.7,67.51 141.83,67.39 141.83,67.11 141.7,66.98 141.5,66.98 141.37,66.85 141.37,66.45 141.5,66.32 141.7,66.32 141.83,66.19 141.83,65.84 141.7,65.71 141.5,65.71 141.37,65.58 141.37,65.28 141.5,65.15 141.75,65.15 141.88,65.02 141.88,64.67 141.75,64.54 141.5,64.54 141.37,64.41 141.37,60.89 140.98,60.5 140.98,26.88 141.85,26.01 141.85,24.08 142.15,23.79 142.15,22.74 142.44,22.44 142.44,21.35 v2(142.87,20.92)
  BOTTOM w0.089: v2(142.73,79.92) 143.2,80.39 JCPU1.AK2
  BOTTOM w0.102: v2(142.87,20.92) 142.35,20.4 142.35,19.34 143,18.69 JDIMM2.68
DDR_B_D31: length 66.8
  IN1 w0.089: v2(142.73,78.92) 142.73,78.47 142.51,78.25 142.51,77.36
  IN1 w0.102: v2(142.87,19.4) 142.66,19.4 142.06,20 142.06,22.39 141.84,22.61 141.84,23.66 141.55,23.96 141.55,25.88 140.67,26.75 140.67,60.63 141.07,61.02 141.07,70.83 141.88,71.64 141.88,73.29 141.98,73.39 142.41,73.39 142.51,73.49 142.51,73.79 142.41,73.89 141.98,73.89 141.88,74 141.88,74.3 141.98,74.4 142.41,74.4 142.51,74.5 142.51,74.81 142.41,74.91 141.98,74.91 141.88,75.01 141.88,75.32 141.98,75.42 142.41,75.42 142.51,75.52 142.51,75.83 142.41,75.93 142.2,75.93 142.07,76.05 142.07,76.31 142.2,76.43 142.41,76.43 142.51,76.54 142.51,77.36
  BOTTOM w0.089: JCPU1.AK1 143.2,79.39 v2(142.73,78.92)
  BOTTOM w0.102: JDIMM2.70 143.6,18.67 v2(142.87,19.4)
DDR_B_D32: length 68.4
  IN1 w0.089: 162.14,77.36 161.5,77.99 161.26,77.99 160.75,78.5 160.63,78.5 160.26,78.87 160.26,80.02 160.55,80.32 161.99,80.32 162.39,79.92 v2(162.73,79.92)
  IN1 w0.102: v2(164.94,23.05) 164.81,23.05 164.43,23.43 164.43,26.36 165.15,27.08 165.15,28.5 165.27,28.63 165.71,28.63 165.84,28.75 165.84,28.95 165.71,29.08 165.27,29.08 165.15,29.21 165.15,36.84 165.27,36.97 165.4,36.97 165.53,37.1 165.53,46.5 163.66,48.37 163.66,75.83 162.14,77.36
  BOTTOM w0.089: v2(162.73,79.92) JCPU1.L2
  BOTTOM w0.102: JDIMM2.129 163.7,24.29 v2(164.94,23.05)
DDR_B_D33: length 68
  IN1 w0.089: v2(161.73,79.92) 161.26,79.92 161.13,79.79 161.13,78.46 161.35,78.24 161.68,78.24 162.57,77.36
  IN1 w0.102: v2(164.94,24.57) 164.86,24.57 164.73,24.7 164.73,25.36 164.86,25.49 165.18,25.49 165.31,25.36 165.31,25.11 165.44,24.98 165.77,24.98 165.9,25.11 165.9,26.02 165.77,26.15 165.48,26.15 165.35,26.28 165.35,26.85 165.48,26.98 166.01,26.98 166.14,27.11 166.14,27.71 166.01,27.84 165.6,27.84 165.48,27.97 165.48,28.19 165.6,28.32 166.01,28.32 166.14,28.45 166.14,30.04 166.01,30.16 165.6,30.16 165.48,30.29 165.48,30.63 165.6,30.76 166.01,30.76 166.14,30.89 166.14,31.17 166.01,31.29 165.59,31.29 165.46,31.42 165.46,31.76 165.59,31.88 166.04,31.88 166.14,31.99 166.14,35.76 166.06,35.83 165.55,35.83 165.48,35.91 165.48,36.41 165.6,36.54 166.01,36.54 166.14,36.66 166.14,36.9 165.86,37.18 165.86,46.6 163.97,48.49 163.97,75.96 162.57,77.36
  BOTTOM w0.089: v2(161.73,79.92) JCPU1.M2
  BOTTOM w0.102: JDIMM2.131 164.3,25.22 v2(164.94,24.57)
DDR_B_D34: length 71.3
  IN1 w0.089: 165.6,77.36 164.82,78.14 164.82,78.3 164.32,78.79 164.32,81.16 163.98,81.51 162.85,81.51 162.73,81.63 v2(162.73,81.92)
  IN1 w0.102: v2(167.76,23.05) 168.29,23.58 168.29,25.89 168.67,26.27 168.67,27.53 168.79,27.66 169.24,27.66 169.37,27.79 169.37,28.87 169.24,28.99 168.79,28.99 168.67,29.12 168.67,29.68 168.79,29.81 169.24,29.81 169.37,29.93 169.37,32.58 169.24,32.71 168.79,32.71 168.67,32.84 168.67,35.72 168.79,35.85 169.24,35.85 169.37,35.98 169.37,37.01 169.24,37.13 168.79,37.13 168.67,37.26 168.67,37.7 169.37,38.4 169.37,40.44 168.52,41.28 168.52,43.9 168.63,44.01 169.19,44.01 169.37,44.19 169.37,46.17 166.11,49.42 166.11,76.85 165.6,77.36
  BOTTOM w0.089: v2(162.73,81.92) JCPU1.L4
  BOTTOM w0.102: JDIMM2.141 167.3,23.51 v2(167.76,23.05)
DDR_B_D35: length 71
  IN1 w0.089: 165.17,77.36 164.46,78.07 164.46,78.38 164.13,78.71 164.13,81.09 163.9,81.32 162.68,81.32 162.33,81.67 162.33,82.11 162.2,82.23 161.86,82.23 161.73,82.11 v2(161.73,81.92)
  IN1 w0.102: v2(167.76,24.57) 167.99,24.8 167.99,25.02 167.9,25.11 167.84,25.11 167.74,25.21 167.74,25.77 168.36,26.39 168.36,27.95 168.49,28.08 168.93,28.08 169.06,28.21 169.06,28.56 168.93,28.69 168.49,28.69 168.36,28.82 168.36,30.68 168.46,30.78 168.96,30.78 169.06,30.88 169.06,31.18 168.96,31.29 168.46,31.29 168.36,31.39 168.36,31.69 168.46,31.79 168.96,31.79 169.06,31.9 169.06,32.2 168.96,32.3 168.46,32.3 168.36,32.4 168.36,36.09 168.49,36.22 168.93,36.22 169.06,36.35 169.06,36.7 168.93,36.83 168.49,36.83 168.36,36.96 168.36,37.83 168.44,37.9 168.44,38.58 168.56,38.71 168.95,38.71 169.06,38.82 169.06,40.31 168.22,41.16 168.22,44.18 168.35,44.31 168.93,44.31 169.06,44.44 169.06,46.04 168.48,46.62 168.09,46.62 167.96,46.75 167.96,47.14 165.81,49.3 165.81,76.72 165.17,77.36
  BOTTOM w0.089: v2(161.73,81.92) JCPU1.M4
  BOTTOM w0.102: JDIMM2.143 167.9,24.71 v2(167.76,24.57)
DDR_B_D36: length 67.3
  IN1 w0.089: 163,77.36 161.86,78.5 161.54,78.5 161.32,78.71 161.32,79.24 161.53,79.44 162.44,79.44 162.73,79.15 v2(162.73,78.92)
  IN1 w0.102: 163,77.36 164.27,76.08 164.27,48.62 166.26,46.63 166.26,37.24 166.47,37.03 166.47,26.86 166.2,26.59 166.2,24.93 165.35,24.08 165.35,21.93 v2(164.94,21.52)
  BOTTOM w0.089: v2(162.73,78.92) JCPU1.L1
  BOTTOM w0.102: JDIMM2.130 164,20.58 v2(164.94,21.52)
DDR_B_D37: length 66.6
  IN1 w0.089: v2(161.73,78.92) 161.87,78.92 163.43,77.36
  IN1 w0.102: v2(164.94,20) 166,20 166.12,20.13 166.12,20.5 166,20.62 165.55,20.62 165.43,20.75 165.43,21.11 165.55,21.23 165.9,21.23 166.05,21.39 166.05,24.35 166.51,24.8 166.51,26.4 166.8,26.7 166.8,37.17 166.65,37.32 166.65,46.68 164.57,48.75 164.57,76.21 163.43,77.36
  BOTTOM w0.089: v2(161.73,78.92) JCPU1.M1
  BOTTOM w0.102: JDIMM2.132 164.6,18.87 164.51,18.96 164.51,19.57 v2(164.94,20)
DDR_B_D38: length 71.8
  IN1 w0.089: 166.19,77.36 165.13,78.41 165.13,81.09 164.9,81.32 164.49,81.32 164.13,81.67 164.13,82.09 163.9,82.32 163.17,82.32 162.73,82.75 v2(162.73,82.92)
  IN1 w0.102: 166.19,77.36 166.42,77.13 166.42,49.55 169.67,46.29 169.67,27.32 169.16,26.81 169.16,26.29 168.59,25.72 168.59,22.63 168.47,22.5 168.29,22.5 168.17,22.38 168.17,22.11 168.29,21.98 168.47,21.98 168.59,21.86 168.59,21.42 168.42,21.25 168.04,21.25 v2(167.76,21.52)
  BOTTOM w0.089: v2(162.73,82.92) JCPU1.L5
  BOTTOM w0.102: JDIMM2.140 167,20.76 v2(167.76,21.52)
DDR_B_D39: length 72.6
  IN1 w0.089: 166.72,77.36 166.72,77.46 166.58,77.6 166.52,77.6 165.32,78.8 165.32,81.16 164.98,81.51 164.57,81.51 164.32,81.75 164.32,82.16 163.98,82.51 163.37,82.51 163.22,82.66 163.22,83.17 162.97,83.41 161.96,83.41 161.73,83.19 v2(161.73,82.92)
  IN1 w0.102: v2(167.76,20) 168.9,21.14 168.9,25.59 169.49,26.18 169.49,26.71 169.98,27.2 169.98,46.42 166.72,49.68 166.72,77.36
  BOTTOM w0.089: v2(161.73,82.92) JCPU1.M5
  BOTTOM w0.102: v2(167.76,20) 167.33,19.57 167.33,19.08 167.6,18.81 JDIMM2.142
DDR_B_D40: length 78.1
  IN1 w0.089: 168.16,77.36 168.16,78.72 167.32,79.55 167.32,84.33 v2(166.73,84.92)
  IN1 w0.102: 168.16,77.36 168.16,51.51 170.57,49.1 170.57,48.91 170.28,48.61 170.28,48.33 170.64,47.97 170.78,47.97 171.21,48.39 171.39,48.39 171.57,48.21 171.57,48.03 171.14,47.61 171.14,47.46 172.17,46.44 172.17,31.08 172.04,30.95 171.53,30.95 171.4,30.82 171.4,30.42 171.5,30.31 172.09,30.31 172.19,30.21 172.19,29.91 172.09,29.81 171.5,29.81 171.4,29.71 171.4,29.4 171.5,29.3 172.02,29.3 172.14,29.17 172.14,28.92 172.02,28.79 171.5,28.79 171.4,28.69 171.4,28.38 171.5,28.28 172.51,28.28 172.64,28.16 172.64,27.9 172.51,27.77 171.55,27.77 171.42,27.65 171.42,27.36 171.55,27.23 171.75,27.23 171.88,27.1 171.88,26.56 171.75,26.43 171.24,26.43 171.01,26.2 171.01,23.04 v2(170.3,22.33)
  BOTTOM w0.089: v2(166.73,84.92) JCPU1.G7
  BOTTOM w0.102: v2(170.3,22.33) 169.1,23.53 JDIMM2.147
DDR_B_D41: length 78.3
  IN1 w0.089: v2(164.73,86.92) 165.33,86.32 165.33,85.49 165.46,85.36 165.95,85.36 166.33,84.98 166.33,84.77 166.82,84.28 166.86,84.28 167.13,84.01 167.13,78.94 167.84,78.23 167.84,77.36
  IN1 w0.102: v2(170.3,23.85) 170.71,24.26 170.71,26.35 171.09,26.73 171.09,31.25 171.22,31.38 171.73,31.38 171.86,31.51 171.86,31.9 171.76,32 171.19,32 171.09,32.1 171.09,32.4 171.19,32.51 171.76,32.51 171.86,32.61 171.86,36.42 171.73,36.55 171.22,36.55 171.09,36.68 171.09,37.05 171.21,37.17 171.76,37.17 171.86,37.27 171.86,37.59 171.73,37.72 171.22,37.72 171.09,37.85 171.09,38.15 171.22,38.28 171.73,38.28 171.86,38.4 171.86,38.72 171.73,38.85 171.22,38.85 171.09,38.98 171.09,39.4 171.22,39.52 171.73,39.52 171.86,39.65 171.86,46.04 171.59,46.32 171.22,46.32 171.09,46.44 171.09,47.08 169.76,48.41 169.76,48.55 170.12,48.91 170.12,49.05 169.9,49.27 169.76,49.27 169.4,48.91 169.26,48.91 169.05,49.13 169.05,49.27 169.4,49.63 169.4,49.77 169.19,49.99 169.04,49.99 168.69,49.63 168.54,49.63 168.35,49.83 168.35,50.03 168.64,50.32 168.64,50.52 167.84,51.32 167.84,77.36
  BOTTOM w0.089: v2(164.73,86.92) 164.26,86.45 JCPU1.J8
  BOTTOM w0.102: JDIMM2.149 169.7,24.45 v2(170.3,23.85)
DDR_B_D42: length 78.2
  IN1 w0.089: 169.39,77.36 169.39,79.26 169.13,79.51 169.13,85.09 168.9,85.32 168.44,85.32 168.13,85.62 168.13,86.09 167.9,86.32 167.44,86.32 166.84,86.92 v2(166.73,86.92)
  IN1 w0.102: 169.39,77.36 169.39,52.83 169.54,52.68 169.54,52.49 169.39,52.34 169.39,52.21 169.75,51.85 169.89,51.85 170.07,52.03 170.22,52.03 170.43,51.81 170.43,51.67 170.25,51.49 170.25,51.35 170.47,51.13 170.61,51.13 170.79,51.31 170.93,51.31 171.15,51.1 171.15,50.95 170.97,50.77 170.97,50.63 171.19,50.41 171.33,50.41 171.51,50.59 171.65,50.59 171.87,50.38 171.87,50.23 171.69,50.05 171.69,49.91 173.42,48.17 173.42,46.29 173.55,46.16 173.84,46.16 173.97,46.03 173.97,36.75 173.84,36.63 173.55,36.63 173.42,36.5 173.42,36.09 173.55,35.97 173.84,35.97 173.97,35.84 173.97,32.83 173.84,32.71 173.55,32.71 173.42,32.58 173.42,29.94 173.55,29.81 173.84,29.81 173.97,29.68 173.97,27.18 173.16,26.37 173.16,25.12 173.06,25.02 172.67,25.02 172.4,24.75 172.4,22.44 172.51,22.33 v2(172.84,22.33)
  BOTTOM w0.089: v2(166.73,86.92) 166.26,86.45 JCPU1.G8
  BOTTOM w0.102: v2(172.84,22.33) 172.1,23.07 JDIMM2.157
DDR_B_D43: length 78.1
  IN1 w0.089: v2(166.73,87.92) 166.73,87.56 167.13,87.16 167.13,86.89 167.52,86.51 167.98,86.51 168.32,86.16 168.32,85.7 168.52,85.51 168.98,85.51 169.32,85.16 169.32,79.59 169.69,79.22 169.69,77.36
  IN1 w0.102: v2(172.84,23.85) 172.84,23.6 172.97,23.48 173.43,23.48 173.55,23.6 173.55,26.33 174.27,27.06 174.27,30.25 174.15,30.38 173.86,30.38 173.73,30.51 173.73,30.92 173.86,31.05 174.15,31.05 174.27,31.18 174.27,31.61 174.15,31.74 173.86,31.74 173.73,31.86 173.73,32.2 173.83,32.3 174.17,32.3 174.27,32.4 174.27,46.58 174.17,46.68 173.83,46.68 173.73,46.79 173.73,47.09 173.83,47.19 174.17,47.19 174.27,47.29 174.27,47.6 174.17,47.7 173.83,47.7 173.73,47.8 173.73,48.4 172.96,49.17 172.96,49.31 173.3,49.65 173.3,49.83 173.12,50.01 172.94,50.01 172.6,49.67 172.46,49.67 172.24,49.89 172.24,50.03 172.61,50.4 172.61,50.55 172.19,50.97 172.05,50.97 171.95,50.87 171.81,50.87 171.59,51.09 171.59,51.23 171.69,51.33 171.69,51.47 171.47,51.69 171.33,51.69 171.23,51.59 171.09,51.59 170.87,51.8 170.87,51.95 170.97,52.05 170.97,52.19 170.75,52.41 170.61,52.41 170.51,52.31 170.37,52.31 170.15,52.52 170.15,52.67 170.25,52.76 170.25,52.91 169.69,53.47 169.69,77.36
  BOTTOM w0.089: v2(166.73,87.92) 166.26,87.45 JCPU1.G9
  BOTTOM w0.102: v2(172.84,23.85) 172.42,24.27 172.42,25.01 172.7,25.28 JDIMM2.159
DDR_B_D44: length 77.8
  IN1 w0.089: v2(164.73,85.92) 164.73,85.4 164.83,85.31 165.13,85.31 165.25,85.19 165.25,84.45 165.38,84.33 166.21,84.33 166.33,84.2 166.33,78.72 166.91,78.14 167.34,78.14 167.53,77.95 167.53,77.36
  IN1 w0.102: 167.53,77.36 167.53,50.11 170.79,46.86 170.79,46.14 170.92,46.01 171.43,46.01 171.56,45.88 171.56,41.03 171.43,40.91 170.92,40.91 170.79,40.78 170.79,40.51 170.92,40.39 171.43,40.39 171.56,40.26 171.56,39.98 171.43,39.85 170.92,39.85 170.79,39.73 170.79,36.31 170.92,36.19 171.43,36.19 171.56,36.06 171.56,33.04 171.43,32.91 170.92,32.91 170.79,32.79 170.79,26.86 170.31,26.38 170.31,25.85 169.71,25.25 169.71,20.69 169.84,20.56 170.04,20.56 170.28,20.8 v2(170.3,20.8)
  BOTTOM w0.089: JCPU1.J7 164.26,85.45 v2(164.73,85.92)
  BOTTOM w0.102: v2(170.3,20.8) 168.8,19.3 JDIMM2.146
DDR_B_D45: length 77.8
  IN1 w0.089: 167.23,77.36 167.23,77.48 166.14,78.57 166.14,83.16 165.98,83.32 165.66,83.32 165.24,83.74 165.24,84.05 164.83,84.47 164.51,84.47 164.29,84.69 164.29,87.48 v2(164.73,87.92)
  IN1 w0.102: 167.23,77.36 167.23,49.89 170.48,46.63 170.48,45.83 170.61,45.71 171.13,45.71 171.25,45.58 171.25,45.25 171.13,45.12 170.61,45.12 170.48,45 170.48,44.74 170.61,44.61 171.13,44.61 171.25,44.49 171.25,44.2 171.13,44.07 170.61,44.07 170.48,43.94 170.48,26.98 170,26.5 170,25.97 169.41,25.38 169.41,20.17 v2(170.3,19.28)
  BOTTOM w0.089: v2(164.73,87.92) 164.26,87.45 JCPU1.J9
  BOTTOM w0.102: JDIMM2.148 169.4,18.87 169.81,19.28 v2(170.3,19.28)
DDR_B_D46: length 78.3
  IN1 w0.089: v2(166.73,88.92) 167.33,88.32 167.33,87.75 167.58,87.51 168.02,87.51 168.32,87.21 168.32,86.7 168.52,86.51 168.98,86.51 169.32,86.16 169.32,85.7 169.52,85.51 169.98,85.51 170.32,85.16 170.32,79.16 170.3,79.14 170.3,77.36
  IN1 w0.102: 170.3,77.36 170.3,53.76 174.05,50.01 174.05,49.08 174.88,48.25 174.88,26.73 174.16,26.01 174.16,20.82 174.03,20.69 173.8,20.69 173.67,20.56 173.67,20.23 173.8,20.1 174.02,20.1 174.15,19.98 174.15,19.41 174.02,19.28 v2(172.84,19.28)
  BOTTOM w0.089: JCPU1.G10 166.26,88.45 v2(166.73,88.92)
  BOTTOM w0.102: JDIMM2.158 172.4,18.84 v2(172.84,19.28)
DDR_B_D47: length 78.6
  IN1 w0.089: v2(164.73,88.92) 165.25,88.41 166.78,88.41 167.14,88.04 167.14,87.67 167.5,87.32 167.86,87.32 168.13,87.05 168.13,86.62 168.44,86.32 168.86,86.32 169.13,86.05 169.13,85.62 169.44,85.32 169.86,85.32 170.13,85.05 170.13,79.52 170,79.38 170,77.36
  IN1 w0.102: v2(172.84,20.8) 173.86,21.82 173.86,26.17 174.58,26.89 174.58,48.01 173.69,48.89 173.69,49.94 170,53.63 170,77.36
  BOTTOM w0.089: JCPU1.J10 164.26,88.45 v2(164.73,88.92)
  BOTTOM w0.102: v2(172.84,20.8) 173.3,20.35 173.3,19.16 173,18.86 JDIMM2.160
DDR_B_D48: length 79.1
  IN1 w0.089: 171.73,77.36 171.73,78.26 172.32,78.86 172.32,86.51 v2(172.73,86.92)
  IN1 w0.102: 171.73,77.36 171.73,55.01 172.09,54.65 172.23,54.65 172.36,54.78 172.5,54.78 172.72,54.57 172.72,54.42 172.59,54.29 172.59,54.15 172.8,53.93 172.95,53.93 173.08,54.06 173.22,54.06 173.44,53.85 173.44,53.7 173.31,53.57 173.31,53.43 173.52,53.21 173.67,53.21 173.74,53.28 173.92,53.28 174.1,53.1 174.1,52.92 174.03,52.85 174.03,52.71 176.97,49.76 176.97,38.54 177.1,38.42 177.25,38.42 177.38,38.29 177.38,38.04 177.25,37.91 177.1,37.91 176.97,37.78 176.97,37.5 177.07,37.39 177.54,37.39 177.62,37.31 177.62,37.01 177.5,36.89 177.07,36.89 176.97,36.78 176.97,32.75 177.07,32.65 177.47,32.65 177.59,32.52 177.59,32.27 177.47,32.14 177.07,32.14 176.97,32.04 176.97,31.7 177.1,31.57 177.49,31.57 177.62,31.44 177.62,31.11 177.49,30.99 177.16,30.99 177.03,30.86 177.03,30.45 177.16,30.33 177.49,30.33 177.62,30.2 177.62,29.88 177.49,29.76 177.1,29.76 176.97,29.63 176.97,29.07 177.1,28.94 177.49,28.94 177.62,28.82 177.62,27.38 176.96,26.72 176.45,26.72 176.31,26.58 176.31,26.07 175.88,25.64 175.88,22.93 175.75,22.8 175.51,22.8 175.38,22.93 v2(175.38,23.17)
  BOTTOM w0.089: JCPU1.A8 172.26,86.45 v2(172.73,86.92)
  BOTTOM w0.102: v2(175.38,23.17) 173.9,24.66 JDIMM2.163
DDR_B_D49: length 80.7
  IN1 w0.089: 171.42,77.36 171.42,78.31 172.13,79.02 172.13,86.6 171.81,86.92 v2(171.73,86.92)
  IN1 w0.102: 171.42,77.36 171.42,54.88 172.84,53.46 172.84,53.32 172.67,53.15 172.67,53.01 172.88,52.79 173.03,52.79 173.2,52.96 173.34,52.96 173.56,52.75 173.56,52.6 173.39,52.43 173.39,52.29 173.6,52.07 173.75,52.07 173.92,52.24 174.06,52.24 174.28,52.03 174.28,51.88 174.11,51.71 174.11,51.57 174.32,51.35 174.46,51.35 174.64,51.52 174.78,51.52 175,51.31 175,51.16 174.82,50.99 174.82,50.85 175.04,50.63 175.18,50.63 175.35,50.8 175.5,50.8 175.69,50.61 175.69,50.46 175.26,50.03 175.26,49.85 175.6,49.51 175.78,49.51 176.23,49.96 176.34,49.96 176.59,49.72 176.59,49.54 176.37,49.33 176.37,49.14 176.67,48.84 176.67,38.6 176.56,38.49 176.12,38.49 176.02,38.39 176.02,38.09 176.12,37.99 176.56,37.99 176.67,37.88 176.67,36.52 176.56,36.42 176.13,36.42 176.03,36.31 176.03,36.01 176.13,35.91 176.56,35.91 176.67,35.81 176.67,32.71 176.56,32.61 176.13,32.61 176.03,32.5 176.03,32.2 176.13,32.1 176.56,32.1 176.67,32 176.67,31.69 176.56,31.59 176.13,31.59 176.03,31.49 176.03,31.18 176.13,31.08 176.56,31.08 176.67,30.98 176.67,30.68 176.56,30.57 176.13,30.57 176.03,30.47 176.03,30.17 176.13,30.07 176.56,30.07 176.67,29.96 176.67,28.99 176.54,28.87 176.13,28.87 176,28.74 176,28.44 176.13,28.31 177,28.31 177.12,28.18 177.12,27.33 177,27.2 176.68,27.2 176.55,27.33 176.55,27.63 176.42,27.76 176.13,27.76 176,27.63 176,26.2 175.38,25.58 v2(175.38,24.7)
  BOTTOM w0.089: v2(171.73,86.92) 171.26,86.45 JCPU1.B8
  BOTTOM w0.102: JDIMM2.165 174.5,25.22 175.02,24.7 v2(175.38,24.7)
DDR_B_D50: length 79.8
  IN1 w0.089: 173.47,87.71 173.26,87.92 v2(172.73,87.92)
  IN1 w0.102: 173.47,87.71 173.98,87.2 173.98,78.48 172.96,77.46 172.96,56.13 175.96,53.13 175.96,52.99 175.82,52.85 175.82,52.71 176.04,52.49 176.18,52.49 176.32,52.63 176.46,52.63 176.68,52.41 176.68,52.27 176.54,52.13 176.54,51.99 176.76,51.77 176.9,51.77 177.04,51.91 177.18,51.91 177.4,51.69 177.4,51.55 177.26,51.41 177.26,51.27 177.47,51.05 177.62,51.05 177.76,51.19 177.9,51.19 178.33,50.76 178.33,49.89 178.46,49.76 178.54,49.76 178.67,49.63 178.67,49.32 178.54,49.19 178.33,49.19 178.2,49.07 178.2,48.81 178.33,48.69 179.13,48.69 179.23,48.58 179.23,48.28 179.13,48.18 178.33,48.18 178.2,48.05 178.2,47.8 178.33,47.67 179.13,47.67 179.23,47.57 179.23,47.26 179.13,47.16 178.34,47.16 178.21,47.03 178.21,46.78 178.34,46.65 179.13,46.65 179.23,46.55 179.23,39.09 178.87,38.73 178.87,26.89 177.52,25.54 177.52,23.95 v2(178.3,23.17)
  BOTTOM w0.089: JCPU1.A9 172.26,87.45 v2(172.73,87.92)
  BOTTOM w0.102: v2(178.3,23.17) 177.5,23.98 JDIMM2.175
DDR_B_D51: length 81.1
  IN1 w0.089: 173.47,88.2 173.36,88.32 172.13,88.32 v2(171.73,87.92)
  IN1 w0.102: 173.47,88.2 174.31,87.37 174.31,78.38 173.26,77.33 173.26,57.15 173.68,56.72 173.68,56.56 173.41,56.29 173.41,56.11 173.68,55.84 173.86,55.84 174.31,56.3 174.49,56.3 174.67,56.12 174.67,55.94 174.22,55.48 174.22,55.3 174.4,55.12 174.58,55.12 175.03,55.58 175.21,55.58 175.39,55.4 175.39,55.22 174.94,54.76 174.94,54.58 175.12,54.4 175.3,54.4 175.71,54.82 175.89,54.82 176.07,54.64 176.07,54.46 175.66,54.05 175.66,53.87 175.98,53.54 176.16,53.54 176.42,53.81 176.6,53.81 176.78,53.63 176.78,53.45 176.52,53.18 176.52,53 176.7,52.82 176.88,52.82 177.14,53.09 177.32,53.09 177.5,52.91 177.5,52.73 177.24,52.46 177.24,52.28 177.42,52.1 177.6,52.1 177.86,52.37 178.04,52.37 178.22,52.19 178.22,52.01 178.01,51.8 178.01,51.65 178.96,50.7 178.96,50.41 179.09,50.29 179.38,50.29 179.56,50.1 179.56,49.76 179.43,49.63 179.1,49.63 178.98,49.5 178.98,49.19 179.1,49.06 179.43,49.06 179.56,48.93 179.56,38.75 179.2,38.39 179.2,26.79 178.72,26.31 178.72,25.96 178.59,25.83 178.25,25.83 178.13,25.7 178.13,25.36 178.25,25.23 178.59,25.23 178.72,25.11 178.72,24.82 178.6,24.7 v2(178.3,24.7)
  BOTTOM w0.089: JCPU1.B9 171.26,87.45 v2(171.73,87.92)
  BOTTOM w0.102: JDIMM2.177 178.1,24.9 v2(178.3,24.7)
DDR_B_D52: length 81.9
  IN1 w0.089: 171.12,77.36 171.12,78.73 171.32,78.94 171.32,85.2 171.01,85.51 170.52,85.51 170.32,85.7 170.32,86.33 v2(169.73,86.92)
  IN1 w0.102: v2(175.38,21.65) 175.16,21.65 174.97,21.83 174.97,25.67 175.7,26.39 175.7,39.18 175.8,39.28 176.23,39.28 176.36,39.41 176.36,39.66 176.23,39.79 175.8,39.79 175.7,39.89 175.7,40.2 175.8,40.3 176.22,40.3 176.35,40.42 176.35,40.68 176.22,40.81 175.8,40.81 175.7,40.91 175.7,44.09 175.8,44.19 176.25,44.19 176.35,44.29 176.35,44.59 176.25,44.7 175.8,44.7 175.7,44.8 175.7,45.1 175.8,45.2 176.25,45.2 176.35,45.31 176.35,45.61 176.25,45.71 175.8,45.71 175.7,45.81 175.7,46.12 175.8,46.22 176.25,46.22 176.35,46.32 176.35,46.63 176.25,46.73 175.8,46.73 175.7,46.83 175.7,47.13 175.8,47.24 176.25,47.24 176.35,47.34 176.35,47.64 176.25,47.74 175.8,47.74 175.7,47.85 175.7,48.15 175.8,48.25 176.25,48.25 176.35,48.35 176.35,48.66 176.25,48.76 175.8,48.76 174.95,49.61 174.95,50.29 172.16,53.08 172.16,53.22 172.3,53.36 172.3,53.54 172.12,53.72 171.94,53.72 171.8,53.58 171.66,53.58 171.41,53.83 171.41,53.99 171.57,54.15 171.57,54.3 171.12,54.76 171.12,77.36
  BOTTOM w0.089: JCPU1.D8 169.26,86.45 v2(169.73,86.92)
  BOTTOM w0.102: v2(175.38,21.65) 174.2,20.47 JDIMM2.164
DDR_B_D53: length 82
  IN1 w0.089: v2(168.73,86.92) 169.04,86.92 169.55,86.41 169.81,86.41 170.13,86.09 170.13,85.62 170.44,85.32 170.93,85.32 171.13,85.12 171.13,79.32 170.81,78.99 170.81,77.36
  IN1 w0.102: 170.81,77.36 170.81,53.97 174.6,50.18 174.6,49.27 175.39,48.48 175.39,26.52 174.67,25.8 174.67,19.06 174.82,18.91 176.86,18.91 176.98,19.04 176.98,19.39 176.86,19.52 176.22,19.52 176.09,19.65 176.09,19.96 176.22,20.09 176.58,20.09 176.7,20.22 176.7,20.61 176.58,20.74 175.97,20.74 175.73,20.5 175.51,20.5 175.38,20.38 v2(175.38,20.13)
  BOTTOM w0.089: JCPU1.E8 168.26,86.45 v2(168.73,86.92)
  BOTTOM w0.102: JDIMM2.166 174.8,19.55 v2(175.38,20.13)
DDR_B_D54: length 82.7
  IN1 w0.089: v2(169.73,87.92) 170.33,88.52 173.59,88.52
  IN1 w0.102: v2(178.3,21.65) 178.3,21.4 178.43,21.27 178.89,21.27 179.02,21.4 179.02,21.86 178.94,21.94 178.83,21.94 178.74,22.03 178.74,22.81 178.84,22.91 178.94,22.91 179.02,22.99 179.02,23.39 178.95,23.46 178.81,23.46 178.72,23.55 178.72,23.99 178.81,24.08 178.95,24.08 179.02,24.15 179.02,26.18 179.53,26.69 179.53,37.82 179.89,38.18 179.89,50.23 179.46,50.66 179.46,50.8 179.55,50.89 179.55,51.07 179.37,51.25 179.19,51.25 179.1,51.16 178.96,51.16 178.6,51.52 178.6,51.79 178.94,52.14 178.94,52.28 173.57,57.65 173.57,77.2 174.73,78.36 174.73,87.43 173.64,88.52 173.59,88.52
  BOTTOM w0.089: JCPU1.D9 169.26,87.45 v2(169.73,87.92)
  BOTTOM w0.102: JDIMM2.174 177.2,20.55 v2(178.3,21.65)
DDR_B_D55: length 82.4
  IN1 w0.089: v2(168.73,87.92) 168.73,87.93 169.26,88.45 169.26,88.97 169.6,89.32 172.9,89.32 173.32,88.9 173.59,88.9
  IN1 w0.102: v2(178.3,20.13) 178.3,20.25 179.33,21.28 179.33,26.05 179.86,26.59 179.86,37.68 180.22,38.04 180.22,51.43 173.87,57.78 173.87,77 175.06,78.18 175.06,87.53 173.69,88.9 173.59,88.9
  BOTTOM w0.089: v2(168.73,87.92) 168.26,87.45 JCPU1.E9
  BOTTOM w0.102: JDIMM2.176 177.8,19.62 v2(178.3,20.13)
DDR_B_D56: length 92
  IN1 w0.089: 173.59,90.22 173.27,90.22 172.98,90.51 172.43,90.51 172.25,90.69 172.25,91.17 172.08,91.34 171.26,91.34 171.14,91.45 171.14,92.08 170.9,92.32 170.35,92.32 170.13,92.54 170.13,93.09 169.72,93.5 169.58,93.5 169.16,93.92 v2(168.73,93.92)
  IN1 w0.102: 173.59,90.22 174.13,90.22 176.22,88.13 176.22,76.52 176.1,76.39 175.12,76.39 174.99,76.26 174.99,75.89 175.12,75.77 175.57,75.77 175.7,75.64 175.7,75.36 175.57,75.23 175.12,75.23 174.99,75.11 174.99,58.24 181.36,51.87 181.36,44.13 181.49,44.01 181.79,44.01 181.92,43.88 181.92,40.91 181.82,40.81 181.49,40.81 181.39,40.7 181.39,40.4 181.49,40.3 181.82,40.3 181.92,40.2 181.92,39.89 181.82,39.79 181.49,39.79 181.39,39.69 181.39,39.38 181.49,39.28 181.82,39.28 181.92,39.18 181.92,38.88 181.82,38.77 181.49,38.77 181.39,38.67 181.39,38.37 181.49,38.27 181.82,38.27 181.92,38.16 181.92,36.44 181.79,36.31 181.54,36.31 181.41,36.18 181.41,26.56 180.97,26.11 180.97,25.72 180.84,25.59 180.57,25.59 180.44,25.46 180.44,25.12 180.57,24.99 180.84,24.99 180.97,24.87 180.97,24.53 180.84,24.4 180.57,24.4 180.44,24.28 180.44,22.21 180.57,22.08 180.72,22.08 180.85,22.21 v2(180.85,22.45)
  BOTTOM w0.089: JCPU1.E15 168.26,93.45 v2(168.73,93.92)
  BOTTOM w0.102: JDIMM2.181 179.3,24.01 v2(180.85,22.45)
DDR_B_D57: length 90.9
  IN1 w0.089: 173.59,90.8 173.44,90.8 172.92,91.32 172.76,91.32 172.55,91.53 171.56,91.53 171.33,91.75 171.33,92.16 170.98,92.52 170.57,92.52 170.32,92.76 170.32,93.17 169.73,93.76 v2(169.73,93.92)
  IN1 w0.102: v2(180.85,23.98) 180.85,23.73 180.98,23.6 181.15,23.6 181.28,23.73 181.28,25.99 181.72,26.43 181.72,27.03 181.84,27.15 182.11,27.15 182.24,27.28 182.24,27.53 182.14,27.63 181.82,27.63 181.72,27.74 181.72,27.94 181.82,28.04 182.14,28.04 182.24,28.14 182.24,28.35 182.14,28.45 181.82,28.45 181.72,28.55 181.72,28.75 181.82,28.85 182.14,28.85 182.24,28.96 182.24,30.03 182.14,30.13 181.82,30.13 181.72,30.24 181.72,30.44 181.82,30.54 182.14,30.54 182.24,30.64 182.24,30.85 182.14,30.95 181.82,30.95 181.72,31.05 181.72,31.25 181.82,31.35 182.14,31.35 182.24,31.46 182.24,31.66 182.14,31.76 181.82,31.76 181.72,31.86 181.72,32.06 181.82,32.17 182.14,32.17 182.24,32.27 182.24,32.47 182.14,32.57 181.82,32.57 181.72,32.67 181.72,32.88 181.82,32.98 182.14,32.98 182.24,33.08 182.24,44.41 182.14,44.52 181.77,44.52 181.67,44.62 181.67,45.13 181.77,45.23 182.14,45.23 182.24,45.33 182.24,45.63 182.14,45.74 181.77,45.74 181.67,45.84 181.67,46.14 181.77,46.24 182.14,46.24 182.24,46.34 182.24,46.65 182.14,46.75 181.77,46.75 181.67,46.85 181.67,47.16 181.77,47.26 182.14,47.26 182.24,47.36 182.24,47.67 182.14,47.77 181.77,47.77 181.67,47.87 181.67,48.17 181.77,48.28 182.11,48.28 182.24,48.4 182.24,48.66 182.11,48.78 181.77,48.78 181.67,48.88 181.67,52 175.29,58.37 175.29,74.18 176.55,75.44 176.55,88.26 174.01,90.8 173.59,90.8
  BOTTOM w0.089: v2(169.73,93.92) 169.26,93.45 JCPU1.D15
  BOTTOM w0.102: JDIMM2.183 179.9,24.93 v2(180.85,23.98)
DDR_B_D58: length 91.4
  IN1 w0.089: v2(172.73,93.92) 173.59,93.92
  IN1 w0.102: 173.59,93.92 173.75,93.92 173.93,93.74 175,93.74 184.41,84.33 184.43,84.25 184.43,79.76 184.41,79.68 182.34,77.61 179.49,77.61 178.6,76.72 178.6,74.06 177.14,72.59 177.14,59.15 184.9,51.38 184.9,28.39 184.08,27.57 184.08,26.19 183.33,25.44 183.33,22.64 183.55,22.43 v2(183.76,22.43)
  BOTTOM w0.089: JCPU1.A15 172.26,93.45 v2(172.73,93.92)
  BOTTOM w0.102: JDIMM2.191 182.3,23.89 v2(183.76,22.43)
DDR_B_D59: length 90.9
  IN1 w0.089: 173.59,94.49 172.3,94.49 v2(171.73,93.92)
  IN1 w0.102: 173.59,94.49 173.66,94.49 174.06,94.08 175.09,94.08 184.72,84.45 184.73,84.37 184.73,79.63 184.72,79.55 182.47,77.3 179.62,77.3 178.91,76.6 178.91,73.94 177.44,72.47 177.44,59.27 185.2,51.51 185.2,27.52 185.08,27.39 184.53,27.39 184.4,27.27 184.4,26.71 184.5,26.6 185.1,26.6 185.2,26.5 185.2,25.43 183.76,23.98 v2(183.76,23.95)
  BOTTOM w0.089: v2(171.73,93.92) 171.26,93.45 JCPU1.B15
  BOTTOM w0.102: v2(183.76,23.95) 182.9,24.82 JDIMM2.193
DDR_B_D60: length 91.8
  IN1 w0.089: v2(168.73,92.92) 169.17,92.48 169.17,90.52 169.38,90.32 172.9,90.32 173.4,89.82 173.59,89.82
  IN1 w0.102: v2(180.85,20.93) 180.85,20.74 180.39,20.28 180.39,19.84 180.26,19.71 179.78,19.71 179.65,19.84 179.65,20.45 180.14,20.94 180.14,25.71 180.68,26.25 180.68,27.01 180.8,27.14 180.95,27.14 181.07,27.27 181.07,27.61 180.95,27.74 180.81,27.74 180.68,27.86 180.68,28.22 180.81,28.35 180.95,28.35 181.06,28.45 181.06,30.34 180.93,30.47 180.8,30.47 180.68,30.59 180.68,30.94 180.8,31.06 180.93,31.06 181.06,31.19 181.06,31.57 180.93,31.7 180.8,31.7 180.68,31.83 180.68,32.24 180.78,32.34 180.95,32.34 181.06,32.45 181.06,35.98 180.93,36.11 180.8,36.11 180.68,36.23 180.68,36.82 180.8,36.94 180.93,36.94 181.06,37.07 181.06,51.75 174.68,58.12 174.68,76.61 174.81,76.73 175.77,76.73 175.89,76.86 175.89,87.99 174.07,89.82 173.59,89.82
  BOTTOM w0.089: JCPU1.E14 168.26,92.45 v2(168.73,92.92)
  BOTTOM w0.102: v2(180.85,20.93) 180.26,20.93 179,19.67 JDIMM2.180
DDR_B_D61: length 90.6
  IN1 w0.089: v2(169.73,92.92) 169.26,93.4 168.5,93.4 168.23,93.13 168.23,89.8 168.52,89.51 173.59,89.51
  IN1 w0.102: 173.59,89.51 173.91,89.51 175.56,87.85 175.56,77.97 174.38,76.79 174.38,57.99 180.73,51.64 180.73,37.37 180.37,37.02 180.37,35.9 180.73,35.54 180.73,32.93 180.37,32.57 180.37,29.93 180.73,29.57 180.73,28.86 180.37,28.5 180.37,26.38 179.83,25.84 179.83,21.06 179.35,20.58 179.35,19.53 179.47,19.41 v2(180.85,19.41)
  BOTTOM w0.089: JCPU1.D14 169.26,92.45 v2(169.73,92.92)
  BOTTOM w0.102: v2(180.85,19.41) 180.07,19.41 179.6,18.94 JDIMM2.182
DDR_B_D62: length 91.2
  IN1 w0.089: 173.59,92.92 v2(172.73,92.92)
  IN1 w0.102: v2(183.76,20.91) 183.03,21.64 183.03,25.57 183.78,26.32 183.78,27.75 184.6,28.57 184.6,51.26 176.83,59.02 176.83,72.72 178.3,74.19 178.3,76.85 179.36,77.91 182.22,77.91 184.11,79.81 184.12,79.89 184.12,83.92 184.11,84 175.19,92.92 173.59,92.92
  BOTTOM w0.089: JCPU1.A14 172.26,92.45 v2(172.73,92.92)
  BOTTOM w0.102: v2(183.76,20.91) 182.6,19.74 JDIMM2.192
DDR_B_D63: length 90.9
  IN1 w0.089: v2(171.73,92.92) 171.98,92.92 172.51,92.39 173.59,92.39
  IN1 w0.102: 173.59,92.39 174.73,92.39 177.84,89.29 177.84,74.57 176.53,73.25 176.53,58.89 184.12,51.3 184.12,47.67 184.29,47.5 184.29,44.59 184.16,44.46 183.6,44.46 183.47,44.34 183.47,41.03 183.6,40.91 184.16,40.91 184.29,40.78 184.29,39 184.16,38.87 183.6,38.87 183.47,38.75 183.47,38.46 183.6,38.33 184.16,38.33 184.29,38.2 184.29,37.76 184.16,37.64 183.6,37.64 183.47,37.51 183.47,36.75 183.6,36.63 184.16,36.63 184.29,36.5 184.29,36.12 184.16,35.99 183.6,35.99 183.47,35.86 183.47,32.83 183.6,32.71 184.16,32.71 184.29,32.58 184.29,30.78 184.16,30.66 183.6,30.66 183.47,30.53 183.47,26.44 182.72,25.69 182.72,19.74 183.08,19.38 v2(183.76,19.38)
  BOTTOM w0.089: JCPU1.B14 171.26,92.45 v2(171.73,92.92)
  BOTTOM w0.102: JDIMM2.194 183.2,18.82 v2(183.76,19.38)
DDR_B_DQS0: length 90.8
  IN1 w0.089: v2(138.73,94.92) 138.73,95.21 138.59,95.35 138.43,95.35 138.34,95.26 138.34,94.53 138.15,94.33 137.58,94.33 137.33,94.09 137.33,93.68 136.98,93.33 136.16,93.33 136.14,93.31 136.08,93.25
  IN1 w0.102: 136.08,93.25 123.43,80.59 123.43,72.38 123.68,72.13 123.68,48.86 123.78,48.76 124.17,48.76 124.39,48.54 124.39,47.95 124.17,47.72 123.6,47.72 123.49,47.61 123.49,47.24 123.62,47.11 124.17,47.11 124.39,46.88 124.39,46.3 124.17,46.07 123.78,46.07 123.1,45.38 123.1,27.05 124.57,25.58 124.57,21.15 124.75,20.97 125.03,20.97 125.14,21.08 v2(125.14,21.27)
  BOTTOM w0.089: v2(138.73,94.92) 139.2,95.39 JCPU1.AP17
  BOTTOM w0.102: JDIMM2.12 126.2,18.78 125.94,19.04 125.94,20.64 125.6,20.98 125.43,20.98 v2(125.14,21.27)
DDR_B_DQS1: length 81.5
  IN1 w0.089: v2(138.73,89.92) 138.73,89.69 138.67,89.63 138.37,89.63 138.13,89.4 138.13,88.75 137.9,88.52 137.38,88.52 137.13,88.28 137.13,87.75 136.9,87.52 136.24,87.52 136,87.27
  IN1 w0.102: 136,87.27 132.7,83.97 132.7,72.38 129.78,69.46 129.78,67.12 129.68,67.02 129.5,67.02 129.24,66.77 129.24,66.23 129.5,65.98 129.55,65.98 129.68,65.85 129.68,65.5 129.55,65.37 129.48,65.37 129.23,65.12 129.23,64.58 129.48,64.33 129.56,64.33 129.69,64.2 129.69,63.85 129.56,63.72 129.45,63.72 129.19,63.47 129.19,62.93 129.45,62.68 129.47,62.68 129.6,62.55 129.6,62.2 129.47,62.07 129.43,62.07 129.18,61.82 129.18,61.28 129.43,61.03 129.59,61.03 129.71,60.9 129.71,60.54 129.59,60.42 129.43,60.42 129.18,60.16 129.18,59.63 129.43,59.38 129.52,59.38 129.65,59.25 129.65,58.89 129.52,58.77 129.47,58.77 129.22,58.51 129.22,57.98 129.47,57.73 129.65,57.73 129.78,57.6 129.78,46.55 128.9,45.68 127.82,44.6 127.82,40.3 129.64,38.49 129.64,26.83 130.34,26.14 130.34,23.3 130.63,23.01 130.76,23.01 v2(130.98,22.79)
  BOTTOM w0.089: JCPU1.AP12 139.2,90.39 v2(138.73,89.92)
  BOTTOM w0.102: JDIMM2.29 131.3,25.17 131.24,25.11 131.24,24.98 131.62,24.6 131.62,23.32 131.38,23.08 131.26,23.08 v2(130.98,22.79)
DDR_B_DQS2: length 71.7
  IN1 w0.089: 136.27,77.36 136.27,79.43 137.14,80.31 137.14,80.39 137.14,81.23 137.43,81.51 137.87,81.51 138.13,81.77 138.13,83.52 138.32,83.71 138.52,83.71 v2(138.73,83.92)
  IN1 w0.102: v2(136.06,22.79) 135.84,23.01 135.67,23.01 135.42,23.27 135.42,25.53 133.99,26.95 133.99,41.21 133.71,41.49 133.71,41.76 133.71,44.78 135.28,46.34 135.28,47.44 135.5,47.67 136.01,47.67 136.14,47.8 136.14,48.15 136.01,48.28 135.53,48.28 135.28,48.53 135.28,49.07 135.53,49.32 135.99,49.32 136.11,49.45 136.11,49.81 135.99,49.93 135.5,49.93 135.28,50.16 135.28,69.6 136.27,70.59 136.27,77.36
  BOTTOM w0.089: JCPU1.AP6 139.2,84.39 v2(138.73,83.92)
  BOTTOM w0.102: JDIMM2.47 136.7,24.81 136.89,24.63 136.89,23.46 136.61,23.18 136.44,23.18 v2(136.06,22.79)
DDR_B_DQS3: length 69
  IN1 w0.089: 141.15,77.36 141.15,77.69 142.14,78.68 142.14,80.18 142.49,80.52 142.92,80.52 142.98,80.58 142.98,80.84 142.89,80.92 v2(142.73,80.92)
  IN1 w0.102: 141.15,77.36 141.15,72.33 139.84,71.01 139.84,68.42 140.06,68.19 140.24,68.19 140.34,68.09 140.34,67.68 140.24,67.58 140.06,67.58 139.84,67.35 139.84,66.62 140.13,66.33 140.13,65.85 139.84,65.56 139.84,60.73 139.94,60.63 139.94,36.92 139.61,36.59 139.61,26.6 140.78,25.43 140.78,21.04 141.01,20.81 141.2,20.81 v2(141.47,20.54)
  BOTTOM w0.089: JCPU1.AK3 143.3,81.35 143.3,81.06 143.16,80.92 v2(142.73,80.92)
  BOTTOM w0.102: v2(141.47,20.54) 141.23,20.78 141.05,20.78 140.99,20.71 140.99,19.55 141.14,19.39 141.31,19.39 141.58,19.13 141.58,19.02 141.8,18.8 JDIMM2.64
